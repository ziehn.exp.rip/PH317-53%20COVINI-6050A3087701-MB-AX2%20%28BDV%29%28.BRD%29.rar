# Allegro board PH317-53 COVINI-6050A3087701-MB-AX2 (BDV)(.BRD).brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
CNV_WT_CLKP_R: length 4.5
  TOP w0.107: v1(290.03,21.79) 290.03,21.76 289.73,21.47 289.73,20.9 289.96,20.68 290.75,20.68 290.99,20.92 R1353.2
  BOTTOM w0.107: v1(290.03,21.79) 289.95,21.79 289.76,21.59 289.76,21.24 289.95,21.05 289.95,21.04 CN1300.73
CNV_WT_D0N_R: length 5.5
  TOP w0.107: R1330.2 290.84,22.69 288.54,22.69 288.1,22.24 288.1,22.01 v3(287.87,21.78)
  BOTTOM w0.107: v3(287.87,21.78) 288.05,21.6 288.05,21.15 287.95,21.05 CN1300.65
CNV_WT_D0P_R: length 5.5
  TOP w0.107: v1(288.53,21.78) 288.3,22.01 288.3,22.16 288.63,22.48 290.62,22.48 290.99,22.12 R1331.2
  BOTTOM w0.107: CN1300.67 288.45,21.05 288.45,21.05 288.26,21.24 288.26,21.52 v1(288.53,21.78)
CNV_WT_D1N_R: length 9
  TOP w0.107: v1(290.32,24.13) 290.32,24.14 290.47,23.99 292.26,23.99 R1367.2
  BOTTOM w0.107: v1(290.32,24.13) 290.32,24.13 290.32,24.14 290.17,23.99 288.83,23.99 286.6,21.76 286.6,21.19 286.45,21.05 CN1300.59
CNV_WT_D1P_R: length 8.9
  TOP w0.107: v3(290.32,23.47) 290.32,23.57 290.52,23.78 292.4,23.78 292.61,23.57 R1368.2
  BOTTOM w0.107: v3(290.32,23.47) 290.32,23.55 290.09,23.78 288.91,23.78 286.8,21.67 286.8,21.19 286.95,21.05 CN1300.61
CORE_PWEN: length 362.2
  TOP w0.102: R37.1 231.49,47.89 231.77,47.6 231.77,45.11 231.39,44.73 230.2,44.73 229.71,44.25 v1(229.64,44.25)
  L3 w0.102: v1(228.22,30.1) 228.11,30 225.17,30 222.91,32.26 222.91,34.14 221.61,35.44 219.38,35.44 218.74,34.8 212.49,34.8 v1(211.25,36.05)
  L5 w0.102: v1(68.4,91.52) 68.4,89.79 68.45,89.74 68.45,85.61 67.99,85.15 67.99,83.99 64.61,80.61 64.61,80.61 63.7,79.7 63.7,77.43 61.84,75.57 60.11,75.57 58.75,74.2 58.75,66.03 64.72,60.06 64.72,55.7 71.8,48.62 74.94,48.62 82.73,40.82 133.17,40.82 133.83,41.48 134.99,41.48 136.11,40.36 153.71,40.36 153.84,40.24 159.58,40.24 v1(159.84,40.49) 160.69,41.34 165.72,41.34 166.92,40.14 171.9,40.14 172.43,39.6 174.88,39.6 175.23,39.96 189.61,39.96 190.35,39.22 197.25,39.22 198.95,37.52 202.38,37.52 203.4,36.5 206.26,36.5 207.1,35.67 210.87,35.67 v1(211.25,36.05) ; v1(278.2,67.06) 279.93,65.33 279.93,63.18 283.22,59.89 283.22,58.91 272.87,48.56 272.87,38.76 267.9,33.79 254.53,33.79 254.12,34.19 246.84,34.19 244.47,31.82 244.47,30.81 243.48,29.82 236.04,29.82 235.34,29.12 229.19,29.12 v1(228.22,30.1)
  L8 w0.102: v1(68.4,91.52) 68.4,97.01 v1(69.14,97.75)
  BOTTOM w0.102: D7004.3 68.24,97.75 v1(69.14,97.75) R7054.1 ; R5001.1 159.84,40.19 v1(159.84,40.49) ; v1(211.25,36.05) 211.68,35.61 211.68,33.73 212.28,33.13 U1.112 216.65,33.13 217.17,32.61 218.31,32.61 218.34,32.58 C301.2 R320.2 ; v1(68.4,91.52) 68.27,91.39 68.27,90.48 68.48,90.28 U7006.2 ; R38.1 278.75,66.44 R7029.1 278.41,66.86 v1(278.2,67.06) ; v1(228.22,30.1) 228.22,29.06 227.58,28.43 226.85,28.43 R7024.2 225.62,28.91 v2(225.21,29.33) 223.72,30.81 223.72,39.55 223.92,39.75 227.61,39.75 229.64,41.79 v1(229.64,44.25)
CORE_PWEN_RC: length 3.4
  BOTTOM w0.102: R7024.1 227.22,29.59 v2(227.4,29.77) 227.43,29.8 227.43,30 228.3,30.87 U2.5
CPU2PCH_TRIGGER: length 165.8
  TOP w0.102: v3(252.01,68.27) 252.01,68.28 251.33,68.28 250.39,69.22 235.78,69.22 231.39,64.83 221.43,64.83 220.95,65.31 220.95,65.31 214.39,71.87 164.57,71.87 162.82,70.12 155.96,70.12 151.08,75.01 151.08,76.17 151.08,76.17 151.08,78.66 148.33,81.41 147.18,81.41 136.01,92.58 v1(136.01,119.21)
  BOTTOM w0.089: U4710.AK2 251.59,64.7 251.53,64.75 251.53,66.41
  BOTTOM w0.102: 251.53,66.41 251.53,66.66 251.53,66.81 251.6,66.88 251.6,67.38 252.01,67.79 v3(252.01,68.27) ; v1(136.01,119.21) 135.48,119.74 R4840.1
CPU_C10_PWR_GATE#: length 265.7
  L8 w0.102: v1(65.71,91.04) 65.33,91.04 64.44,90.15 64.44,88.62 63.47,87.66 63.47,83.37 62.1,82 62.1,66 71.3,56.8 87.7,56.8 89.16,55.34 99.7,55.34 108.3,46.74 111.89,46.74 115.65,42.98 122.83,42.98 129.37,36.44 133.83,36.44 134.61,35.67 144.53,35.67 145.2,36.34 166,36.34 169.19,39.53 174.06,39.53 182.3,47.76 216.2,47.76 217.26,47.76 218.64,49.14 218.64,49.14 219.66,50.16 219.73,50.23 219.73,56.2 221.56,58.03 221.56,59.94 223.8,62.17 230.99,62.17 232.2,62.17 234.45,64.42 237.62,64.42 240.75,67.54 243.41,67.54 244.4,66.55 247.4,66.55 248.11,65.84 249.6,65.84 250.39,65.05 255.56,65.05 256.54,66.04 258.61,66.04 v3(260.45,67.87)
  BOTTOM w0.089: U4710.AY3 256.67,63.87 256.89,64.1 256.89,65.09 257.08,65.28 257.08,65.68 258.34,66.94 258.34,66.98 258.45,67.09
  BOTTOM w0.102: v1(65.71,91.04) 65.71,91.22 Q7010.2
  BOTTOM w0.109: v3(260.45,67.87) 260.02,67.44 258.8,67.44 258.45,67.09
CPU_C10_PWR_GATE#_R: length 4.8
  BOTTOM w0.102: v2(65.4,93.6) 65.76,93.25 65.76,92.22 Q7010.3 67.54,91.37 R7065.1 R7063.1
CPU_C10_PWR_GATE_BASE: length 2.3
  BOTTOM w0.102: Q7010.1 64,89.81 v2(64,89.21) 64.72,89.21 R7066.1
CPU_EDP_AUX_DN: length 7.8
  BOTTOM w0.107: CN5.14 38.95,65.21 39.1,65.07 39.1,64.29 39.31,64.08 v2(39.31,63.32) 39.33,63.31 40.08,63.31 40.29,63.1 41.43,63.1 41.99,62.54 41.99,62.34 42.89,61.44 42.89,61.23 C3019.1
CPU_EDP_AUX_DP: length 7.8
  BOTTOM w0.107: C3020.1 43.1,61.23 43.1,61.53 42.2,62.43 42.2,62.63 41.52,63.31 40.38,63.31 40.23,63.45 40.23,64.2 v2(40.21,64.22) 39.46,64.22 39.31,64.38 39.31,65.07 39.45,65.21 CN5.13
CPU_EDP_TX0_DN: length 8.5
  BOTTOM w0.107: C3014.1 44.61,61.23 44.61,61.38 44.4,61.59 43.67,61.59 43.37,61.88 43.37,62.14 v2(42.84,62.67) 43.34,63.17 43.34,63.32 43.07,63.59 42.4,63.59 41.83,64.16 41.11,64.16 40.6,64.67 40.6,65.07 40.45,65.21 CN5.11
CPU_EDP_TX0_DP: length 8.5
  BOTTOM w0.107: C3013.1 44.81,61.23 44.81,61.47 44.49,61.8 43.76,61.8 43.58,61.97 43.58,62.14 v2(44.11,62.67) 43.55,63.24 43.55,63.41 43.16,63.8 42.49,63.8 41.92,64.37 41.2,64.37 40.8,64.76 40.8,65.07 40.95,65.21 CN5.10
CPU_EDP_TX1_DN: length 7.8
  BOTTOM w0.107: CN5.8 41.95,65.21 42.09,65.07 42.09,64.77 42.66,64.21 43.33,64.21 44.2,63.34 45.12,63.34 45.39,63.07 v2(45.39,62.32) 46.13,62.32 46.25,62.2 46.25,61.64 C3016.1
CPU_EDP_TX1_DP: length 7.8
  BOTTOM w0.107: CN5.7 42.45,65.21 42.3,65.07 42.3,64.86 42.74,64.42 43.42,64.42 44.29,63.54 45.21,63.54 45.54,63.21 v2(46.29,63.21) 46.29,62.45 46.46,62.28 46.46,61.64 C3017.1
CPU_EDP_TX2_DN: length 8.6
  BOTTOM w0.107: CN5.5 43.45,65.21 43.6,65.07 43.6,64.82 44.46,63.96 47.26,63.96 47.82,63.39 47.82,62.9 v2(47.29,62.37) 47.82,61.84 47.82,61.64 C3027.1
CPU_EDP_TX2_DP: length 8.6
  BOTTOM w0.107: C3026.1 48.03,61.64 48.03,61.84 v2(48.56,62.37) 48.03,62.9 48.03,63.48 47.34,64.16 44.55,64.16 43.8,64.91 43.8,65.07 43.95,65.21 CN5.4
CPU_EDP_TX3_DN: length 8.4
  BOTTOM w0.107: CN5.2 44.95,65.21 45.1,65.07 45.1,64.83 45.34,64.59 48.55,64.59 48.66,64.48 v2(48.66,63.73) 49.43,63.73 49.77,63.39 49.77,62.26 C3029.1
CPU_EDP_TX3_DP: length 8.4
  BOTTOM w0.107: C3028.1 49.97,62.26 49.97,63.48 49.56,63.89 v2(49.56,64.63) 48.81,64.63 48.64,64.8 45.42,64.8 45.3,64.92 45.3,65.07 45.45,65.21 CN5.1
CPU_PROCHOT#: length 302.7
  TOP w0.109: v1(84.93,140.35) 84.93,140.12 85.27,139.78 R4505.1 R4507.2 86.93,140.51 C4612.2 ; R66105.2 79.55,158.61 v1(79.68,158.48) 79.83,158.33 R66104.2 79.82,157.71 R60021.1
  L3 w0.076: v1(84.93,140.35) 84.58,140.7 84.58,143.59 85.19,144.2 85.19,147.55 84.88,147.86 84.12,147.86 84.12,147.86 83.9,147.86 81.82,149.94 81.82,154.18 79.68,156.33 v1(79.68,158.48)
  L5 w0.076: v1(79.68,158.48) 79.68,156.9 79.97,156.61 79.97,153.28 82.31,150.94 82.31,141.4 79.16,138.25 79.16,129.44 77,127.28 77,119.22 77,118.89 70.85,112.75 70.85,111.33 70.31,110.79 70.31,95.12 71.56,93.87 71.56,89.41 70.63,88.47 70.63,82.15 69.11,80.64 68.22,80.64 66.86,79.28 66.86,73.3 66.58,73.02 66.58,59.17 67.99,57.77 67.99,53.49 71.65,49.82 85.51,49.82 89.25,46.08 102.61,46.08 107.06,41.63 131.14,41.63 131.74,42.23 140,42.23 140.59,41.63 142.87,41.63 143.55,40.96 154.39,40.96 155.47,42.04 165.86,42.04 166.58,41.32 167.85,41.32 168.05,41.52 171.36,41.52 172.68,40.2 174.61,40.2 175.03,40.62 187.91,40.62 188.23,40.94 189.19,40.94 190.51,39.61 197.42,39.61 199.12,37.91 202.58,37.91 202.73,37.76 206.97,37.76 208,36.73 217.3,36.73 218.56,35.46 v1(218.56,35.23)
  BOTTOM w0.109: R339.2 218.63,35.16 v1(218.56,35.23)
CPU_PROCHOT#_R: length 3.3
  TOP w0.109: R4505.2 84.74,139.28 84.74,138.96 v1(84.74,138.96)
  BOTTOM w0.076: v1(84.74,138.96) 84.74,138.96 84.74,139.01 84.98,139.25 84.98,139.25 85.2,139.47 85.21,139.47 85.21,139.48 86.45,139.48 U4555.BR30
CPU_THERMTRIP#: length 198.5
  L5 w0.076: v3(251.18,76.64) 250.78,76.24 247.31,76.24 246.82,75.76 243.47,75.76 242.34,74.62 242.34,73.08 241.7,72.44 241.7,71.2 239.66,69.16 235.6,69.16 231.09,64.65 224.39,64.65 216.74,72.29 154.93,72.29 150.61,76.61 148.89,76.61 147.22,78.28 147.22,83.98 144.38,86.81 144.38,94.18 143.91,94.64 143.91,112.63 144.88,113.6 144.88,117.47 143.25,119.1 143.25,121.52 141.75,123.02 141.75,130.38 132.01,140.12 124.03,140.12 124.01,140.1 123.02,140.1 122.93,140.19 122.28,140.19 121.71,139.61 v1(121.71,139.28)
  BOTTOM w0.076: U4555.J31 121.81,139.38 v1(121.71,139.28)
  BOTTOM w0.109: v3(251.18,76.64) 251.18,76.15 251.1,76.07 R4736.1 251.1,75.08 250.94,74.92 Q4758.2
CPU_TRIGOUT: length 29.2
  L3 w0.076: v1(121.05,133.61) 122.24,133.61 122.43,133.8 122.75,133.8 123.52,133.02 126.06,133.02 126.26,132.82 126.26,123.67 127.42,122.51 132.38,122.51 132.95,121.93 132.95,121.3 133.52,120.73 134.83,120.73
  L3 w0.102: v1(136.13,119.86) 135.25,120.73 134.83,120.73
  BOTTOM w0.076: v1(121.05,133.61) 121.26,133.81 U4555.J23
  BOTTOM w0.102: v1(136.13,119.86) 136.13,119.86 136.04,119.94 136.04,121 R4840.2
CTL1: length 6.8
  TOP w0.102: U2501.6 284.91,29.65 284.78,29.52 283.39,29.52 283.11,29.24 282.52,29.24 282.39,29.37 280.67,29.37 v2(280.16,28.86) 279.52,28.22 R2554.2
CTL2: length 2.1
  TOP w0.102: R2553.2 285.77,28.76 v2(285.44,29.09) 285.41,29.12 U2501.7
CTL3: length 3.3
  TOP w0.102: v2(286.76,29.44) 286.43,29.44 285.91,29.96 U2501.8 ; v2(286.76,29.44) 286.81,29.49 R2557.1 ; v2(286.76,29.44) 286.76,28.39 R2558.2
DB_AC_LED: length 15.5
  L8 w0.254: v1(282.9,104.68) 282.9,108.36 281.91,109.35 279.01,109.35 v1(277.06,111.3)
  BOTTOM w0.254: Q101.5 281.68,103.86 282.5,104.68 v1(282.9,104.68) 283,104.68 v2(283.59,104.09) 283.77,103.91 R107.1 ; CN601.37 277.15,111.21 v1(277.06,111.3)
DB_BUF_PLT_RST#: length 24.8
  TOP w0.102: v3(282.5,96.42) 282.5,96.47 282.48,96.49 U400.2
  L3 w0.102: v3(282.5,96.42) 281.88,97.05 279.05,97.05 278.58,97.51 276.09,97.51 272.72,100.89 272.72,105.79 275.1,108.18 v1(275.54,108.18)
  BOTTOM w0.102: v1(275.54,108.18) 276.57,109.21 CN601.33
DB_CHG_LED: length 8.9
  L3 w0.254: v1(281.33,108.31) v1(279.07,108.31)
  BOTTOM w0.254: Q101.2 281.68,105.92 282.08,106.32 R104.1 282.08,107.55 v1(281.33,108.31) ; v1(279.07,108.31) 279.07,110.39 278.75,110.71 CN601.36
DB_CLK_LAN_DN: length 9.8
  TOP w0.107: U400.32 280.76,101.91 280.19,102.48 280.19,103.9 278.54,105.55 278.54,106.98 277.74,107.78 277.36,107.78 277.19,107.96 277.18,107.96 v1(277.01,108.14)
  BOTTOM w0.107: CN601.31 277.6,108.21 277.34,107.96 277.18,107.96 v1(277.01,108.14)
DB_CLK_LAN_DP: length 9.8
  TOP w0.107: v3(276.99,107.47) 277.09,107.57 277.65,107.57 278.33,106.9 278.33,105.46 279.98,103.81 279.98,102.39 280.86,101.51 U400.33
  BOTTOM w0.107: v3(276.99,107.47) 276.99,107.55 277.19,107.75 277.42,107.75 277.45,107.71 CN601.30
DB_CLKREQ13_LAN#: length 32.1
  TOP w0.102: R404.2 283.16,94.86 v1(283.16,95.86) 283.3,95.86 283.59,96.15 283.59,96.73 283.28,97.04 U400.4
  L8 w0.102: v3(274.82,106.15) 274.82,103.63 275.59,102.87 275.59,99.24 275.08,98.73 275.08,94.67 275.33,94.42 276.55,94.42 277.09,94.95 282.42,94.95 283.16,95.69 v1(283.16,95.86)
  BOTTOM w0.102: v3(274.82,106.15) 274.42,106.56 274.42,109.5 275.13,110.21 CN601.35
DB_HP_R_L: length 69.2
  L3 w0.254: v1(299.58,162.37) 298.32,161.12 298.32,156.65 298.32,156.65 298.32,155.81 297.3,154.79 297.3,135.1 295.84,133.63 295.31,133.63 284.3,133.63 283.08,132.41 283.08,127.62 283.08,127.1 277.8,121.81 277.8,117.35 v1(277.16,116.71)
  BOTTOM w0.254: JACK600.1 302.36,165.46 301.62,164.72 301.62,163.55 301.24,163.17 D7534.2 C16.1 299.79,163.17 299.79,162.59 v1(299.58,162.37) ; CN601.48 v1(277.16,116.71)
DB_HP_R_R: length 68.5
  L10 w0.254: v1(300.99,156.1) 299.68,156.1 296.54,152.96 296.54,134.83 296,134.29 284.27,134.29 282.44,132.47 282.44,132.05 282.44,127.51 276.68,121.75 276.68,117.91 277.11,117.48 v1(277.11,117.43)
  BOTTOM w0.254: v1(277.11,117.43) 277.33,117.21 CN601.49 ; JACK600.2 308.51,155.02 302.82,155.02 v2(301.64,156.19) 301.08,156.19 v1(300.99,156.1) D7533.2 299.35,156.1 C19.1
DB_HPS: length 65.8
  L10 w0.254: JACK600.6 305.76,155.02 302.16,155.02 299.41,152.28 v1(298.29,152.28) 298.19,152.28 297.38,151.46 297.38,134.95 296.21,133.79 284.48,133.79 282.95,132.26 282.95,127.3 277.75,122.09 277.75,116.06 278.76,115.04 v1(278.86,115.04)
  BOTTOM w0.254: v1(298.29,152.28) 298.86,152.28 D7522.2 ; v1(278.86,115.04) 278.86,114.48 278.59,114.21 CN601.43
DB_LAN_CLKREQ13#: length 1.8
  TOP w0.102: R400.2 283.77,92.61 v2(283.33,93.04) 283.34,93.05 R404.1
DB_LAN_PCIE_WAKE#: length 11.1
  TOP w0.102: U400.3 282.88,97.08 283.18,96.78 v1(283.18,96.46)
  L3 w0.102: v1(283.18,96.46) 285.15,96.46 285.7,95.91 v1(287.22,95.91)
  BOTTOM w0.102: v1(287.22,95.91) 288.3,94.83 Q402.2 288.3,92.47 v2(288.64,92.13) 289.3,92.13 R402.1
DB_MIC2_REF: length 67.5
  L8 w0.254: v1(297.05,157.16) 296.67,156.78 296.67,155.41 296.59,155.33 296.59,135.49 295.5,134.39 284.12,134.39 282.32,132.59 282.32,127.41 276.09,121.19 276.09,115.5 v1(276.67,114.93)
  BOTTOM w0.254: v1(276.67,114.93) 276.88,114.71 CN601.44 ; R601.2 297.99,159.06 v2(297.87,158.94) 297.67,158.74 R600.2 297.67,157.78 v1(297.05,157.16)
DB_PCH_WAKE#: length 27.8
  L8 w0.102: v3(289.26,96.17) 289.26,96.37 286.31,99.32 286.31,102.44 285.66,103.08 281.63,103.08 280.98,102.42 279.95,102.42 277.29,105.08 277.29,106 275.87,107.42 v1(275.13,107.42)
  BOTTOM w0.102: v1(275.13,107.42) 274.88,107.67 274.88,109.02 275.57,109.71 CN601.34 ; Q402.3 v3(289.26,96.17)
DB_PCIE_LAN_C_TX13N: length 7.2
  TOP w0.107: C402.2 277.49,101.09 277.16,101.09 276.7,101.56 276.7,102.27 275.79,103.18 275.79,103.91 v1(275.61,104.09)
  BOTTOM w0.107: v1(275.61,104.09) 275.86,104.34 275.86,104.54 276.53,105.21 CN601.25
DB_PCIE_LAN_C_TX13P: length 7.2
  TOP w0.107: v3(276.34,104.1) 276.33,104.11 276.21,104.11 276,103.89 276,103.26 276.91,102.35 276.91,101.64 277.25,101.3 277.38,101.3 277.69,101.61 C400.2
  BOTTOM w0.107: CN601.24 277.61,104.71 277.32,105 276.62,105 276.07,104.46 276.07,104.29 276.25,104.11 276.33,104.11 v3(276.34,104.1)
DB_PCIE_LAN_RX13N: length 9.4
  TOP w0.107: v3(279.3,106.87) 279.43,106.74 280.06,106.74 281.1,107.78 281.84,107.78 282.48,107.15 U400.29
  BOTTOM w0.107: v3(279.3,106.87) 279.14,106.71 CN601.28
DB_PCIE_LAN_RX13P: length 9.4
  TOP w0.107: U400.30 282.08,103.64 282.27,103.84 282.27,107.06 281.76,107.57 281.19,107.57 280.14,106.53 279.64,106.53 v1(279.27,106.16)
  BOTTOM w0.107: v1(279.27,106.16) 278.93,106.5 278.72,106.5 278.43,106.21 CN601.27
DB_PWR_LED: length 15.6
  TOP w0.102: Q102.G 275.9,99.43 274.98,100.35 R109.1 v2(274.98,102.54) 274.98,104.9 v1(274.39,105.49)
  L8 w0.102: v1(276.12,111.31) 274.29,109.48 274.29,105.59 v1(274.39,105.49)
  BOTTOM w0.102: CN601.38 276.53,111.71 v1(276.12,111.31)
DB_RING2: length 69.8
  L8 w0.508: v1(278.85,115.71) 278.85,117.29 276.98,119.15 276.98,121.18 282.95,127.15 282.95,132.33 284.38,133.76 295.76,133.76 297.23,135.22 297.23,154.49 298.29,155.55 298.29,158.4 297.99,158.7 v1(297.99,166.58)
  BOTTOM w0.356: CN601.46 v1(278.85,115.71)
  BOTTOM w0.432: L601.2 298.53,165.8 298.52,165.81 R601.1 v1(297.99,166.58)
DB_SLEEVE: length 60
  L3 w0.508: v1(297.48,156.39) 297.48,156.19 296.67,155.38 296.67,135.36 295.58,134.27 284.04,134.27 282.44,132.68 282.44,127.36 276.37,121.29 276.37,115.98 v1(276.73,115.62)
  BOTTOM w0.356: CN601.45 277.24,115.21 276.83,115.62 v1(276.73,115.62)
  BOTTOM w0.432: R600.1 298.52,157.01 L600.2 298.03,156.94 v1(297.48,156.39)
DB_SPK_OUT_R_L_N: length 34
  L8 w0.508: v5(276.73,112.2) 277.62,112.2 278.63,111.18 282.77,111.18 283.11,111.52 294.37,111.52 295.45,112.61 295.45,117.35 295.17,117.63 295.17,118.65 v5(295.4,118.88)
  BOTTOM w0.356: 277.25,112.71 CN601.40
  BOTTOM w0.432: CN600.2 295.05,123.04 D610.1 294.35,121.63 C606.1 294.35,121 C610.1 294.35,120.15 294.78,119.71 294.99,119.71 295.4,119.31 v5(295.4,118.88)
  BOTTOM w0.508: v5(276.73,112.2) 277.25,112.71
DB_SPK_OUT_R_L_P: length 32.3
  L8 w0.508: v5(279.14,111.94) 282.46,111.94 282.8,112.28 294.05,112.28 294.69,112.92 294.69,117.04 294.41,117.32 294.41,118.82 293.65,119.59 v5(293.34,119.59)
  BOTTOM w0.356: 278.87,112.21 CN601.39
  BOTTOM w0.432: v5(293.34,119.59) 293.3,119.63 C611.1 293.3,120.77 293.18,120.89 C606.2 292.62,121.32 292.2,121.74 292.2,122.59 D611.1 291.65,123.14 291.65,123.49 292.43,124.26 293.88,124.26 CN600.1
  BOTTOM w0.508: v5(279.14,111.94) 278.87,112.21
DB_SPK_OUT_R_R_N: length 29.8
  L8 w0.508: v5(296.95,120.02) 296.95,120.88 296.41,121.42 292.97,121.42 291.69,120.13 291.69,119.01 287.03,114.35 282.71,114.35 281.82,113.47 v5(279.6,113.47)
  BOTTOM w0.356: 279.02,113.21 CN601.41
  BOTTOM w0.432: CN600.3 296.05,122.59 296.77,121.87 D609.1 297.57,121.87 C607.2 297.22,120.71 C609.1 297.21,120.28 v5(296.95,120.02)
  BOTTOM w0.508: v5(279.6,113.47) 279.27,113.47 279.02,113.21
DB_SPK_OUT_R_R_P: length 34.1
  L8 w0.508: v5(297.94,120.45) 297.94,119.59 297.43,119.08 296.31,119.08 294.79,120.6 293.24,120.6 292.45,119.82 292.45,118.7 286.8,113.05 282.48,113.05 282.14,112.7 278.95,112.7 278.32,113.34 v5(276.6,113.34)
  BOTTOM w0.356: 276.98,113.71 CN601.42
  BOTTOM w0.432: CN600.4 297.05,123.9 297.94,123.02 D608.1 298.33,122.44 298.82,121.95 C607.1 298.82,120.95 298.63,120.76 C608.1 298.07,120.58 v5(297.94,120.45)
  BOTTOM w0.508: v5(276.6,113.34) 276.98,113.71
DB_USB3_RX4N: length 15.1
  BOTTOM w0.107: C2413.1 281,113.07 280.25,113.07 279.76,112.58 279.76,105.37 279.42,105.03 279.42,103.95 279.06,103.59 279.06,100.73 278.9,100.57 278.78,100.57 278.63,100.71 CN601.16
DB_USB3_RX4P: length 15.1
  BOTTOM w0.107: CN601.15 278.63,100.21 278.78,100.36 278.99,100.36 279.27,100.64 279.27,103.51 279.63,103.87 279.63,104.95 279.97,105.29 279.97,112.49 280.34,112.86 281.13,112.86 C2412.1
DB_USB3_RX5N: length 33.9
  TOP w0.107: v1(274.39,104.32) 274.39,104.25 274.1,103.96 274.04,103.96 273.81,104.18 273.81,107.08 275.5,108.76 280.33,108.76 284.54,112.97 284.54,119.5 285.32,120.29 v2(286.06,120.29) 286.06,121.03 287.83,122.8 288.55,122.8 288.83,122.51 C2423.1
  BOTTOM w0.107: CN601.22 277.6,103.71 277.37,103.48 275.16,103.48 274.39,104.25 v1(274.39,104.32)
DB_USB3_RX5P: length 33.9
  TOP w0.107: v1(274.39,103.66) 274.3,103.75 273.95,103.75 273.61,104.09 273.61,107.17 275.41,108.97 280.25,108.97 284.33,113.05 284.33,119.59 285.17,120.43 v2(285.17,121.2) 285.93,121.2 287.75,123.01 288.78,123.01 C2422.1
  BOTTOM w0.107: v1(274.39,103.66) 274.69,103.66 275.07,103.28 277.36,103.28 277.42,103.21 CN601.21
DB_USB3_TX4N: length 15.2
  BOTTOM w0.107: CN601.13 278.43,99.21 278.61,99.04 278.9,99.04 279.16,99.3 279.16,99.94 279.7,100.47 279.7,103.35 280.1,103.76 280.1,104.72 280.4,105.02 280.4,111.6 280.63,111.83 280.98,111.83 C2411.1
DB_USB3_TX4P: length 15.1
  BOTTOM w0.107: CN601.12 278.36,98.71 278.48,98.83 278.99,98.83 279.37,99.22 279.37,99.85 279.9,100.38 279.9,103.26 280.31,103.67 280.31,104.64 280.61,104.93 280.61,111.51 280.71,111.62 281.15,111.62 C2410.1
DB_USB3_TX5N: length 37.8
  TOP w0.107: v1(273.68,103.17) 273.44,102.93 273.31,102.93 273.13,103.11 273.13,107.31 275.22,109.4 280.09,109.4 283.92,113.22 283.92,120.73 286.25,123.07 286.52,123.07 v2(286.76,122.82) 286.76,123.58 287.35,124.16 288.64,124.16 288.83,123.96 C2421.1
  BOTTOM w0.107: v1(273.68,103.17) 273.68,103.13 274.82,101.98 277.21,101.98 277.44,102.22 CN601.19
DB_USB3_TX5P: length 37.8
  TOP w0.107: C2420.1 288.74,124.37 287.26,124.37 286.62,123.73 v2(285.88,123.73) 285.88,122.98 283.71,120.82 283.71,113.31 280.01,109.61 275.13,109.61 272.92,107.39 272.92,103.03 273.22,102.72 273.47,102.72 v1(273.68,102.5)
  BOTTOM w0.107: v1(273.68,102.5) 274.01,102.5 274.74,101.78 277.4,101.78 277.46,101.71 CN601.18
DB_USB_P4_DN: length 54.7
  TOP w0.107: L2400.2 295.55,128.65 295.28,128.38 295.19,128.38 294.7,127.89 291.89,127.89 291.39,127.39 291.39,126.6 289.86,125.07 286.38,125.07 284.71,123.4 v2(284.71,122.65) 283.97,122.65 283.3,121.98 283.3,113.48 279.88,110.06 274.97,110.06 272.51,107.6 272.51,99.27 272.92,98.86 272.92,96.61 273.09,96.45 273.25,96.45 273.43,96.63 v1(273.43,96.67)
  BOTTOM w0.107: CN601.7 277.42,96.21 277.25,96.04 274.18,96.04 273.87,96.35 273.68,96.35 273.43,96.6 v1(273.43,96.67)
DB_USB_P4_DP: length 54.7
  TOP w0.107: L2400.1 295,128.48 294.61,128.1 291.81,128.1 291.18,127.47 291.18,126.69 289.77,125.28 286.3,125.28 284.58,123.56 v2(283.82,123.56) 283.82,122.8 283.09,122.07 283.09,113.57 279.79,110.27 274.88,110.27 272.3,107.69 272.3,99.19 272.72,98.77 272.72,96.52 273,96.24 273.2,96.24 v1(273.43,96.01)
  BOTTOM w0.107: v1(273.43,96.01) 273.55,96.14 273.79,96.14 274.09,95.83 277.37,95.83 277.49,95.71 CN601.6
DB_USB_P5_DN: length 48.3
  TOP w0.107: L2403.2 288.21,126.4 288.03,126.57 285.46,126.57 284.84,125.95 v2(284.84,124.91) 283.84,124.91 282.68,123.76 282.68,113.74 279.62,110.68 274.71,110.68 271.68,107.65 271.68,97.78 271.78,97.67 271.98,97.67 272.17,97.86 272.17,97.99 v1(272.17,97.99)
  BOTTOM w0.107: v1(272.17,97.99) 272.17,97.88 272.41,97.64 276.85,97.64 277.07,97.42 277.24,97.42 277.53,97.71 CN601.10
DB_USB_P5_DP: length 48.3
  TOP w0.107: v1(272.18,97.22) 271.94,97.46 271.7,97.46 271.47,97.69 271.47,107.73 274.62,110.89 279.53,110.89 282.47,113.83 282.47,123.84 283.95,125.32 v2(283.95,125.82) 284.41,125.82 285.37,126.78 287.99,126.78 288.16,126.95 L2403.1
  BOTTOM w0.107: v1(272.18,97.22) 272.39,97.43 276.76,97.43 276.98,97.21 CN601.9
DB_USBPWR_EN: length 40.4
  L3 w0.102: v1(292.78,116.84) 291.64,116.84 287.25,112.45 283.64,112.45 281.66,110.47 277.1,110.47 272.51,105.88 272.51,100.81 276.04,97.28 276.04,95.51 v1(276.15,95.41)
  BOTTOM w0.102: CN601.5 277.02,95.21 276.83,95.41 v1(276.15,95.41) ; U2400.4 292.99,117.05 v1(292.78,116.84)
DB_WOL_PWEN: length 16.6
  TOP w0.102: v1(275.54,95.41) 275.67,95.54 R403.1
  L8 w0.102: v3(276.07,106.56) 275.1,105.59 275.1,103.64 275.82,102.93 275.82,98.96 275.54,98.68 v1(275.54,95.41)
  BOTTOM w0.102: v3(276.07,106.56) 275.99,106.63 275.99,108.08 276.63,108.71 CN601.32
DCPRTC: length 5
  BOTTOM w0.254: U4710.BF47 U4710.BG47
  BOTTOM w0.381: U4710.BG47 260.75,42.22 262.12,40.85 v2(263.19,40.85) 263.25,40.79 C4814.1
DDR4_DRAMRST#_CPU: length 17.6
  L5 w0.076: v1(107.41,72.39) 107.41,66.86 110.75,63.53 v1(110.96,63.53)
  BOTTOM w0.109: R4770.2 112.47,59.91 112.41,59.97 CN4125.108 112.29,61.62 112.29,62.51 112.24,62.63 111.33,63.53 v1(110.96,63.53) ; v1(107.41,72.39) CN4100.108
DDR_CA_CPU_VREF_A: length 8.8
  TOP w0.432: R4153.1 C4172.1 82.52,122.66
  TOP w0.508: 82.52,122.66 v2(82.55,122.63) 83,123.09 84.45,123.09 85.33,123.96 85.58,123.96 86.1,124.49 87.27,124.49 87.78,125 87.78,125.31 v1(87.79,125.32)
  BOTTOM w0.254: v1(87.79,125.32) 88.14,125.67 U4555.BN13
DDR_CA_CPU_VREF_RC: length 1.9
  TOP w0.432: R4155.1 80.1,122.23 v2(80.49,121.85) 80.88,122.24 C4172.2
DDR_DQ_CPU_VREF_A: length 1.2
  TOP w0.076: v1(87.16,125.32) 87.12,125.28 TP4524.1
  BOTTOM w0.254: v1(87.16,125.32) 87.16,125.39 U4555.BP13
DDR_DQ_CPU_VREF_B: length 3.4
  TOP w0.432: v3(85.56,126.13) 84.97,126.72 R4148.1 84.61,126.62 83.89,126.62 C4169.1
  BOTTOM w0.254: v3(85.56,126.13) 85.57,126.12 86.32,126.12 86.72,125.71 U4555.BR13
DDR_DQ_CPU_VREF_RC: length 1.9
  TOP w0.432: R4149.1 82.7,127.51 v2(82.27,127.08) 82.72,126.62 C4169.2
DDR_PG_CTRL: length 17.8
  L5 w0.102: v1(82.02,115.84) 81.94,115.92 81.94,123.87 83.45,125.38 85.01,125.38 v1(85.09,125.3)
  BOTTOM w0.102: U4555.BT13 85.51,125.71 v1(85.09,125.3) ; R42.1 81.3,115.12 v1(82.02,115.84)
DDR_PG_CTRL#: length 5
  BOTTOM w0.102: Q1.C 84.69,111.17 84.97,110.88 Q2.1 85.63,110.15 85.09,109.6 v2(84.45,109.6) 84.28,109.78 R41.1
DDR_PG_CTRL_R: length 6.6
  BOTTOM w0.102: v2(82.19,109.63) 81.3,110.52 R42.2 81.66,110.98 Q1.B 82.98,110.98 83.49,111.48 83.49,113.79 R43.1
DDR_RCOMP_0: length 8.6
  BOTTOM w0.254: U4555.G1 123.78,117.14 124.64,117.14
  BOTTOM w0.381: 126.48,115.83 125.17,117.14 124.64,117.14
  BOTTOM w0.508: R4518.2 126.48,111.54 v2(126.48,114.24) 126.48,115.83
DDR_RCOMP_1: length 7.3
  BOTTOM w0.254: U4555.H1 122.37,117.38 124.18,115.57
  BOTTOM w0.508: R4541.2 124.37,111.38 v2(124.37,114.07) 124.37,115.38 124.18,115.57
DDR_RCOMP_2: length 7.9
  BOTTOM w0.254: U4555.J2 121.79,118.06 121.79,117.27 123.06,115.99 123.06,115.47
  BOTTOM w0.508: R4540.2 123.56,111.3 123.06,111.79 v2(123.06,112.41) 123.06,115.47
DDR_VTT_PG_CTRL: length 53.4
  L8 w0.102: v1(67.59,72.14) 67.59,72.75 67.46,72.88 67.46,79.22 69.04,80.8 69.37,80.8 69.48,80.92 69.99,81.43 69.99,81.59 69.99,82.72 70.63,83.37 70.63,83.75 70.63,87.19 72.84,89.4 72.84,93.45 76.17,96.78 78.67,96.78 81.76,99.86 81.76,103.98 v1(83.45,105.67)
  BOTTOM w0.102: v1(83.45,105.67) 85.34,107.56 v2(85.34,107.7) R4116.1 85.96,108.66 Q2.3 87.46,108.98 R44.2 ; v1(67.59,72.14) 67.23,72.14 67.16,72.06 D7000.3 64.92,72.12 R7001.1
DEVSLP_SSD1: length 185.1
  L10 w0.102: v3(85.47,47.81) 86.75,46.52 90.94,46.52 92.05,47.64 103.18,47.64 112.76,38.05 136.61,38.05 137.43,37.24 154.88,37.24 156.16,35.95 167.58,35.95 171.33,39.71 178.26,39.71 182.71,44.15 198.18,44.15 198.48,43.84 212.18,43.84 212.66,44.33 218.35,44.33 220.21,42.47 229.77,42.47 231.63,44.33 237.45,44.33 238.07,44.94 240.55,44.94 241.66,46.05 243.22,46.05 244.57,47.39 247.93,47.39 248.05,47.27 249.73,47.27 v1(250.42,47.96)
  BOTTOM w0.089: U4710.AH35 250.85,48.39 v1(250.42,47.96)
  BOTTOM w0.102: R1900.1 80.9,49.56 81,49.46 83.82,49.46 v3(85.47,47.81)
DEVSLP_SSD7: length 5.6
  BOTTOM w0.089: U4710.AP47 253.41,42.1 253.41,41.63 253.24,41.46 253.24,41.15 252.78,40.69 252.78,39.09
  BOTTOM w0.102: 252.78,39.09 252.5,38.81 TP4805.1
DGPU_FB_CAL_PD_VDDQ: length 2.2
  TOP w0.102: R52210.1 178.39,142.23 178.37,142.23 178.17,142.43 178.17,142.85 v4(177.8,143.22)
  BOTTOM w0.102: v4(177.8,143.22) 177.74,143.22 U50000.R44
DGPU_FB_CAL_PU_GND: length 1.1
  TOP w0.254: R52211.1 177.75,141.97 v4(177.75,142.48)
  BOTTOM w0.254: U50000.P44 178.1,142.85 177.75,142.51 v4(177.75,142.48)
DGPU_FB_CAL_TERM_GND: length 1.5
  TOP w0.254: R52212.1 177.16,142.62 177.16,143.17 177.08,143.24 v4(177.08,143.27)
  BOTTOM w0.254: U50000.R45 177.09,143.27 v4(177.08,143.27)
DGPU_FBVDDQ_SENSE: length 5.8
  TOP w0.254: R52230.1 186.53,152.63 v2(186.51,152.61) 185.09,151.19 v4(185.09,149.22)
  BOTTOM w0.105: v4(185.09,149.22) 184.4,148.53 U50000.E52
DGPU_JTAG_SEL: length 8.1
  BOTTOM w0.102: R51508.2 148.62,122.69 v2(148.98,123.05) 150.77,124.84 150.77,126.64 151.96,127.83 152.41,127.83 152.76,128.18 U50000.BK23
DGPU_JTAG_TRSTB: length 6.4
  BOTTOM w0.102: U50000.BL24 151.93,128.88 151.58,128.53 151.26,128.53 149.83,127.1 149.83,125.81 149.19,125.17 v2(148.92,125.17) R51507.2
DGPU_PEX_TERMP: length 5.3
  BOTTOM w0.102: R50091.1 v2(148.1,142.9) 148.38,143.18 151.79,143.18 152.09,142.88 U50000.BL44
DGPU_PWR_EN: length 251.2
  TOP w0.102: R51680.1 294.2,61.73 v1(293.8,61.32) ; v1(261.82,51.62) 262.29,51.15 Q4.3
  L3 w0.102: v1(293.8,61.32) 297.08,58.04 297.08,47.98 296.03,46.94 296.03,41.96 301.14,36.86 v1(301.14,34.57)
  L5 w0.102: v1(261.82,51.62) 260.78,50.57 257.13,50.57 256.71,50.16 253.61,50.16 252.76,49.3 251.75,49.3 251.31,48.87 242.43,48.87 241.98,48.42 240.55,48.42 240.12,48.85 239.58,48.85 239.29,48.56 239.29,46.76 237.05,44.52 230.9,44.52 228.74,42.37 219.24,42.37 217.95,43.67 214.93,43.67 214.58,43.31 213.86,43.31 213.08,44.1 211.63,44.1 208.35,47.37 150.78,47.37 150.49,47.09 150.49,46.51 150.39,46.41 133.52,46.41 132.71,47.22 131.17,47.22 131.15,47.2 113.71,47.2 v1(113.51,46.99)
  L8 w0.102: v1(293.8,61.32) 293.8,60.71 291.44,58.35 282.31,58.35 280.28,56.32 279.3,56.32 279.15,56.47 272.91,56.47 270.68,54.23 268.03,54.23 265.16,51.36 262.07,51.36 v1(261.82,51.62) ; v1(113.71,50.12) 113.71,52.4 117.37,56.06 123.03,56.06 124.57,57.6 v1(124.86,57.6)
  BOTTOM w0.102: v1(301.14,34.57) 301.16,34.56 R56251.2 ; v1(124.86,57.6) R53583.1 ; v1(113.51,46.99) 113.71,47.2 v1(113.71,50.12) 113.12,49.53 TP53500.1 111.3,49.53 R53505.1 110.42,49.97 U53500.1
DGPU_PWR_Q_EN: length 15.8
  TOP w0.102: v1(301.49,58.93) 301.56,58.99 Q51660.1 ; Q51640.1 v1(298.13,61.12) ; R51682.1 294.99,65.28 294.33,64.62 Q51680.6 294.33,63.73 v1(294.65,63.41) C51681.1
  L5 w0.102: v1(301.49,58.93) 301.43,58.99 300.11,58.99 298.13,60.97 v1(298.13,61.12) 295.84,63.41 v1(294.65,63.41)
DGPU_PWR_R_EN: length 2.1
  TOP w0.102: Q51680.5 293.83,63.63 293.37,63.17 v2(293.37,63.02) 293.48,62.91 R51680.2
DGPU_PWR_R_EN#: length 3.4
  TOP w0.102: Q51680.3 293.33,66.36 v2(293.24,66.45) 293.55,66.76 R51681.1 294.08,66.61 293.83,66.35 Q51680.2
DGPU_PWRLEVEL: length 111.8
  L3 w0.102: v1(192.87,40.01) 192.41,40.47 191.87,40.47 191.26,41.08 186.97,41.08 186.69,40.8 172.44,40.8 171.98,41.25 157.6,41.25 v1(157.4,41.46)
  L8 w0.102: v1(160.2,86.57) 160.2,85.63 156.61,82.05 156.61,76.58 158.16,75.04 158.16,60.96 156.94,59.74 156.94,48.85 159.84,45.95 166.77,45.95 166.87,45.85 166.87,44.02 166.19,43.34 159.81,43.34 159.55,43.08 159.03,43.08 v1(157.4,41.46)
  BOTTOM w0.102: v1(192.87,40.01) R323.2 ; Q51550.D 162.34,93.62 TP51550.1 162.58,92.76 162.58,87.46 162.25,87.13 160.75,87.13 v1(160.2,86.57)
DGPU_PWROK: length 62.2
  L3 w0.102: v3(256.02,52.07) 255.59,51.64 254.58,51.64 253.01,50.07 247.5,50.07 243.05,45.62 243.05,43.78 242.02,42.75 241.12,42.75 239.79,41.42 237.7,41.42 236.22,39.93 222.25,39.93 221.21,38.89 214.27,38.89 214.09,39.07 210.69,39.07 209.98,39.78 206.6,39.78 v1(206.19,39.37)
  BOTTOM w0.089: v3(256.02,52.07) 256.21,52.26 U4710.AW26
  BOTTOM w0.102: R345.2 206.45,43.16 206.5,43.11 206.5,43.1 206.6,43 206.6,42.91 206.6,42.91 206.6,42.32 206.29,42.01 U1.80 206.29,39.47 v1(206.19,39.37)
DGPU_ROM_CS#: length 33.6
  L8 w0.076: v3(157.04,89.36) 157.04,91.14 157.74,91.83 157.74,95.65 154.71,98.68 154.71,103.65 155.18,104.12 155.18,106.42 155.57,106.81 155.57,109.02 154.35,110.24 154.35,113.86 154.12,114.09 153.74,114.09 v4(153.29,114.54)
  BOTTOM w0.109: R51401.1 158.04,85.32 158.04,87.4 157.04,88.4 v3(157.04,89.36) ; v4(153.29,114.54) 153.29,114.61 153.56,114.88 U50000.BJ4
DGPU_ROM_SCLK: length 23.5
  L8 w0.076: v4(152.6,113.82) 153.51,112.91 153.51,109.12 154.52,108.12 154.52,104.4 154.05,103.93 154.05,98.25 155.8,96.49 v1(155.8,95.81)
  BOTTOM w0.109: R51424.1 156.64,94.41 v2(156.61,94.44) 156.64,94.47 156.64,94.67 156.65,94.67 R51423.2 156.49,95.28 156.34,95.13 155.84,95.13 R51402.2 v1(155.8,95.81) ; v4(152.6,113.82) 152.6,113.88 U50000.BK3
DGPU_ROM_SI: length 21
  L8 w0.076: v1(155.34,96.29) 153.59,98.05 153.59,103.36 153.59,104.12 154.06,104.59 154.06,107.93 153.03,108.96 153.03,112.72 v4(152.61,113.14)
  BOTTOM w0.109: v1(155.34,96.29) 154.95,95.91 R51421.2 R51403.2 ; U50000.BK2 152.61,113.19 v4(152.61,113.14)
DGPU_ROM_SO: length 33.1
  L8 w0.076: v3(156.59,87.72) 156.08,88.22 156.08,95.25 156.33,95.51 156.33,96.7 154.5,98.53 154.5,103.74 154.97,104.21 154.97,108.35 153.97,109.35 153.97,113.18 v4(152.58,114.57)
  BOTTOM w0.109: R51422.2 155.97,84.69 156,84.71 156,85.25 156.18,85.43 U51400.2 156.18,87.31 v3(156.59,87.72) ; v4(152.58,114.57) U50000.BK4
DGPU_STRAP0: length 24.8
  TOP w0.102: v4(151.81,113.85) 151.02,113.06 151.02,110.97 151.77,110.22 151.77,97.17 150.69,96.09 v2(150.09,96.09) 148.64,94.64 148.64,93.53 148.28,93.17 R51431.1 148.27,92.91 R51430.2
  BOTTOM w0.102: U50000.BL3 151.87,113.85 v4(151.81,113.85)
DGPU_STRAP1: length 19
  TOP w0.102: R51433.1 151.22,97.94 151.22,97.94 R51432.2 151.22,99.02 v2(151.08,99.17) 151.08,102.84 151.57,103.33 151.57,110.14 150.78,110.93 150.78,114 151.29,114.51 v4(151.84,114.51)
  BOTTOM w0.102: U50000.BL4 152.2,114.88 v4(151.84,114.51)
DGPU_STRAP2: length 27.2
  TOP w0.102: v4(151.4,112.02) 151.98,111.44 151.98,96.89 150.52,95.43 150.19,95.43 v2(149.62,94.86) 148.92,94.16 148.92,93.52 148.69,93.29 148.69,91.36 R51434.2 149.11,90.53 R51435.1
  BOTTOM w0.102: U50000.BM4 150.82,114.2 150.82,112.6 v4(151.4,112.02)
DGPU_STRAP3: length 28.1
  TOP w0.102: R51436.2 v3(152.93,91.72) R51437.1
  L8 w0.102: v3(152.93,91.72) 152.94,91.73 153.17,91.73 153.44,92 153.44,94.25 152.27,95.42 v4(152.27,111.69)
  BOTTOM w0.102: v4(152.27,111.69) 152.22,111.64 151.18,111.64 150.61,112.2 150.61,114.69 U50000.BM5
DGPU_STRAP4: length 28.2
  TOP w0.102: R51438.2 153.51,90.44 v3(152.99,90.44) 152.48,90.44 R51439.1
  L8 w0.102: v4(152.58,115.29) 152.24,114.95 152.24,113.7 152.26,113.68 152.26,112.28 152.74,111.8 152.74,95.24 153.72,94.26 153.72,91.16 v3(152.99,90.44)
  BOTTOM w0.102: U50000.BK5 152.87,115.58 v4(152.58,115.29)
DGPU_STRAP5: length 27.9
  TOP w0.102: R51441.1 152.21,93.01 v3(152.92,93.01) 153.69,93.01 153.7,93.02 R51440.2
  L8 w0.102: v4(153.3,115.28) 152.94,115.64 151.75,115.64 150.64,114.53 150.64,112.22 152.03,110.83 152.03,94.76 152.92,93.87 v3(152.92,93.01)
  BOTTOM w0.102: v4(153.3,115.28) U50000.BJ5
DGPU_XTAL_IN: length 13.9
  BOTTOM w0.091: X51310.1 146.81,106.53 147.49,106.53 147.7,106.74 147.7,107.77 C51310.1 147.71,108.35 147.71,108.8 149.71,110.8 149.71,115.2 151.01,116.5 151.3,116.5 151.41,116.62 151.73,116.62 152.07,116.28 U50000.BL6
DGPU_XTAL_OUT: length 13.8
  BOTTOM w0.091: U50000.BM6 151.47,116.31 151.09,116.31 149.91,115.12 149.91,110.72 147.9,108.72 147.9,108.31 C51311.1 147.89,107.79 147.89,106.66 147.89,106.02 X51310.3
DGPU_XTAL_OUTBUFF: length 14.1
  BOTTOM w0.102: 147.95,109.55 149.4,111 149.4,115.17 151.05,116.82 151.89,116.82 152.06,116.65 152.53,116.65 U50000.BK6
  BOTTOM w0.109: 147.95,109.55 146.35,109.55 TP5631.1 145.67,108.87 R51321.1
DGPU_XTAL_SSIN: length 10.5
  BOTTOM w0.102: v2(149.44,109.54) 149.44,109.57 150.21,110.34 150.21,114.72 151.4,115.91 153.23,115.91 U50000.BJ6
  BOTTOM w0.109: R51316.1 150.03,108.94 v2(149.44,109.54)
DIS_FBVDD: length 2
  TOP w0.254: Q55230.G 200.72,169.02 R55231.2 200.07,168.23 v2(199.92,168.08)
DIS_NVVDD: length 5.6
  BOTTOM w0.254: R55211.2 203.55,86.67 v2(203.7,86.52) 202.26,86.52 201.65,85.9 201.65,84.66 202.1,84.21 Q55210.G
DIS_PEXVDD: length 2.5
  BOTTOM w0.254: v2(205.71,169.83) 206.03,170.15 Q55220.G 205.98,171.14 R55221.2
DISP_RCOMP: length 11.3
  TOP w0.076: R4544.1 123.74,135.91 v3(123.87,135.78)
  L3 w0.102: v3(123.87,135.78) 123.28,135.78 122.81,136.25 122.81,137.49 123.14,137.82 123.14,139.98 122.79,140.33 122.79,141.21 124.28,142.7 124.28,143.2 v1(124.87,143.79)
  BOTTOM w0.254: U4555.D37 124.83,143.7 124.87,143.75 124.87,143.79 v1(124.87,143.79)
DMI_RX0_DN: length 161.4
  L3 w0.076: 131.09,117.39 131.08,117.41 131.08,117.44 129.39,119.12 128.17,119.12 125.52,121.77 125.22,121.77 125.03,121.77 124.75,122.05 v1(124.54,122.4)
  L3 w0.084: v3(236.57,49.97) 236.76,50.42 237.68,51.35 237.68,53.23 236.15,54.76 232.63,54.76 232.46,54.76 230.54,56.68 230.19,57.03 230.19,59.16 230.19,59.98 227.38,62.79 224.56,62.79 219.34,68.01 219.34,70.05 218.18,71.22 216.13,71.22 214.68,72.67 158.78,72.67 157.96,73.5 154.6,76.85 154.6,77.35 154.6,82.36 154.6,82.68 133.64,103.64 133.64,114.84 131.09,117.39
  BOTTOM w0.076: U4555.E8 v1(124.54,122.4)
  BOTTOM w0.089: v3(236.57,49.97) 237.13,50.17 237.4,50.17 237.89,49.68 U4710.C33
DMI_RX0_DP: length 161.3
  L3 w0.076: 131.24,117.54 131.23,117.55 131.19,117.55 129.46,119.28 128.24,119.28 125.59,121.94 125.09,121.94 124.92,122.11 124.92,122.38 124.99,122.45 125.15,122.45 v3(125.21,122.39)
  L3 w0.084: 131.24,117.54 133.85,114.92 133.85,103.73 154.82,82.77 154.82,82.27 154.81,82.27 154.81,77.35 154.81,77.26 154.81,76.94 158.17,73.59 158.87,72.88 214.77,72.88 216.22,71.43 218.27,71.43 219.55,70.14 219.55,68.1 224.65,63 227.46,63 230.4,60.07 230.4,59.25 230.4,57.12 232.55,54.97 236.24,54.97 237.77,53.44 237.77,53.44 237.89,53.32 237.89,51.26 236.97,50.34 236.97,49.86 237.11,49.71 v1(237.21,49.71)
  BOTTOM w0.076: v3(125.21,122.39) 125.21,122.03 125.13,121.95 124.92,121.95 U4555.D8
  BOTTOM w0.089: v1(237.21,49.71) 237.21,49.76 237.32,49.88 237.45,49.88 237.82,49.51 237.82,49.21 237.91,49.12 U4710.B33
DMI_RX1_DN: length 164.5
  L3 w0.076: v1(123.87,120.81) 123.82,120.86 123.66,120.86 123.58,120.78 123.58,120.49 126.2,117.87 128.15,117.87 129.32,116.71 129.35,116.71 129.36,116.7
  L3 w0.084: 129.36,116.7 131.95,114.11 131.95,102.16 153.02,81.1 153.02,78.01 153.02,76.19 156.37,72.84 158.13,71.08 214.02,71.08 215.47,69.63 217.26,69.63 217.76,69.13 217.76,67.35 220.24,64.87 220.24,52.81 221.23,51.82 234.24,51.82 234.54,51.52 234.54,51.26 234.76,51.04 v3(234.82,51.04)
  BOTTOM w0.089: U4710.C32 238.67,49.96 238.58,50.05 238.21,50.05 237.71,50.55 235.98,50.55 235.96,50.56 235.94,50.56
  BOTTOM w0.107: v3(234.82,51.04) 234.73,51.04 234.61,50.92 234.61,50.67 234.72,50.56 235.94,50.56 ; v1(123.87,120.81) 123.65,120.81 123.54,120.91 123.54,121.06 U4555.F6
DMI_RX1_DP: length 164.5
  L3 w0.076: v3(123.87,121.59) 123.87,121.52 123.42,121.06 123.42,120.42 126.13,117.71 128.08,117.71 129.21,116.58 129.21,116.55
  L3 w0.084: v1(234.13,51.05) 234.33,51.24 234.33,51.24 234.33,51.43 234.15,51.61 221.14,51.61 220.03,52.72 220.03,64.78 217.55,67.26 217.55,69.05 217.17,69.42 215.39,69.42 213.94,70.87 158.04,70.87 156.16,72.75 152.81,76.11 152.81,78.09 152.81,81.01 131.74,102.07 131.74,114.02 129.21,116.55
  BOTTOM w0.076: U4555.E6 v3(123.87,121.59)
  BOTTOM w0.089: 235.94,50.36 236.03,50.36 236.04,50.37 237.64,50.37 238.17,49.84 U4710.B32
  BOTTOM w0.107: 235.94,50.36 234.63,50.36 234.4,50.59 234.4,50.78 v1(234.13,51.05)
DMI_RX2_DN: length 161.7
  L3 w0.076: v1(124.56,120.83) 124.56,120.83 124.95,120.44 125.06,120.44 127.18,118.32 128.65,118.32 129.88,117.08 129.91,117.08 129.92,117.08
  L3 w0.084: 129.92,117.08 132.56,114.44 132.56,103.33 153.62,82.27 153.62,77.76 153.62,77.76 153.62,76.44 156.97,73.09 156.97,73.09 158.38,71.68 214.27,71.68 215.72,70.23 217.51,70.23 218.36,69.38 218.36,67.6 220.88,65.07 220.88,53.93 222.39,52.42 234.67,52.42 234.76,52.33 236.06,52.33 236.36,52.03 236.36,51.73 236.4,51.69 236.4,51.68 v3(236.55,51.54)
  BOTTOM w0.076: U4555.E5 v1(124.56,120.83)
  BOTTOM w0.089: U4710.C31 238.8,50.3 238.48,50.61 238.48,50.69 238.11,51.06 237.03,51.06 v3(236.55,51.54)
DMI_RX2_DP: length 161.7
  L3 w0.076: v1(124.76,119.95) 124.76,120.2 124.83,120.27 124.99,120.27 127.11,118.15 128.58,118.15 129.66,117.07 129.66,117.04 129.71,117 129.71,116.99 129.77,116.93
  L3 w0.084: v1(235.89,51.5) 236.07,51.5 236.15,51.58 236.15,51.94 235.98,52.12 234.67,52.12 234.58,52.21 222.31,52.21 220.67,53.85 220.67,64.98 218.14,67.51 218.14,69.3 217.42,70.02 215.63,70.02 214.18,71.47 158.29,71.47 156.76,73 153.4,76.35 153.4,77.84 153.41,82.19 132.35,103.24 132.35,114.35 129.77,116.93
  BOTTOM w0.076: v1(124.76,119.95) 124.7,120.01 124.7,120.26 U4555.D5
  BOTTOM w0.089: v1(235.89,51.5) 236.04,51.5 236.39,51.15 236.68,51.15 236.96,50.88 238.04,50.88 238.3,50.61 238.3,50.5 U4710.B31
DMI_RX3_DN: length 165.1
  L3 w0.076: v3(122.53,123.19) 122.92,122.8 123.48,122.8 124.86,121.42 125.5,121.42 128.2,118.72 129.16,118.72 130.47,117.41 130.5,117.41 130.51,117.4
  L3 w0.084: v1(236.47,52.78) 236.29,52.96 236.29,53.22 235.8,53.71 232.32,53.71 231.63,53.02 222.7,53.02 221.95,53.77 221.95,64.85 218.95,67.85 218.95,69.63 217.75,70.83 215.97,70.83 214.52,72.28 158.62,72.28 157.57,73.34 154.22,76.69 154.22,77.51 154.22,82.52 133.17,103.57 133.17,114.74 130.51,117.4
  BOTTOM w0.076: U4555.J9 v3(122.53,123.19)
  BOTTOM w0.089: U4710.C29 238.17,51.59 237.84,51.92 237.84,52.1 237.58,52.36 236.38,52.36 236.29,52.44 236.29,52.61 v1(236.47,52.78)
DMI_RX3_DP: length 165
  L3 w0.076: 122.81,122.63 123.41,122.63 124.79,121.25 124.9,121.25 125.43,121.25 128.13,118.56 128.26,118.56 129.09,118.56 130.35,117.3 130.35,117.26 130.36,117.25 ; 122.59,122.53 122.7,122.63
  L3 w0.084: 122.7,122.63 122.81,122.63 ; 130.36,117.25 132.96,114.66 132.96,103.48 154,82.44 154,77.6 154,76.6 157.36,73.25 158.54,72.07 214.43,72.07 215.88,70.62 217.67,70.62 218.74,69.54 218.74,67.76 221.74,64.76 221.74,53.68 222.61,52.81 231.72,52.81 232.4,53.5 235.72,53.5 236.08,53.13 236.08,52.95 235.94,52.81 v3(235.81,52.81) ; v1(122.59,122.4) 122.59,122.53
  BOTTOM w0.076: U4555.J8 122.1,122.36 122.22,122.48 122.51,122.48 v1(122.59,122.4)
  BOTTOM w0.089: v3(235.81,52.81) 235.92,52.81 236.12,52.61 236.12,52.37 236.31,52.18 237.51,52.18 237.66,52.02 237.66,51.84 237.82,51.69 237.82,51.4 237.91,51.31 U4710.B29
DMI_TX0_DN: length 174.3
  L3 w0.084: v3(241.91,49.51) 241.91,49.3 242,49.21 242.39,49.21 242.57,49.39 242.57,52.08 241.82,52.83 241.82,54.71 238.9,57.63 237.54,57.63 237.37,57.63 236.81,58.19 234.66,58.19 232.99,59.86 232.99,60.03 232.99,60.64 231.88,61.76 231.88,71.48 231.88,71.48 231.88,72.04 234.52,74.69 234.52,80.01 234.2,80.32 233.78,80.32 233.14,80.96 232.63,80.96 232.18,81.41 215.36,81.41 214.39,80.45 162.02,80.45 151.71,90.76 151.71,92 147.96,95.75 147.96,101.87 136.05,113.77 136.05,116.93 131.07,121.91 v1(131.02,121.91)
  BOTTOM w0.076: 130.75,122.35 130.73,122.35 130.71,122.37 129.89,122.37 129.85,122.41 127.57,122.41 127.15,122.41 127.07,122.33 126.57,122.33 126.46,122.22 126.46,122.08 126.57,121.97 126.78,121.97 U4555.A8
  BOTTOM w0.107: 130.75,122.35 131.24,122.35 131.3,122.29 131.3,122.11 131.1,121.91 v1(131.02,121.91) ; U4710.K34 241.99,48.53 241.89,48.64 241.89,49.11 241.88,49.12 241.88,49.47 v3(241.91,49.51)
DMI_TX0_DP: length 174.4
  L3 w0.084: v3(131.68,121.91) 131.68,121.61 136.27,117.02 136.27,113.86 148.17,101.95 148.17,95.84 151.92,92.09 151.92,90.85 162.11,80.66 214.31,80.66 215.27,81.63 232.27,81.63 232.72,81.17 233.23,81.17 233.86,80.54 234.29,80.54 234.73,80.1 234.73,74.6 232.09,71.96 232.09,71.57 232.09,61.84 233.2,60.73 233.2,59.95 234.75,58.4 236.9,58.4 237.46,57.84 238.99,57.84 242.03,54.8 242.03,52.92 242.78,52.17 242.78,49.3 242.47,49 241.54,49 v1(241.49,48.95)
  BOTTOM w0.076: U4555.B8 126.3,122.14 126.3,122.29 126.5,122.49 127,122.49 127.08,122.57 127.57,122.57 129.92,122.57 129.96,122.53 130.64,122.53 130.66,122.55 130.75,122.55
  BOTTOM w0.107: 130.75,122.55 131.32,122.55 131.5,122.37 131.5,122.09 v3(131.68,121.91) ; U4710.J35 v1(241.49,48.95)
DMI_TX1_DN: length 162.9
  L3 w0.084: v1(130.76,119.18) 130.76,118.83 131,118.58 131,118.55 131.03,118.53 131.07,118.53 131.15,118.44 131.15,118.28 134.24,115.19 134.24,109.45 142.05,101.64 142.05,96.08 155.2,82.93 155.2,82.11 155.2,77.1 159.03,73.27 214.93,73.27 216.38,71.82 218.43,71.82 219.94,70.3 219.94,68.26 224.75,63.45 227.56,63.45 230.79,60.23 230.79,57.28 232.71,55.36 237.07,55.36 238.69,53.74 238.69,49.63 239.32,49 240.06,49 240.09,48.99 240.09,48.99 v3(240.72,48.82)
  BOTTOM w0.076: 130.62,120.73 130.56,120.79 130.56,120.82 129.42,121.96 127.57,121.96 127.14,121.54 126.06,121.54 125.92,121.4 125.92,121.29 126,121.22 U4555.B6
  BOTTOM w0.107: v3(240.72,48.82) U4710.G33 ; 130.62,120.73 131.03,120.32 131.03,119.45 v1(130.76,119.18)
DMI_TX1_DP: length 163
  L3 w0.084: v1(131.37,118.98) 131.37,118.37 134.33,115.4 134.45,115.28 134.45,109.54 142.26,101.73 142.26,96.17 155.41,83.02 155.41,82.03 155.41,77.19 159.12,73.48 215.02,73.48 216.47,72.03 218.51,72.03 220.15,70.39 220.15,68.34 224.83,63.66 227.65,63.66 227.78,63.54 231,60.32 231,57.37 232.8,55.57 237.16,55.57 238.9,53.83 238.9,49.72 239.41,49.21 240.09,49.21 240.11,49.21 240.15,49.25 v1(240.26,49.64)
  BOTTOM w0.076: 130.77,120.88 130.7,120.94 130.67,120.94 129.49,122.13 127.5,122.13 127.07,121.7 125.99,121.7 125.76,121.47 125.76,121.29 125.68,121.22 U4555.C6
  BOTTOM w0.107: 130.77,120.88 131.24,120.41 131.24,119.1 v1(131.37,118.98) ; U4710.F34 240.26,49.15 v1(240.26,49.64)
DMI_TX2_DN: length 158.5
  L3 w0.076: v3(128.58,121.56) 128.57,121.56 128.33,121.32 128.33,121.13 128.53,120.93 131.29,120.93 132.12,120.1 132.15,120.1 132.17,120.08
  L3 w0.084: v1(241.78,50.57) 241.61,50.57 241.53,50.66 241.53,51 241.11,51.42 241.11,52.37 241.43,52.69 241.43,53.89 241.43,53.89 241.43,54.55 238.74,57.24 237.71,57.24 234.08,57.24 232.2,59.12 232.2,59.82 232.2,60.88 228.08,65 225.19,65 221.35,68.84 221.35,70.93 219.06,73.23 216.96,73.23 215.51,74.68 215.02,74.68 167.05,74.68 151.95,89.77 150.71,89.77 147.57,92.91 147.57,101.71 135.67,113.61 135.67,116.58 132.17,120.08
  BOTTOM w0.076: v3(128.58,121.56) 128.33,121.32 128.33,120.89 128.14,120.7 127.68,120.7 127.61,120.63 126.89,120.63 126.81,120.55 U4555.A5
  BOTTOM w0.107: v1(241.78,50.57) 241.64,50.43 241.64,50.13 241.84,49.93 U4710.K32
DMI_TX2_DP: length 158.6
  L3 w0.076: v1(127.92,121.56) 128.17,121.31 128.17,121.06 128.46,120.77 131.22,120.77 132,119.98 132,119.95 132.02,119.93
  L3 w0.084: 132.02,119.93 135.45,116.5 135.45,113.52 147.36,101.62 147.36,92.82 150.62,89.56 151.86,89.56 166.96,74.47 215.1,74.47 215.43,74.47 216.88,73.02 218.97,73.02 221.14,70.85 221.14,68.75 225.1,64.79 227.99,64.79 231.99,60.8 231.99,59.91 231.99,59.91 231.99,59.03 233.99,57.03 237.12,57.03 237.12,57.03 237.79,57.03 237.79,57.03 238.65,57.03 241.22,54.46 241.22,53.98 241.22,52.78 240.9,52.46 240.9,51.33 241.31,50.91 241.31,50.72 v3(241.11,50.51)
  BOTTOM w0.076: U4555.B5 126.34,120.43 126.7,120.79 127.54,120.79 127.62,120.87 128.08,120.87 128.17,120.96 128.17,121.32 v1(127.92,121.56)
  BOTTOM w0.107: U4710.J32 v3(241.11,50.51)
DMI_TX3_DN: length 160.3
  L3 w0.076: v1(129.24,119.72) 129.37,119.72 129.51,119.87 129.51,120.17 129.73,120.39 130.98,120.39 131.53,119.84 131.56,119.84 131.57,119.83
  L3 w0.084: v3(240.43,51.62) 240.23,51.62 240.1,51.74 240.1,54.87 238.8,56.17 234.3,56.17 231.6,58.87 231.6,60.07 231.6,60.56 228.66,63.5 227.96,64.2 227.96,64.2 227.8,64.37 224.98,64.37 220.75,68.59 220.75,70.69 218.81,72.63 216.72,72.63 215.26,74.08 159.37,74.08 156.01,77.44 156.01,81.78 156.01,81.78 156.01,83.27 142.92,96.36 142.92,102.11 135.05,109.98 135.05,116.35 131.57,119.83
  BOTTOM w0.076: U4555.B4 125.84,119.87 125.92,119.94 126.63,119.94 126.68,119.99 126.95,119.99 127.01,119.93 127.67,119.93 127.97,120.22 129.38,120.22 129.51,120.09 129.51,119.99 v1(129.24,119.72)
  BOTTOM w0.107: v3(240.43,51.62) 240.33,51.51 240.33,51.16 U4710.G30
DMI_TX3_DP: length 160.3
  L3 w0.076: 131.42,119.68 131.41,119.69 131.41,119.72 130.91,120.22 129.8,120.22 129.68,120.1 129.68,119.94 v1(129.9,119.72)
  L3 w0.084: v1(239.91,51.17) 239.89,51.18 239.89,54.78 238.71,55.96 234.21,55.96 231.39,58.78 231.39,60.16 231.39,60.48 228.45,63.41 227.71,64.16 224.89,64.16 220.54,68.5 220.54,70.6 218.72,72.42 216.63,72.42 215.18,73.87 159.28,73.87 155.8,77.35 155.8,81.86 155.8,83.18 142.71,96.27 142.71,102.02 134.84,109.89 134.84,116.26 131.42,119.68
  BOTTOM w0.076: U4555.D4 125.79,120.11 126.56,120.11 126.61,120.15 127.02,120.15 127.08,120.09 127.61,120.09 127.9,120.39 129.45,120.39 129.68,120.16 129.68,119.94 v1(129.9,119.72)
  BOTTOM w0.107: U4710.F30 239.91,51 v1(239.91,51.17)
DMIC__R_DATA: length 3.2
  TOP w0.109: R3000.2 28.57,64.16 v2(28.65,64.24) 29.21,64.8 v1(29.49,64.8)
  BOTTOM w0.109: v1(29.49,64.8) 29.46,64.83 29.46,64.85 29.46,64.85 29.46,66.04 CN5.33
DMIC_CLK: length 21.5
  TOP w0.109: C18.1 20.7,63.8 v1(21.07,63.44) 20.95,63.33 R512.1 ; R3001.1 C3005.1 29.62,61.39 v1(29.26,61.39)
  L10 w0.076: v1(29.26,61.39) 27.96,62.69 27.96,64.39 27.89,64.47 27.54,64.47 27.46,64.39 27.46,63.27 27.39,63.2 27.08,63.2 27,63.27 27,64.39 26.93,64.47 26.62,64.47 26.55,64.39 26.55,63.27 26.47,63.2 26.17,63.2 26.09,63.27 26.09,64.39 26.01,64.47 25.71,64.47 25.63,64.39 25.63,63.27 25.56,63.2 25.25,63.2 25.18,63.27 25.18,64.11 25.04,64.25 23.61,64.25 22.22,62.87 21.64,62.87 v1(21.07,63.44)
DMIC_CLK_R: length 2.9
  TOP w0.109: R512.2 21.48,61.25 v2(21.48,61.06) 20.81,60.39 U500.3
DMIC_DATA: length 23
  TOP w0.109: v1(27.71,61.4) v2(27.71,62.06) 28.26,62.06 C3004.1 R3000.1 ; U500.2 21.21,60.16 v1(21.46,60.4)
  L10 w0.076: v1(27.71,61.4) 27.3,61.8 26.68,61.8 26.58,61.7 26.58,60.51 26.51,60.43 26.2,60.43 26.13,60.51 26.13,61.57 26.05,61.65 25.74,61.65 25.67,61.57 25.67,60.51 25.59,60.43 25.29,60.43 25.21,60.51 25.21,61.57 25.13,61.65 24.83,61.65 24.75,61.57 24.75,60.51 24.68,60.43 24.37,60.43 24.3,60.51 24.3,61.7 24.09,61.9 23.43,61.9 23.22,61.7 23.22,60.51 23.15,60.43 22.84,60.43 22.77,60.51 22.77,61.7 22.69,61.78 22.35,61.78 22.25,61.67 22.25,60.81 22.15,60.71 21.89,60.71 21.79,60.81 21.79,61.65 21.69,61.75 21.38,61.75 21.31,61.67 21.31,60.55 v1(21.46,60.4)
DMIC_R_CLK: length 2.8
  TOP w0.109: v1(29.95,64.42) 29.95,63.38 R3001.2
  BOTTOM w0.109: CN5.32 29.95,65.05 30.04,64.96 30.04,64.51 29.95,64.42 v1(29.95,64.42)
DP_AUX#_GATE: length 6.6
  TOP w0.102: Q51630.3 297.51,54.84 296.9,55.45 v2(296.9,57.58) 297.19,57.28 Q51641.3
DP_AUX_GATE: length 4
  TOP w0.102: v2(304.3,58.33) 303.49,57.52 Q51661.3 303.49,55.68 303.79,55.38 Q51650.3
DP_CABLE_DET: length 28.2
  TOP w0.102: R51670.1 296.03,61.66 296.08,61.61 v1(296.08,61.14) ; v1(298.29,49.64) 298.78,49.15 300.5,49.15 R56200.2 300.83,49.49 D56230.4 D56230.7 303.49,49.49 303.68,49.3 305.14,49.3 306.65,50.81 306.65,52.05 v3(308.66,54.05)
  L3 w0.102: v1(296.08,61.14) 296.08,61.09 297.51,59.67 297.51,50.42 v1(298.29,49.64)
  BOTTOM w0.102: CN56200.4 308.56,54.15 v3(308.66,54.05)
DP_CABLE_DET#: length 3.1
  TOP w0.102: v2(295.86,66.48) 296,66.34 Q51670.2 ; v2(295.86,66.48) 295.5,66.11 Q51670.3 ; v2(295.86,66.48) R51671.1
DP_CABLE_R_DET: length 2
  TOP w0.102: v2(296.85,63.05) 296.71,62.91 R51670.2 296.03,63.31 296,63.35 Q51670.5
DP_CN_HPD: length 60.5
  TOP w0.102: v1(298.29,48.91) 302,48.91 D56230.5 D56230.6 303.26,48.99 303.37,49.1 305.23,49.1 306.85,50.73 306.85,51.96 308.36,53.47 v1(309.24,53.47)
  L10 w0.102: v1(298.29,48.91) 296.74,48.91 296.3,48.47 282.98,48.47 v1(271.7,59.74)
  BOTTOM w0.102: C56261.1 271.57,66.4 R56261.2 ; R56261.2 272.03,66.51 R56281.2 273.03,65.51 274.27,65.51 R56271.2 ; R56261.2 271.7,66.48 v2(271.7,65.64) 271.7,63.5 272.28,62.92 272.28,60.33 v1(271.7,59.74) ; v1(309.24,53.47) 309.24,54.16 308.65,54.75 CN56200.2
DP_IFPB_0: length 208.5
  TOP w0.091: C51627.1 287.25,57.74 286.8,58.18 286.8,61.99 v3(286.85,62.04)
  L10 w0.076: v3(286.85,62.04) 286.22,61.41 275.25,61.41 273.54,63.11 264.83,63.11 263.79,64.15 262.6,64.15 262.3,63.86 260.27,63.86 259.33,64.8 252.42,64.8 252.09,65.13 252.09,66.68 250.48,68.29 236.44,68.29 236.44,68.29 236.06,68.29 234.1,66.33 221.58,66.33 220.06,67.85 220.06,71.02 219.3,71.78 216.7,71.78 215.32,73.16 167.17,73.16 161.62,78.7 161.62,81 155.3,87.32 155.3,87.56 154.67,88.2 154.67,92.19 150.92,95.94 149.47,95.94 142.69,102.72 142.69,111.75 144.65,113.7 144.65,121.11 150.46,126.92 155.36,126.92 155.59,126.69 v4(156.03,126.41)
  BOTTOM w0.091: U50000.BE20 v4(156.03,126.41)
