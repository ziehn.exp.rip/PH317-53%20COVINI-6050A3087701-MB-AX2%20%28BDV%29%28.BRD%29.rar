# Allegro board PH317-53 COVINI-6050A3087701-MB-AX2 (BDV)(.BRD).brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
FBA_CMD12: length 24.3
  BOTTOM w0.137: U50000.AD50 171.1,147.29 170.75,147.64 170.75,147.98 170.52,148.21 170.52,149.95 170.51,149.96 170.51,149.98 170.44,150.05 170.44,151.72 171.5,152.78 171.5,153.78 174.73,157.01 174.73,157.52 178.5,161.29 178.55,161.29 179.23,161.97 179.23,164.33 179.24,164.34 179.24,164.65 179.23,164.66 179.23,165.31 178.98,165.56 178.88,165.56 178.47,165.97 177.91,165.97 177.53,166.35 U50500.M11
FBA_CMD13: length 25.7
  L8 w0.086: v4(174.87,167.44) 175.22,167.09 176.02,167.09 176.36,167.43 v4(177.15,167.43)
  BOTTOM w0.137: v4(174.87,167.44) 174.14,166.71 174.14,157.26 170.99,154.11 170.99,152.84 170.08,151.93 170.08,150.05 170.28,149.85 170.28,148.19 170.05,147.97 170.05,147.68 170.02,147.65 169.7,147.32 U50000.AF50 ; U50500.L12 176.82,167.1 v4(177.15,167.43)
FBA_CMD14: length 27.2
  L8 w0.086: v4(177.86,168.22) 177.48,167.85 174.36,167.85 v4(173.32,166.8)
  BOTTOM w0.109: U50500.J11 177.86,168.27 v4(177.86,168.22) 177.86,168.18 U50500.K11
  BOTTOM w0.137: U50000.AF51 169.7,147.99 170.02,148.31 170.02,149.57 169.77,149.82 169.77,152.15 170.53,152.91 170.53,154.52 173.75,157.74 173.75,166.38 v4(173.32,166.8)
FBA_CMD15: length 26
  L8 w0.086: v4(176.41,168.22) 176,168.63 173.64,168.63 v4(173.29,168.28)
  BOTTOM w0.109: U50500.J12 176.78,168.59 v4(176.41,168.22) U50500.K12
  BOTTOM w0.137: U50000.AF52 169.7,149.46 169.44,149.72 169.44,152.36 170.13,153.04 170.13,154.99 172.9,157.76 172.9,167.89 v4(173.29,168.28)
FBA_CMD16: length 32.5
  L8 w0.086: v1(157.57,169.8) 157.87,170.11 160.73,170.11 v4(161.13,169.7)
  BOTTOM w0.137: v4(161.13,169.7) U50600.L3 ; v1(157.57,169.8) 156.57,169.8 155.82,169.05 155.82,162.52 156.33,162 156.33,158.75 156.56,158.52 156.56,157.4 162.3,151.66 162.99,151.66 164.24,150.41 164.24,148.25 164.45,148.04 164.45,147.62 164.8,147.27 U50000.AN50
FBA_CMD17: length 31.4
  L8 w0.086: v4(158.78,169.11) 158.78,169.11 159.28,168.6 160.03,168.6 v4(160.42,168.21)
  BOTTOM w0.109: U50600.J3 v4(160.42,168.21) 160.78,168.58 U50600.K3
  BOTTOM w0.137: v4(158.78,169.11) 158.77,169.11 158.31,168.65 158.09,168.65 157.99,168.75 157.99,169.02 157.75,169.26 156.61,169.26 156.2,168.85 156.2,163.03 156.83,162.4 156.83,159.15 157.54,158.43 157.54,156.99 162.5,152.03 163.11,152.03 164.48,150.67 164.48,148.35 164.8,148.02 U50000.AN51
FBA_CMD18_RST: length 25.3
  BOTTOM w0.137: U50600.J1 159.23,167.9 158,167.9 157.37,167.27 R50606.1 156.58,167.19 156.58,163.46 157.28,162.76 157.28,159.23 159.01,157.5 159.01,156.35 162.87,152.5 163.12,152.5 164.8,150.82 U50000.AN52
FBA_CMD19: length 29.4
  L8 w0.086: v1(158.24,167.47) 158.62,167.85 161.3,167.85 161.68,168.22 v4(161.91,168.22)
  BOTTOM w0.109: U50600.J4 161.53,167.85 v4(161.91,168.22) 161.53,168.6 U50600.K4
  BOTTOM w0.137: v1(158.24,167.47) 157.95,167.18 157.95,159.48 160.02,157.41 160.02,156.07 165.15,150.94 165.15,146.73 U50000.AM49
FBA_CMD20: length 24.5
  L8 w0.086: v4(161.16,167.47) 161.07,167.47 160.71,167.12 159.3,167.12 v4(158.91,166.72)
  BOTTOM w0.137: U50000.AM52 165.5,151.11 162.15,154.46 162.15,154.48 161.59,155.03 161.59,156.62 158.36,159.85 158.36,166.2 158.89,166.72 v4(158.91,166.72) ; v4(161.16,167.47) U50600.H3
FBA_CMD21: length 21.9
  BOTTOM w0.137: U50600.G4 161.9,166.72 162.5,166.72 163.09,166.13 163.09,164.19 162.66,163.76 162.66,154.4 165.74,151.33 165.74,151.14 165.83,151.05 165.83,148.33 165.5,147.99 U50000.AM51
FBA_CMD22: length 24.4
  L8 w0.086: v4(162.86,166.92) 162.86,168.19 v4(162.84,168.21)
  BOTTOM w0.109: U50600.K5 162.44,168.6 v4(162.84,168.21) 162.48,167.85 U50600.J5
  BOTTOM w0.137: U50000.AM50 165.5,147.32 165.84,147.66 165.84,147.92 166.08,148.16 166.08,151.44 164.32,153.2 164.32,154.4 163.04,155.68 163.04,163.51 163.33,163.79 163.33,166.45 v4(162.86,166.92)
FBA_CMD23: length 25.9
  BOTTOM w0.109: U50600.L5 162.28,169.33 163.22,168.39 163.22,168.3 163.19,168.26 163.19,167.98 162.3,167.1 U50600.H5
  BOTTOM w0.137: 163.22,168.3 163.44,168.09 163.44,166.88 163.61,166.71 163.61,163.54 163.42,163.35 163.42,156.57 164.97,155.02 164.97,153.17 166.32,151.81 166.32,148.21 166.55,147.98 166.55,147.64 166.9,147.29 U50000.AK50
FBA_CMD24: length 25.3
  BOTTOM w0.137: U50600.M4 161.53,170.1 161.91,169.72 163.11,169.72 163.68,169.15 163.68,167 163.75,166.92 163.75,166.9 163.85,166.81 163.85,162.48 163.8,162.43 163.8,157.23 165.55,155.48 165.55,153.19 166.57,152.17 166.57,148.31 166.9,147.98 U50000.AK51
FBA_CMD25: length 26
  BOTTOM w0.137: U50600.M11 166.41,170.47 165.86,170.47 165.71,170.63 164.58,170.63 163.95,169.99 163.95,167.25 164.16,167.04 164.16,166.85 164.18,166.83 164.18,157.84 166.27,155.75 166.27,153.32 166.9,152.69 U50000.AK52
FBA_CMD26_CKE: length 33.7
  TOP w0.137: R50605.1 164.79,168.76 v4(164.83,168.72)
  L8 w0.076: v4(165.54,170.22) 164.93,170.22 164.83,170.12 164.83,169.55 165.08,169.31 165.08,168.97 v4(164.83,168.72) 165.3,168.02 165.3,167.76 v4(165.16,166.85)
  BOTTOM w0.109: U50600.M10 v4(165.54,170.22) ; U50600.G10 v4(165.16,166.85)
  BOTTOM w0.137: v4(164.83,168.72) 164.63,168.92 164.63,169.27 164.78,169.42 164.96,169.42 165.06,169.51 165.06,169.81 164.95,169.92 164.34,169.92 164.2,169.78 164.2,167.42 164.51,167.11 164.51,165.68 164.56,165.64 164.56,158.63 166.75,156.44 166.75,153.38 167.25,152.88 167.25,146.73 U50000.AJ49
FBA_CMD27: length 25.5
  BOTTOM w0.109: U50600.L10 165.93,169.45 165.5,169.45 165.22,169.17 165.22,168.3 165.25,168.28 165.25,168.02 165.26,168.02 165.26,167.71 165.25,167.7 165.25,167.33 165.48,167.1 U50600.H10
  BOTTOM w0.137: U50000.AJ52 167.54,148.53 167.54,153.16 167.29,153.41 167.29,156.85 164.93,159.21 164.93,161.07 164.89,161.11 164.89,165.64 164.77,165.77 164.77,167.32 164.46,167.63 164.46,168.11 164.66,168.3 165.22,168.3
FBA_CMD28: length 20.8
  BOTTOM w0.137: U50000.AJ51 167.6,147.98 167.92,148.3 167.92,148.67 167.8,148.78 167.8,154.04 167.68,154.16 167.68,157.7 165.31,160.06 165.31,161.07 165.2,161.18 165.2,165.3 165.87,165.97 166.41,165.97 U50600.G11
FBA_CMD29: length 25.2
  L8 w0.086: v4(167.16,167.47) 167.31,167.63 168.89,167.63 169.6,167.19 170.05,166.54 v4(170.45,166.11)
  BOTTOM w0.137: v4(167.16,167.47) 167.53,167.1 U50600.H12 ; v4(170.45,166.11) 170.85,165.7 170.85,160.14 168.05,157.34 168.05,148.87 168.17,148.75 168.17,148.16 167.95,147.94 167.95,147.62 167.6,147.27 U50000.AJ50
FBA_CMD30: length 26.8
  BOTTOM w0.109: U50600.K12 167.53,168.6 167.64,168.49 167.64,167.96 167.53,167.85 U50600.J12
  BOTTOM w0.137: 167.64,168.22 167.83,168.22 167.91,168.14 167.91,167.67 168.09,167.49 171.07,167.49 171.27,167.29 171.27,159.72 168.43,156.88 168.43,154.16 168.33,154.06 168.33,149.06 168.42,148.98 168.42,148.23 168.65,147.99 168.65,147.62 169,147.28 U50000.AG50
FBA_CMD31: length 28
  L8 w0.086: v4(166.45,168.22) 166.82,168.59 170.07,168.59 v4(170.17,168.69)
  BOTTOM w0.109: U50600.J11 166.45,168.18 v4(166.45,168.22) 166.45,168.27 U50600.K11
  BOTTOM w0.137: v4(170.17,168.69) 170.4,168.69 171.68,167.4 171.68,159.21 168.86,156.38 168.86,153.7 168.62,153.46 168.62,149.19 168.66,149.15 168.66,148.33 169,147.98 U50000.AG51
FBA_CMD32: length 30.8
  L8 w0.086: v4(173.3,170.23) 174.16,169.37 176.79,169.37 v4(177.16,169.01)
  BOTTOM w0.137: U50000.AF49 169.33,146.74 169.33,149.25 169.14,149.45 169.14,152.59 169.74,153.2 169.74,155.46 172.52,158.23 172.52,169.58 173.17,170.23 v4(173.3,170.23) ; v4(177.16,169.01) 176.82,169.35 U50500.H12
FBA_CMD33: length 27.4
  L8 w0.086: v4(170.27,169.74) 169.89,169.36 167.55,169.36 v4(167.16,168.97)
  BOTTOM w0.137: v4(170.27,169.74) 172.1,167.91 172.1,158.8 169.29,155.98 169.29,153.28 168.88,152.88 168.88,149.33 169,149.21 U50000.AG52 ; v4(167.16,168.97) 167.53,169.35 U50600.L12
FBA_D0: length 33.1
  L8 w0.109: v4(183.91,169.72) 184.29,170.11 186.81,170.11 187.92,168.99 187.92,161.35 185,158.42 184.78,158.42 181.99,155.63 180.48,155.63 175.1,150.25 175.1,148.68 v4(175.62,148.16)
  BOTTOM w0.17: U50500.G2 184.28,170.1 v4(183.91,169.72) ; v4(175.62,148.16) U50000.U51
FBA_D1: length 40.3
  L10 w0.109: v4(176.43,146.02) 176.03,146.42 176.03,146.59 176.03,146.6 176.03,146.88 176.03,146.89 176.03,147.6 175.83,147.8 175.48,147.8 175.47,147.8 175.1,148.17 175.1,151.1 181.74,157.74 184.55,157.74 188.38,161.57 188.38,170.48 186.51,172.35 184.81,172.35 184.81,172.35 183.69,172.35 183.53,172.51 183.53,173.1 v4(183.16,173.47)
  BOTTOM w0.17: U50000.U48 176.02,145.68 v4(176.43,146.02) ; v4(183.16,173.47) 183.53,173.85 U50500.B3
FBA_D2: length 34.1
  L8 w0.109: v4(184.66,170.47) 185.03,170.84 186.44,170.84 186.69,170.59 187.22,170.59 188.66,169.14 188.66,161.45 184.98,157.77 184.77,157.77 182.18,155.18 180.82,155.18 175.9,150.25 175.9,149.29 176.05,149.14 176.05,147.74 v4(176.41,147.37)
  BOTTOM w0.17: v4(176.41,147.37) U50000.U50 ; U50500.F2 184.28,170.85 v4(184.66,170.47)
FBA_D3: length 37.4
  L10 w0.109: v4(183.16,171.97) 183.41,171.97 183.78,171.6 185.89,171.6 187.88,169.62 187.88,161.71 184.36,158.19 181.52,158.19 174.52,151.18 174.52,148.05 174.73,147.83 174.96,147.83 175.27,147.51 175.27,147.11 v4(175.67,146.71)
  BOTTOM w0.17: U50500.E3 183.53,171.6 v4(183.16,171.97) ; U50000.U49 v4(175.67,146.71)
FBA_D4: length 40.8
  L10 w0.109: v4(177.14,148.11) 177.1,148.11 176.85,148.36 176.85,149.07 176.7,149.21 176.7,150.33 183.21,156.83 184.92,156.83 189.37,161.29 189.37,171.66 186.43,174.6 182.99,174.6 182.61,174.22 v4(181.68,174.22)
  BOTTOM w0.17: v4(177.14,148.11) U50000.R51 ; U50500.B4 182.41,174.22 v4(181.68,174.22)
FBA_D5: length 39.5
  L10 w0.109: v4(176.91,146.77) 176.91,146.78 177.32,147.19 177.32,147.61 177.22,147.72 176.92,147.72 176.85,147.79 176.27,147.79 176.02,148.04 176.02,149.17 175.9,149.29 175.9,150.82 179.39,154.31 180.04,154.31 183.02,157.29 184.73,157.29 188.83,161.38 188.83,170.73 185.71,173.85 184.28,173.85 v4(183.91,174.22)
  BOTTOM w0.17: U50000.R50 176.92,146.77 v4(176.91,146.77) ; v4(183.91,174.22) 184.28,173.85 U50500.B2
FBA_D6: length 38.4
  L8 w0.109: v4(183.91,171.22) 184.28,171.6 187.3,171.6 189.25,169.65 189.25,161.24 185.29,157.28 184.92,157.28 182.36,154.73 181.19,154.73 176.7,150.23 176.7,149.21 176.86,149.05 176.86,148.58 176.77,148.49 176.77,147.87 176.93,147.71 177.15,147.71 177.41,147.45 177.41,147.03 177.31,146.93 177.31,145.59 177.05,145.33 v4(177.03,145.33)
  BOTTOM w0.17: v4(177.03,145.33) U50000.R47 ; v4(183.91,171.22) U50500.E2
FBA_D7: length 44.1
  L10 w0.109: v4(176.31,144.59) 176.7,144.98 177.22,144.98 177.39,145.15 177.39,145.53 177.3,145.79 177.3,145.88 177.31,145.88 177.31,146.17 177.3,146.18 177.3,146.59 177.3,146.6 177.3,146.85 177.54,147.1 177.74,147.31 177.74,148.3 177.16,148.88 177.16,150.15 183.39,156.38 185.11,156.38 189.83,161.1 189.83,171.85 186.24,175.43 183.46,175.43 v4(183.16,175.12)
  BOTTOM w0.17: v4(176.31,144.59) U50000.U46 ; U50500.A3 183.53,174.6 v4(183.16,175.12)
FBA_D8: length 41.9
  L3 w0.109: v4(175.6,143.95) 175.6,143.96 175.58,143.97 175.58,144.47 176.09,144.98 176.09,145.49 176.09,145.86 176.08,145.87 176.08,146.17 176.03,146.22 176.03,149.16 175.92,149.27 175.92,152.57 182.25,158.9 182.82,158.9 185.03,161.11 185.03,166.43 184.28,167.18 184.28,172.88 184.06,173.1 181.28,173.1 179.73,174.65 178.33,174.65 177.92,174.23 177.92,174.23 v4(177.93,174.22)
  BOTTOM w0.17: v4(175.6,143.95) 175.6,144.01 175.32,144.28 U50000.V46 ; U50500.B11 177.55,173.85 v4(177.93,174.22)
FBA_D9: length 33.6
  L3 w0.109: v4(176.41,169.72) 176.79,169.34 176.79,167.96 176.95,167.8 177.37,167.8 177.55,167.63 177.55,166.56 178.5,165.61 179.05,165.61 179.26,165.39 179.26,161.46 171.85,154.05 171.85,146.5 172.08,146.27 172.08,145.86 171.88,145.66 171.88,145.32 172.13,145.06 172.87,145.06 173.2,144.73 173.2,143.64 v4(173.55,143.29)
  BOTTOM w0.17: v4(173.55,143.29) 173.84,143.58 U50000.Y45 ; v4(176.41,169.72) U50500.G13
FBA_D10: length 41.2
  L10 w0.109: v4(176.41,171.22) 176.78,170.85 177.37,170.85 177.68,170.53 179.36,170.53 179.85,170.04 179.85,168.38 180.41,167.82 180.41,167.52 181.37,166.56 184.61,166.56 185.03,166.13 185.03,165.07 185.03,165.07 185.03,161.2 183.53,159.69 181.03,159.69 173.13,151.79 173.13,147.93 173.55,147.51 173.55,146.7 173.89,146.37 173.89,146.23 173.89,146.23 173.89,145.94 173.83,145.88 173.83,145.53 173.88,145.49 173.88,145.2 173.83,145.16 173.83,145.13 v4(173.56,144.64)
  BOTTOM w0.17: v4(176.41,171.22) U50500.E13 ; v4(173.56,144.64) U50000.Y47
FBA_D11: length 34.2
  L3 w0.109: v4(175.66,170.47) 176.03,170.1 177.31,170.1 177.53,169.87 177.53,169.53 177.71,169.35 178.12,169.35 178.27,169.2 178.27,167.32 179.73,165.86 179.73,161.17 172.43,153.88 172.43,148.06 173.12,147.37 173.12,146.84 173.12,145.19 173.32,145 173.72,145 173.92,144.79 173.92,144.42 v4(174.3,144.03)
  BOTTOM w0.17: v4(175.66,170.47) U50500.F13 ; U50000.Y46 173.91,144.23 v4(174.3,144.03)
FBA_D12: length 33.7
  L3 w0.109: v4(177.17,171.99) 177.53,172.35 178.89,172.35 181,170.23 181.63,170.23 182.03,169.83 182.03,167.32 182.77,166.59 182.77,165.8 182.78,165.79 182.78,164.63 182.78,164.63 182.78,164.32 182.78,164.32 182.78,161.18 181.85,160.26 181.68,160.26 174.32,152.89 174.32,148.71 174.7,148.33 174.7,147.59 v4(174.87,147.41)
  BOTTOM w0.17: U50000.V50 175.29,147.12 v4(174.87,147.41) ; v4(177.17,171.99) U50500.E12
FBA_D13: length 37.8
  L3 w0.109: v4(177.15,173.48) 177.53,173.1 179.11,173.1 181.53,170.68 182.26,170.68 182.78,170.15 182.78,167.13 183.52,166.39 183.52,165.8 183.53,165.79 183.53,161.16 182.18,159.8 181.87,159.8 174.95,152.89 174.95,148.92 175.21,148.67 175.21,148.04 175.28,147.96 175.28,144.92 v4(174.99,144.63)
  BOTTOM w0.17: v4(174.99,144.63) 175.3,144.94 U50000.V47 ; v4(177.15,173.48) U50500.B12
FBA_D14: length 41.5
  L3 w0.109: v4(175.66,174.22) 176.03,174.59 176.03,175.23 176.24,175.44 179.77,175.44 181.36,173.85 184.84,173.85 185.03,173.66 185.03,167.04 185.92,166.15 185.92,161.26 183.11,158.45 182.57,158.45 176.68,152.56 176.68,149.08 v4(176.45,148.85)
  BOTTOM w0.17: v4(175.66,174.22) U50500.B13 ; v4(176.45,148.85) 176.04,148.48 U50000.U52
FBA_D15: length 38.3
  L3 w0.109: v4(175.48,149.52) 175.41,149.59 175.41,152.7 182.06,159.35 182.51,159.35 184.27,161.12 184.27,166.5 183.53,167.24 183.53,172.21 183.4,172.34 181.06,172.34 179.55,173.85 176.89,173.85 176.79,173.95 176.79,174.59 v4(176.41,174.97)
  BOTTOM w0.17: v4(176.41,174.97) U50500.A12 ; v4(175.48,149.52) 174.9,148.94 174.9,148.18 U50000.V51
FBA_D16: length 27.7
  L8 w0.109: v4(167.31,142.53) 167.43,142.7 167.63,143.05 167.67,143.72 167.6,144.48 167.6,146.38 167.38,147.1 167.38,153.98 173.92,160.51 173.92,164.29 174.47,164.85 175.28,164.85 v4(175.66,165.22)
  BOTTOM w0.17: v4(167.31,142.53) U50000.AJ44 ; U50500.P13 v4(175.66,165.22)
FBA_D17: length 20.2
  L3 w0.109: v4(175.66,162.22) 175.28,161.85 174.57,161.85 174.01,161.29 174.01,159.82 169.58,155.38 169.58,146.29 169.31,146.02 v4(169.31,146.02)
  BOTTOM w0.17: U50000.AG48 169,145.71 169.31,146.02 v4(169.31,146.02) ; v4(175.66,162.22) U50500.U13
FBA_D18: length 28.4
  L3 w0.109: v4(168.02,143.19) 167.7,143.51 167.7,144.27 167.62,144.35 167.62,146.29 167.78,146.45 167.78,156.33 170.78,159.33 170.78,161.85 174.56,165.62 174.56,166.06 174.76,166.27 175.2,166.27 v4(175.66,166.72)
  BOTTOM w0.17: v4(175.66,166.72) U50500.M13 ; U50000.AJ45 167.99,143.19 v4(168.02,143.19)
FBA_D19: length 24.5
  L3 w0.109: v4(176.41,165.97) 176.04,165.61 176.04,165.04 175.87,164.86 174.43,164.86 172.54,162.97 172.54,160.17 168.38,156.01 168.38,147.82 168.65,147.55 v4(168.65,146.73)
  BOTTOM w0.17: v4(168.65,146.73) U50000.AG49 ; v4(176.41,165.97) U50500.N13
FBA_D20: length 23.3
  L3 w0.109: v4(169.96,143.97) 169.86,144.07 169.86,146.13 170.04,146.31 170.29,146.31 170.97,147 170.97,147.47 170.18,148.26 170.18,154.92 176.3,161.04 176.59,161.04 176.78,161.23 176.78,161.85 v4(177.16,162.22)
  BOTTOM w0.17: v4(177.16,162.22) U50500.U12 ; v4(169.96,143.97) 169.7,144.23 U50000.AF46
FBA_D21: length 25
  L3 w0.109: v4(169.3,144.66) 168.95,145.01 168.95,146.34 169.08,146.48 169.08,147.6 168.98,147.7 168.98,155.73 173.11,159.86 173.11,162.59 174.63,164.1 176.03,164.1 v4(176.41,164.47)
  BOTTOM w0.17: U50500.P12 v4(176.41,164.47) ; U50000.AF47 169.67,144.98 169.33,144.65 v4(169.3,144.66)
FBA_D22: length 20.3
  L8 w0.109: v4(170.23,145.96) 170.23,146.2 170.47,146.44 170.47,146.82 169.29,147.99 169.29,153.1 176.51,160.31 176.51,161.37 v4(176.41,161.47)
  BOTTOM w0.17: v4(170.23,145.96) U50000.AF48 ; U50500.V12 v4(176.41,161.47)
FBA_D23: length 23.4
  L8 w0.109: v4(170.8,144.66) 170.84,144.7 170.84,144.72 171.06,145.64 171.14,145.72 171.14,146.21 170.98,146.37 170.98,147.59 169.96,148.6 169.96,152.88 178.31,161.23 178.31,162.54 v4(177.89,162.96)
  BOTTOM w0.17: U50000.AD47 171.1,144.96 v4(170.8,144.66) ; U50500.U11 v4(177.89,162.96)
FBA_D24: length 27.8
  L10 w0.109: v4(184.66,165.24) 184.32,165.57 182.16,165.57 182.02,165.44 182.02,164.99 181.91,164.88 181.2,164.88 179.81,163.49 179.81,161.67 170.59,152.45 v4(170.59,147.26)
  BOTTOM w0.17: v4(184.66,165.24) 184.3,165.6 U50500.N2 ; v4(170.59,147.26) 170.59,147.08 171.1,146.57 U50000.AD49
FBA_D25: length 27
  L10 w0.109: v4(183.17,165.21) 183.17,165.21 182.79,164.84 182.79,164.25 182.64,164.1 181.12,164.1 180.4,163.38 180.4,161.63 171.15,152.37 171.15,147.96 170.98,147.8 170.98,146.7 171.45,146.22 171.45,145.44 v4(171.38,145.37)
  BOTTOM w0.17: U50000.AD48 171.38,145.39 v4(171.38,145.37) ; v4(183.17,165.21) 183.17,165.21 183.53,164.85 U50500.P3
FBA_D26: length 31.3
  L10 w0.109: v4(171.49,143.94) 171.49,143.99 171.25,144.23 171.25,144.88 170.86,145.27 170.86,145.58 171.12,145.83 171.12,146.23 170.55,146.8 170.49,146.8 170.14,147.15 170.14,152.64 179.27,161.77 179.27,163.85 181.31,165.89 182.49,165.89 182.93,166.33 183.52,166.33 v4(183.89,165.96)
  BOTTOM w0.17: U50000.AC46 171.8,144.25 v4(171.49,143.94) ; v4(183.89,165.96) 184.28,166.35 U50500.M2
FBA_D27: length 27.3
  L10 w0.109: v4(183.91,164.47) 183.53,164.1 183.53,163.55 183.33,163.35 181.42,163.35 181.15,163.08 181.15,161.73 171.63,152.21 171.63,147.68 171.37,147.43 171.37,146.61 171.85,146.13 171.85,144.93 172.09,144.69 v4(172.09,144.69)
  BOTTOM w0.17: v4(183.91,164.47) 184.28,164.85 U50500.P2 ; U50000.AC47 172.09,144.69 v4(172.09,144.69)
FBA_D28: length 24
  L10 w0.109: v4(183.16,162.22) 182.78,161.85 182.78,161.07 182.68,160.96 181.02,160.96 172.13,152.08 172.13,147.46 171.86,147.19 171.86,146.7 172.08,146.48 172.23,146.48 172.52,146.2 v4(172.52,145.93)
  BOTTOM w0.17: v4(183.16,162.22) U50500.U3 ; v4(172.52,145.93) 172.82,145.32 U50000.AA47
FBA_D29: length 24.6
  L10 w0.109: v4(183.91,161.47) 182.84,160.4 181.1,160.4 172.63,151.94 172.63,147.83 173.12,147.34 173.12,146.84 173.12,144.8 173.14,144.78 173.14,144.49 173.12,144.48 173.12,144.35 173.12,144.27 172.84,143.99 v4(172.84,143.95)
  BOTTOM w0.17: U50000.AA46 173.2,144.25 172.84,143.95 v4(172.84,143.95) ; v4(183.91,161.47) 183.53,161.85 U50500.V3
FBA_D30: length 26.8
  L8 w0.109: v4(182.41,162.97) 182.03,162.6 181.47,162.6 180.63,161.76 180.63,161.39 171.5,152.25 171.5,148.66 171.83,148.33 171.83,146.66 172.15,146.33 172.64,146.33 173,145.98 173,145.34 173.21,145.13 173.21,143.64 v4(172.83,143.26)
  BOTTOM w0.17: U50000.AA45 173.04,143.31 v4(172.83,143.26) ; v4(182.41,162.97) U50500.U4
FBA_D31: length 26.8
  L8 w0.109: v4(174.23,142.51) 173.94,142.81 173.94,144.96 173.89,145.01 173.89,145.94 173.89,145.94 173.89,146.23 173.89,146.23 173.89,146.37 173.53,146.73 173.53,148.01 173.22,148.31 173.22,151.37 182.48,160.63 183.94,160.63 184.28,160.97 184.28,161.84 v4(184.66,162.22)
  BOTTOM w0.17: v4(174.23,142.51) 174.23,142.55 U50000.Y44 ; v4(184.66,162.22) 184.28,162.6 U50500.U2
FBA_D32: length 17.5
  L3 w0.109: v4(160.34,148.11) 160.12,148.11 159.51,148.73 159.51,150.49 158.94,151.05 158.94,159.13 160.78,160.97 U50600.B3 v4(161.16,162.97)
  BOTTOM w0.17: v4(161.16,162.97) U50600.B3 ; U50000.AW51 160.6,147.85 v4(160.34,148.11)
FBA_D33: length 20
  L8 w0.109: v4(160.41,165.22) 160.63,165.22 161.01,164.85 161.3,164.85 161.53,164.62 161.53,160.43 158.18,157.08 158.18,150.38 158.57,149.99 v4(158.93,149.99)
  BOTTOM w0.17: U50000.BA52 159.2,148.86 159.11,149.37 v4(158.93,149.99) ; v4(160.41,165.22) U50600.E2
FBA_D34: length 20.8
  L3 w0.109: v4(161.16,164.47) 160.78,164.09 160.78,163.56 160.98,163.35 161.35,163.35 161.53,163.17 161.53,160.36 159.76,158.59 159.76,151 160.53,150.24 160.53,148.91 160.83,148.61 160.83,147.24 v4(160.31,146.72)
  BOTTOM w0.17: U50600.E3 v4(161.16,164.47) ; v4(160.31,146.72) 160.6,147.01 U50000.AW50
FBA_D35: length 17
  L3 w0.109: v4(160.41,161.47) 158.07,159.14 158.07,150.2 158.87,149.4 158.87,148.21 v4(159.72,147.35)
  BOTTOM w0.17: U50600.A3 v4(160.41,161.47) ; v4(159.72,147.35) 159.69,147.39 159.28,147.78 U50000.BA51
FBA_D36: length 26.7
  L8 w0.109: v4(160.41,166.72) 160.2,166.72 159.82,166.35 158.66,166.35 157.68,165.36 157.68,160.92 155.18,158.43 155.18,150.02 156.28,148.92 156.28,148.69 156.95,148.03 156.95,147.21 157.86,146.3 158.37,146.3 158.54,146.41 158.8,146.7 v4(158.8,146.71)
  BOTTOM w0.17: U50000.BA50 158.82,146.71 v4(158.8,146.71) ; U50600.G2 v4(160.41,166.72)
FBA_D37: length 23.2
  L8 w0.109: v4(159.66,165.97) 159.46,165.97 159.09,165.6 158.66,165.6 158.58,165.51 158.36,165.29 158.21,165.15 158.21,160.4 155.87,158.06 155.87,150.3 157.88,148.29 157.88,147.97 157.7,147.79 v4(157.59,147.08)
  BOTTOM w0.17: v4(159.66,165.97) U50600.F2 ; v4(157.59,147.08) U50000.BB50
FBA_D38: length 20.6
  L3 w0.109: v4(159.57,146) 159.3,146.27 159.3,146.87 159.09,147.08 158.51,147.08 158.34,147.25 158.34,147.82 157,149.15 157,159.01 159.3,161.3 159.3,162.61 v4(159.66,162.97)
  BOTTOM w0.17: U50000.BA49 159.23,146.38 v4(159.57,146) ; v4(159.66,162.97) U50600.B2
FBA_D39: length 18.4
  L3 w0.109: v4(160.9,146.08) 161.18,146.36 161.18,148.62 160.83,148.97 160.83,150.49 160.49,150.83 160.49,158.58 162.33,160.41 162.33,161.8 v4(161.91,162.22)
  BOTTOM w0.17: v4(160.9,146.08) U50000.AW49 ; v4(161.91,162.22) 161.53,162.6 U50600.B4
FBA_D40: length 26.4
  L10 w0.109: v4(161.64,145.38) 161.27,145.75 161.27,146.35 160.72,146.9 160.72,150.43 160.21,150.94 160.21,157.02 164.57,161.38 164.57,164.02 165.39,164.84 165.89,164.84 166.04,164.99 166.04,165.06 166.04,165.06 166.04,165.46 166.18,165.6 167.31,165.6 167.31,165.6 167.53,165.6 v4(167.91,165.22)
  BOTTOM w0.17: v4(167.91,165.22) U50600.E13 ; U50000.AV48 161.35,145.68 v4(161.64,145.38)
FBA_D41: length 23.5
  L8 w0.109: v4(168.67,165.99) 168.67,165.76 169.08,165.35 169.08,161.94 169.25,161.77 169.25,161.25 163.02,155.02 163.02,148.63 162.58,148.19 162.58,147.07 162.3,146.79 v4(162.3,146.75)
  BOTTOM w0.17: v4(162.3,146.75) 162.33,146.75 U50000.AT49 ; v4(168.67,165.99) U50600.F13
FBA_D42: length 21.8
  L10 w0.109: v4(162.19,144.49) 162.22,144.49 162.68,144.95 162.68,145.17 162.69,145.17 162.69,145.46 162.68,147.36 162.4,147.64 162.4,148.17 163,148.77 163,150.91 162.8,151.11 162.8,156.41 167.53,161.14 167.53,161.85 v4(167.91,162.22)
  BOTTOM w0.17: U50000.AT47 162.19,144.47 162.19,144.48 162.19,144.48 v4(162.19,144.49) ; v4(167.91,162.22) U50600.B13
FBA_D43: length 21.7
  L8 w0.109: v4(162.32,145.88) 162.2,145.75 161.39,145.75 161.27,145.87 161.27,146.79 161.16,146.9 161.16,147.61 161.31,147.76 161.31,148.55 160.88,148.98 160.88,150.52 160.5,150.9 160.5,155.58 165.19,160.27 165.19,161.52 165.5,161.83 166.02,161.83 v4(166.39,162.21)
  BOTTOM w0.17: v4(162.32,145.88) U50000.AT48 ; v4(166.39,162.21) U50600.B11
FBA_D44: length 27
  L8 w0.109: v4(162.98,143.97) 162.01,143.59 160.87,143.59 160.63,143.83 160.63,144.26 160.57,144.32 160.57,145.42 160.54,145.72 160.54,146.17 160.7,146.56 160.7,148.02 160.7,148.04 160.7,148.53 160.45,149.02 160.45,150.24 159.92,150.78 159.92,156.04 164.26,160.39 164.26,161.84 165.03,162.61 166.79,162.61 v4(167.16,162.97)
  BOTTOM w0.17: v4(167.16,162.97) 167.53,162.6 U50600.B12 ; v4(162.98,143.97) U50000.AT46
FBA_D45: length 21
  L10 w0.109: v4(167.16,164.47) 166.94,164.47 166.57,164.1 165.48,164.1 165.09,163.71 165.09,160.9 161.01,156.82 161.01,153.29 161.38,152.92 161.38,150.43 v4(161.32,150.37)
  BOTTOM w0.17: U50000.AV51 161.71,148.19 161.71,149.98 v4(161.32,150.37) ; U50600.E12 167.53,164.85 v4(167.16,164.47)
FBA_D46: length 16.2
  L10 w0.109: v4(161.29,149.08) 161.99,149.78 161.99,156.7 166.21,160.92 166.6,160.92 v4(167.16,161.47)
  BOTTOM w0.17: U50000.AV52 161.3,149.07 v4(161.29,149.08) ; v4(167.16,161.47) 167.53,161.85 U50600.A12
FBA_D47: length 26.2
  L10 w0.109: v4(160.02,149.43) 159.38,150.07 159.38,156.93 163.98,161.52 163.98,164.38 165.13,165.54 165.44,165.54 166.25,166.34 167.52,166.34 v4(167.91,166.72)
  BOTTOM w0.17: v4(160.02,149.43) 160.73,148.82 160.74,148.82 160.94,148.62 160.94,146.74 U50000.AV49 ; v4(167.91,166.72) U50600.G13
FBA_D48: length 37.2
  L10 w0.109: v4(167.97,145.96) 167.97,146.99 167.86,147.1 167.86,147.56 168.2,147.91 168.2,153.62 174.37,159.79 174.37,171.29 170.94,174.73 168.52,174.73 168.03,174.24 167.92,174.24 v4(167.91,174.22)
  BOTTOM w0.17: U50000.AJ48 167.69,145.68 v4(167.97,145.96) ; v4(167.91,174.22) U50600.U13
FBA_D49: length 39.7
  L10 w0.109: v4(166.41,174.22) 166.58,174.22 166.95,173.86 169.04,173.86 169.1,173.92 170.4,173.92 172.74,171.58 173.35,171.58 173.76,171.17 173.76,160.12 167.59,153.94 167.59,148.31 167.37,147.68 167.37,146.9 167.61,146.13 167.61,146.11 167.61,146.11 167.61,145.81 167.61,145.81 167.61,144.31 167.56,144.12 v4(167.28,143.97)
  BOTTOM w0.17: U50000.AJ46 167.29,143.97 v4(167.28,143.97) ; v4(166.41,174.22) U50600.U11
FBA_D50: length 42.2
  L10 w0.109: v4(167.16,174.97) 167.16,175.34 167.5,175.68 171.27,175.68 174.6,172.35 175.06,172.35 175.07,172.34 175.09,172.34 175.28,172.15 175.28,171.82 175.28,171.82 175.28,159.9 168.75,153.36 168.75,147.4 169.03,147.11 169.03,146.39 168.95,146.31 168.95,145.15 168.43,144.62 v4(168.02,144.62)
  BOTTOM w0.17: U50600.V12 167.53,174.6 v4(167.16,174.97) ; v4(168.02,144.62) 167.66,144.98 U50000.AJ47
FBA_D51: length 31.1
  L10 w0.109: v4(166.55,146.72) 166.58,146.77 166.44,147.22 166.44,154.69 172.38,160.63 172.38,169.63 170.41,171.6 169.03,171.6 v4(168.66,171.97)
  BOTTOM w0.17: v4(166.55,146.72) U50000.AK49 ; v4(168.66,171.97) U50600.P13
FBA_D52: length 33
  L10 w0.109: v4(167.91,171.22) 168.11,171.22 168.47,170.86 170.02,170.86 171.84,169.04 171.84,160.88 165.8,154.83 165.8,147.64 165.63,147.48 165.63,145.66 165.58,145.53 165.55,145.51 165.55,145.31 165.15,144.64 v4(165.16,144.62)
  BOTTOM w0.17: U50000.AM47 165.18,144.65 v4(165.16,144.62) ; v4(167.91,171.22) 167.53,171.6 U50600.P12
FBA_D53: length 37.2
  L10 w0.109: v4(167.16,173.47) 167.33,173.47 167.71,173.1 169.84,173.1 172.92,170.02 172.92,160.27 167,154.35 167,146.5 166.76,146.09 166.76,145.76 166.54,144.49 166.13,144.07 v4(165.89,143.94)
  BOTTOM w0.17: v4(167.16,173.47) 167.53,173.85 U50600.U12 ; v4(165.89,143.94) U50000.AM46
FBA_D54: length 29.5
  L10 w0.109: v4(165.16,146.08) 165.11,146.71 165.11,154.99 171.36,161.24 171.36,168.08 169.85,169.59 169.85,169.91 169.64,170.12 169.01,170.12 v4(168.66,170.47)
  BOTTOM w0.17: v4(165.16,146.08) U50000.AN48 ; U50600.N13 v4(168.66,170.47)
FBA_D55: length 28.5
  L10 w0.109: v4(164.5,146.67) 164.53,146.71 164.53,155.24 170.83,161.54 170.83,167.39 169.62,168.6 168.44,168.6 168.28,168.76 168.28,169.35 v4(167.91,169.72)
  BOTTOM w0.17: v4(164.5,146.67) 164.5,146.67 U50000.AN49 ; v4(167.91,169.72) U50600.M13
FBA_D56: length 39.9
  L3 w0.109: v4(160.41,174.22) 160.78,174.6 162.9,174.6 164.55,172.95 164.55,171.71 165.01,171.26 165.01,169.9 165.26,169.65 165.26,167.33 166.21,166.38 167.34,166.38 167.53,166.19 167.53,158.46 166.16,157.09 166.16,148.69 166.51,148.34 166.51,147.29 165.93,146.71 165.93,145.85 166.29,145.49 166.29,145.16 166.12,144.99 166.01,144.99 165.53,144.51 165.53,142.85 v4(165.85,142.53)
  BOTTOM w0.17: U50000.AM44 165.5,142.88 165.85,142.53 v4(165.85,142.53) ; v4(160.41,174.22) U50600.V3
FBA_D57: length 43.6
  L8 w0.109: v4(165.16,143.21) 165.54,143.59 165.54,146.47 164.99,147.02 164.99,148.13 165.45,148.59 165.45,154.7 171.5,160.75 171.5,169.79 169.69,171.6 167.7,171.6 167.53,171.77 167.53,173.69 167.37,173.85 165.82,173.85 165.06,174.62 162.3,174.62 v4(161.91,174.22)
  BOTTOM w0.17: v4(165.16,143.21) U50000.AM45 ; v4(161.91,174.22) 161.53,173.85 U50600.U4
FBA_D58: length 38.2
  L3 w0.109: v4(159.66,173.47) 159.28,173.1 158.57,173.1 158.02,172.55 158.02,168.4 157.79,168.17 157.79,165.7 158.64,164.85 161.41,164.85 161.52,164.74 161.52,164.28 161.7,164.1 162.14,164.1 162.8,163.44 162.8,160.03 161.57,158.79 161.57,150.93 161.93,150.57 161.93,148.16 162.71,147.38 162.71,144.83 164.32,143.22 v4(164.43,143.22)
  BOTTOM w0.17: U50000.AN45 164.44,143.22 v4(164.43,143.22) ; v4(159.66,173.47) U50600.U2
FBA_D59: length 35.2
  L3 w0.109: v4(164.42,143.96) 164.78,144.32 164.78,144.79 164.97,144.99 165.3,144.99 165.53,145.22 165.53,146.23 165.53,146.23 165.53,157.38 166.78,158.63 166.78,165.37 166.57,165.58 166.17,165.58 165.38,166.37 165.05,166.37 164.84,166.58 164.77,166.71 164.77,166.82 164.53,167.4 164.35,167.85 164.35,171.09 163.65,171.79 163.65,172.42 162.97,173.1 161.53,173.1 v4(161.16,173.47)
  BOTTOM w0.17: v4(161.16,173.47) U50600.U3 ; U50000.AN46 164.74,144.28 v4(164.42,143.96)
FBA_D60: length 28.8
  L3 w0.109: v4(163.7,145.98) 164.11,146.39 164.11,146.88 164.36,147.14 164.36,158 165.03,158.67 165.03,164.63 164.1,165.56 164.1,166.03 163.9,166.41 163.73,166.73 163.73,166.97 163.27,168.04 163.27,168.34 161.52,170.1 160.95,170.1 160.78,170.27 160.78,170.85 v4(160.41,171.22)
  BOTTOM w0.17: v4(160.41,171.22) U50600.P2 ; v4(163.7,145.98) U50000.AR48
FBA_D61: length 31
  L3 w0.109: v4(161.16,171.97) 161.53,171.6 162.29,171.6 163.76,170.12 163.76,168.05 164.18,167.06 164.18,166.84 164.29,166.64 164.55,166.14 164.55,165.75 165.47,164.83 165.92,164.83 166.02,164.73 166.02,158.74 164.91,157.64 164.91,146.45 164.77,146.3 164.77,145.75 v4(164.39,145.37)
  BOTTOM w0.17: v4(161.16,171.97) U50600.P3 ; U50000.AN47 164.8,145.01 v4(164.39,145.37)
FBA_D62: length 28.5
  L3 w0.109: v4(160.41,169.72) 160.78,169.35 160.78,168.09 161.01,167.86 162.55,167.86 163.09,167.32 163.24,166.96 163.24,166.68 163.58,166.03 163.58,165.44 164.22,164.8 164.22,158.73 163.65,158.16 163.65,150.65 163.9,150.4 163.9,148.52 163.22,147.84 163.22,145.42 v4(163.08,145.28)
  BOTTOM w0.17: v4(163.08,145.28) U50000.AR47 ; v4(160.41,169.72) U50600.M2
FBA_D63: length 45.1
  L8 w0.109: v4(163.78,144.58) 164.1,144.9 164.21,144.9 164.26,144.96 164.52,144.96 164.78,145.21 164.78,146.13 164.61,146.29 164.34,146.29 164.13,146.5 164.13,146.93 164.43,147.23 164.43,148.41 164.79,148.77 164.79,154.9 170.88,161 170.88,169.9 169.92,170.85 166.96,170.85 166.78,171.03 166.78,172.91 166.6,173.09 166.1,173.09 165.89,173.3 165.2,173.3 162.76,170.86 160.04,170.86 v4(159.66,170.47)
  BOTTOM w0.17: v4(163.78,144.58) U50000.AR46 ; v4(159.66,170.47) U50600.N2
FBA_DBI0: length 38.9
  L8 w0.109: v4(183.91,172.72) 183.91,172.5 183.53,172.12 183.53,169.51 183.7,169.34 185.55,169.34 185.9,168.99 186.48,168.99 187.17,168.3 187.17,164.98 186.97,164.77 186.97,161.03 185.12,159.18 183.04,159.18 174.62,150.77 174.62,148.4 175.24,147.78 175.24,147.24 175.41,147.07 175.82,147.07 176.02,146.87 176.02,146.33 176.08,146.27 176.08,145.87 176.08,145.87 176.08,145.65 v4(175.74,145.31)
  BOTTOM w0.17: U50000.U47 176,145.01 175.74,145.27 v4(175.74,145.31) ; v4(183.91,172.72) 184.28,172.35 U50500.D2
FBA_DBI1: length 33.8
  L3 w0.109: v4(175.66,171.97) 176.03,171.6 176.03,171.04 176.23,170.85 177.68,170.85 178.33,170.2 178.33,169.87 179.2,169 179.2,167.02 180.18,166.05 180.18,160.99 180.16,160.97 180.16,160.64 173.09,153.58 173.09,148.19 173.55,147.73 173.55,146.72 173.9,146.37 173.9,146.09 173.89,146.08 173.89,145.79 173.9,145.78 173.9,145.7 174.24,145.36 v4(174.24,145.34)
  BOTTOM w0.17: v4(175.66,171.97) U50500.D13 ; U50000.Y48 173.93,145.68 174.24,145.37 v4(174.24,145.34)
FBA_DBI2: length 23.5
  L8 w0.109: v4(168.58,145.39) 168.6,145.41 168.64,145.41 168.94,145.72 168.94,146.12 168.72,146.34 168.5,146.34 167.82,147.02 167.82,147.63 167.96,147.77 167.96,153.6 175.28,160.93 175.28,163.35 v4(175.66,163.72)
  BOTTOM w0.17: U50500.R13 v4(175.66,163.72) ; v4(168.58,145.39) U50000.AG47
FBA_DBI3: length 26.3
  L8 w0.109: v4(184.65,163.73) 184.28,164.1 182.96,164.1 182.78,163.92 182.78,162.82 182.78,162.82 182.78,162.01 182.62,161.85 181.49,161.85 181.22,161.58 181.22,161.1 171.98,151.87 171.98,148.91 172.24,148.65 v4(172.24,146.88)
  BOTTOM w0.17: v4(172.24,146.88) 172.15,146.78 172.15,146.03 U50000.AC48 ; U50500.R2 184.28,164.1 v4(184.65,163.73)
FBA_DBI4: length 19.8
  L8 w0.109: v4(159.66,164.47) 160.03,164.1 160.55,164.1 160.78,163.86 160.78,160.96 157.39,157.57 v4(157.39,150.28)
  BOTTOM w0.17: v4(157.39,150.28) 157.39,149.01 157.55,148.67 158.3,147.93 U50000.BB51 ; U50600.D2 v4(159.66,164.47)
FBA_DBI5: length 21.8
  L8 w0.109: v4(161.63,147.41) 161.99,147.77 161.99,148.55 161.7,148.84 161.7,150.57 161.43,150.84 161.43,155.08 167.27,160.91 167.53,161.17 167.53,163.99 167.64,164.1 168.32,164.1 v4(168.68,164.46)
  BOTTOM w0.17: v4(168.68,164.46) 168.64,164.46 U50600.D13 ; U50000.AV50 v4(161.63,147.41)
FBA_DBI6: length 34.1
  L8 w0.109: v4(167.91,172.72) 168.28,172.35 170.08,172.35 172.15,170.28 172.15,160.51 166.06,154.43 166.06,148.1 165.6,147.64 165.6,147.13 165.93,146.79 165.93,145.38 v4(165.91,145.36)
  BOTTOM w0.17: U50000.AM48 v4(165.91,145.36) ; U50600.R13 v4(167.91,172.72)
FBA_DBI7: length 30.3
  L3 w0.109: v4(159.66,171.97) 159.28,171.6 159.28,165.8 159.48,165.6 162.03,165.6 163.3,164.33 163.3,159.65 162.26,158.62 162.26,151.04 v4(162.54,150.76)
  BOTTOM w0.17: v4(162.54,150.76) 163.01,150.29 163.01,148.64 163.04,148.62 163.04,146.74 U50000.AR49 ; v4(159.66,171.97) U50600.R2
FBA_DEBUG0: length 8.4
  BOTTOM w0.102: 174.49,148.16 174.49,149.04 175.51,150.05 177.53,150.05 179.32,151.84 R50120.1
  BOTTOM w0.109: 174.49,148.16 174.27,147.93 174.27,147.7 173.9,147.33 U50000.Y50
FBA_DEBUG1: length 8.1
  BOTTOM w0.102: U50000.AR50 163.4,147.33 163.72,147.65 163.72,147.94 164.02,148.23 164.02,150.28 163.02,151.28 160.71,151.28 160.22,151.77 R50121.1
FBA_EDC0: length 37.9
  L8 w0.109: v4(184.66,173.47) 184.86,173.47 185.24,173.1 185.7,173.1 186.39,172.4 187.14,172.4 189.86,169.68 189.86,161.21 185.48,156.83 185.16,156.83 182.01,153.67 181.04,153.67 177.16,149.79 177.16,148.87 177.82,148.21 177.82,147.25 178.02,147.05 178.02,146.36 v4(177.66,146.01)
  BOTTOM w0.17: U50500.C2 184.28,173.1 v4(184.66,173.47) ; v4(177.66,146.01) 177.65,146.01 U50000.R48
FBA_EDC1: length 35.3
  L3 w0.109: v4(176.41,172.72) 176.79,172.34 176.79,171.82 177.01,171.6 178.89,171.6 181.48,169 181.48,167.49 182.03,166.94 182.03,161.24 173.69,152.9 173.69,148.56 174.16,148.09 174.16,146.65 174.77,146.04 174.77,145.97 174.78,145.97 174.78,145.96 v4(174.79,145.95)
  BOTTOM w0.17: U50000.V48 175.07,145.68 174.8,145.95 v4(174.79,145.95) ; v4(176.41,172.72) U50500.C13
FBA_EDC2: length 25.3
  L8 w0.109: v4(176.41,162.97) 176.01,162.58 176.01,160.75 168.61,153.35 168.61,147.8 169.31,147.1 169.31,146.79 169.76,146.34 169.76,144.49 169.6,144.33 169.6,143.69 169.65,143.47 169.65,143.13 169.79,142.89 v4(170.01,142.57)
  BOTTOM w0.17: v4(170.01,142.57) U50000.AF44 ; U50500.T13 v4(176.41,162.97)
FBA_EDC3: length 23.7
  L8 w0.109: v4(183.91,162.97) 183.53,162.6 183.53,161.26 183.36,161.09 182.16,161.09 172.62,151.55 172.62,147.82 173.15,147.3 173.15,146.48 v4(173.54,146.08)
  BOTTOM w0.17: U50000.AA48 173.2,145.74 v4(173.54,146.08) ; v4(183.91,162.97) 184.28,163.35 U50500.T2
FBA_EDC4: length 18.2
  L8 w0.109: v4(160.41,163.72) 160.03,163.35 160.03,161.12 156.61,157.7 156.61,150.22 158.03,148.8 v4(158.03,148.76)
  BOTTOM w0.17: U50600.C2 v4(160.41,163.72) ; U50000.BB52 158.31,148.48 v4(158.03,148.76)
FBA_EDC5: length 20.3
  L8 w0.109: v4(162.37,149.49) 162.12,149.75 162.12,150.95 162.27,151.1 162.27,155.05 168.13,160.91 168.29,161.07 168.29,163.34 v4(167.91,163.72)
  BOTTOM w0.17: U50000.AT50 162.7,147.26 162.35,147.6 162.35,148.22 162.23,148.35 162.23,149.34 v4(162.37,149.49) ; v4(167.91,163.72) U50600.C13
FBA_EDC6: length 34.1
  L8 w0.109: v4(167.2,145.38) 166.82,145.76 166.82,146.26 167,146.44 167,146.91 166.71,147.2 166.71,154.22 172.78,160.29 172.78,170.25 169.93,173.1 169.03,173.1 v4(168.66,173.47)
  BOTTOM w0.17: v4(167.2,145.38) U50000.AK48 ; v4(168.66,173.47) U50600.T13
FBA_EDC7: length 29.5
  L3 w0.109: v4(160.41,172.72) 160.03,172.35 160.03,166.54 160.2,166.37 162.82,166.37 162.97,166.22 163.08,166.01 163.08,165.29 163.77,164.6 163.77,159.25 163.04,158.52 163.04,149.89 163.42,149.51 v4(163.45,149.51)
  BOTTOM w0.17: v4(160.41,172.72) U50600.T2 ; U50000.AR51 163.4,148 163.78,148.38 163.78,149.17 v4(163.45,149.51)
FBA_WCK01: length 42.4
  L8 w0.097: v4(182.41,172.72) 182.04,172.36 182.04,167.29 182.55,166.78 185.5,166.78 186.08,166.21 186.08,160.98 184.89,159.79 182.79,159.79 174.11,151.11 174.11,146.95 174.46,146.61 175.08,146.61 175.36,146.34 175.36,145.11 175.88,144.59 175.88,144.49 176.16,144.22 176.16,143.66 175.97,143.47 175.97,143.1 176.07,142.99 176.19,142.99 176.33,143.14 v4(176.33,143.25)
  BOTTOM w0.122: U50000.U45 176.23,143.58 176.35,143.45 176.35,143.29 176.33,143.27 v4(176.33,143.25) ; U50500.D4 v4(182.41,172.72)
FBA_WCK01#: length 42.4
  L8 w0.097: v4(181.64,172.72) 181.81,172.54 181.81,167.2 182.45,166.56 185.41,166.56 185.85,166.11 185.85,161.07 184.8,160.02 182.7,160.02 173.89,151.21 173.89,146.86 174.36,146.39 174.99,146.39 175.13,146.24 175.13,145.02 175.66,144.5 175.66,144.4 175.94,144.12 175.94,143.76 175.74,143.57 175.74,143 175.99,142.76 176.09,142.76 v4(176.3,142.55)
  BOTTOM w0.122: v4(181.64,172.72) 182,172.35 U50500.D5 ; v4(176.3,142.55) 176.28,142.55 U50000.U44
FBA_WCK23: length 27.4
  L3 w0.097: v4(177.9,164.47) 177.9,164.53 178.12,164.75 178.29,164.75 178.39,164.65 178.39,164.38 178.29,164.27 178.29,161.87 170.89,154.48 170.89,148.42 171.28,148.04 171.28,146.08 170.81,145.6 170.81,145.15 171.85,144.1 171.85,143.29 171.69,143.13 171.59,143.13 v4(171.47,143.24)
  BOTTOM w0.122: U50500.R11 177.53,164.1 v4(177.9,164.47) ; v4(171.47,143.24) 171.8,143.56 U50000.AC45
FBA_WCK23#: length 27.5
  L3 w0.097: v4(178.87,164.5) 178.83,164.5 178.51,164.18 178.51,161.78 171.12,154.38 171.12,148.51 171.5,148.13 171.5,145.98 171.03,145.51 171.03,145.24 172.08,144.19 172.08,143.2 171.46,142.59 v4(171.46,142.51)
  BOTTOM w0.122: v4(178.87,164.5) 178.68,164.5 U50500.R10 ; v4(171.46,142.51) 171.8,142.85 U50000.AC44
FBA_WCK45: length 26.8
  L10 w0.097: v4(161,144.68) 160.84,144.52 160.72,144.52 160.21,145.03 160.03,145.03 159.21,145.85 159.21,146.29 159.39,146.47 159.39,146.88 159.38,146.89 159.38,149.01 158.36,150.03 158.36,156.79 163.32,161.75 163.32,164.72 162.92,165.12 162.35,165.12 162.1,164.87 162.1,164.63 v4(161.9,164.47)
  BOTTOM w0.122: v4(161,144.68) U50000.AV47 ; U50600.D4 161.53,164.1 v4(161.9,164.47)
FBA_WCK45#: length 26.8
  L10 w0.097: v4(161,143.98) 161,144.19 160.89,144.3 160.62,144.3 160.11,144.81 159.94,144.81 158.99,145.76 158.99,146.38 159.17,146.56 159.17,146.78 159.15,146.79 159.15,148.92 158.14,149.93 158.14,156.89 163.1,161.84 163.1,164.63 162.83,164.89 162.44,164.89 162.32,164.78 162.32,164.56 162.42,164.45 162.61,164.43 v4(162.65,164.46)
  BOTTOM w0.122: v4(162.65,164.46) U50600.D5 ; v4(161,143.98) U50000.AV46
FBA_WCK67: length 42
  L8 w0.097: v4(166.41,171.97) 166.41,172.06 165.9,172.56 164.84,172.56 164.44,172.17 164.44,170.97 164.24,170.77 164.24,166.7 164.66,166.28 165.43,166.28 166.26,167.11 166.65,167.11 166.89,166.87 167.44,166.87 167.69,167.12 168.79,167.12 169.83,166.07 169.83,161.05 163.93,155.15 163.93,148.79 163.58,148.43 163.58,147.94 163.06,147.43 163.06,145.78 163.44,145.41 163.44,145.07 163.19,144.83 163.19,144.31 163.43,144.08 163.43,143.35 163.3,143.23 v4(163.08,143.23)
  BOTTOM w0.122: U50600.R11 v4(166.41,171.97) ; v4(163.08,143.23) U50000.AR45
FBA_WCK67#: length 42.1
  L8 w0.097: v4(163.04,142.52) 163.04,142.65 163.65,143.26 163.65,144.17 163.42,144.41 163.42,144.74 163.66,144.98 163.66,145.5 163.29,145.87 163.29,147.34 163.8,147.85 163.8,148.34 164.16,148.7 164.16,155.06 170.06,160.96 170.06,166.16 168.88,167.34 167.6,167.34 167.35,167.09 166.99,167.09 166.74,167.34 166.17,167.34 165.33,166.5 164.76,166.5 164.46,166.8 164.46,170.68 164.66,170.88 164.66,172.07 164.93,172.34 165.81,172.34 165.92,172.22 165.92,172.07 165.83,171.97 v4(165.66,171.97)
  BOTTOM w0.122: U50600.R10 v4(165.66,171.97) ; v4(163.04,142.52) U50000.AR44
FBA_WCKB01: length 44.8
  L10 w0.097: v4(177.91,172.72) 178.18,172.45 178.18,172.24 180.78,169.63 180.78,169.27 181.59,168.47 181.59,167.42 182.16,166.85 185.09,166.85 185.83,166.12 185.83,160.76 184.04,158.97 181.18,158.97 173.69,151.48 173.69,148.07 173.9,147.87 173.9,146.83 174.42,146.31 175.01,146.31 175.14,146.18 175.14,145.04 175.43,144.75 175.43,144.64 175.94,144.12 175.94,143.73 175.08,142.87 175,142.87 174.91,142.96 174.91,143.22 v4(174.97,143.28)
  BOTTOM w0.122: U50000.V45 175.11,143.58 174.97,143.44 v4(174.97,143.28) ; v4(177.91,172.72) 177.53,172.35 U50500.D11
FBA_WCKB01#: length 44.8
  L10 w0.097: v4(178.66,172.72) 178.4,172.47 178.4,172.33 181.01,169.72 181.01,169.36 181.81,168.56 181.81,167.52 182.25,167.08 185.19,167.08 186.05,166.21 186.05,160.66 184.13,158.74 181.27,158.74 173.92,151.39 173.92,148.17 174.12,147.96 174.12,146.93 174.52,146.53 175.1,146.53 175.36,146.27 175.36,145.14 175.65,144.85 175.65,144.73 176.17,144.22 176.17,143.64 175.17,142.64 175.09,142.64 v4(174.95,142.5)
  BOTTOM w0.122: U50500.D10 178.28,172.35 v4(178.66,172.72) ; U50000.V44 174.95,142.53 v4(174.95,142.5)
FBA_WCKB23: length 28.9
  L8 w0.097: v4(170.72,143.95) 170.72,143.99 171.4,144.66 171.4,144.85 171.73,145.18 171.73,146.03 171.27,146.48 171.27,147.81 170.64,148.45 170.64,152.57 179.95,161.88 179.95,163.95 181.02,165.03 181.65,165.03 181.87,164.8 182.2,164.47 v4(182.41,164.47)
  BOTTOM w0.122: v4(170.72,143.95) U50000.AD46 ; v4(182.41,164.47) U50500.R4
FBA_WCKB23#: length 28.9
  L8 w0.097: v4(170.61,143.13) 170.71,143.29 171.11,143.84 171.11,144.06 171.62,144.57 171.62,144.75 171.95,145.09 171.95,146.12 171.5,146.58 171.5,147.91 170.86,148.54 170.86,152.47 180.17,161.78 180.17,163.86 181.12,164.81 181.56,164.81 181.65,164.71 v4(181.65,164.48)
  BOTTOM w0.122: U50000.AD45 170.75,143.25 170.74,143.25 v4(170.61,143.13) ; v4(181.65,164.48) U50500.R5
FBA_WCKB45: length 24.6
  L8 w0.097: v4(160.18,145.4) 160.21,145.37 160.21,145.12 160.1,145.01 159.96,145.01 159.85,145.12 159.22,145.75 159.22,146.2 159.37,146.34 159.37,149.37 159.56,149.56 159.56,150.6 159.18,150.98 159.18,156.82 163.58,161.23 163.58,162.15 164.76,163.33 165.64,163.33 v4(166.41,163.72)
  BOTTOM w0.122: v4(166.41,163.72) U50600.D11 ; U50000.AW48 160.25,145.39 v4(160.18,145.4)
FBA_WCKB45#: length 24.7
  L8 w0.097: v4(159.97,144.42) 159.97,144.69 159,145.66 159,146.29 159.15,146.43 159.15,149.46 159.34,149.65 159.34,150.51 158.95,150.89 158.95,156.92 163.36,161.32 163.36,162.25 164.66,163.55 165.45,163.55 v4(165.63,163.73)
  BOTTOM w0.122: v4(159.97,144.42) 159.98,144.48 160.59,144.95 U50000.AW47 ; v4(165.63,163.73) U50600.D10
FBA_WCKB67: length 43.2
  L10 w0.097: v4(161.75,143.17) 162.05,143.17 162.07,143.19 162.33,143.67 162.33,144.12 163.08,144.88 163.17,144.88 163.49,145.2 163.49,145.35 163.04,145.8 163.04,147.37 163.88,148.2 163.88,150.79 163.56,151.11 163.56,155.42 169.85,161.72 169.85,166.26 168.94,167.17 167.75,167.17 167.4,166.81 167,166.81 166.63,167.18 166.39,167.18 165.48,166.28 164.73,166.28 164.21,166.8 164.21,171 163.22,171.99 162.44,171.99 162.16,172.28 162.16,172.48 v4(161.91,172.72)
  BOTTOM w0.122: v4(161.75,143.17) 161.79,143.21 162.33,143.21 U50000.AT45 ; U50600.R4 161.53,172.35 v4(161.91,172.72)
FBA_WCKB67#: length 43.2
  L10 w0.097: v4(162.05,142.7) 162.07,142.72 162.25,143.05 162.55,143.61 162.55,144.03 163.18,144.65 163.26,144.65 163.72,145.1 163.72,145.44 163.27,145.89 163.27,147.28 164.1,148.11 164.1,150.88 163.78,151.2 163.78,155.33 170.08,161.62 170.08,166.35 169.03,167.39 167.66,167.39 167.31,167.03 167.1,167.03 166.73,167.41 166.3,167.41 165.39,166.5 164.82,166.5 164.44,166.89 164.44,171.1 163.32,172.22 162.53,172.22 162.38,172.37 162.38,172.63 162.45,172.71 v4(162.69,172.71)
  BOTTOM w0.122: U50600.R5 162.33,172.35 v4(162.69,172.71) ; U50000.AT44 162.23,142.88 v4(162.05,142.7)
FBA_ZQ_1_A: length 1.4
  TOP w0.25: R50500.1 174.75,168.92 v4(174.83,169.01)
  BOTTOM w0.254: U50500.J14 174.87,169.01 v4(174.83,169.01)
FBA_ZQ_1_B: length 1.4
  TOP w0.25: v4(174.91,168.22) 174.84,168.16 R50501.1
  BOTTOM w0.254: v4(174.91,168.22) U50500.K14
FBA_ZQ_2_A: length 2.1
  TOP w0.3: R50600.1 170.63,168.43 170.38,168.17 v4(169.48,168.17)
  BOTTOM w0.3: v4(169.48,168.17) 169.15,167.85 U50600.J14
FBA_ZQ_2_B: length 2.1
  TOP w0.3: v4(169.41,168.97) 169.63,169.19 170.81,169.19 R50601.1
  BOTTOM w0.3: v4(169.41,168.97) U50600.K14
FBB1_VREFC: length 1.3
  TOP w0.381: R50710.2 207.08,137.99 v4(207.18,138.09)
  BOTTOM w0.3: v4(207.18,138.09) 206.86,138.42 U50700.K1
FBB2_VREFC: length 1.5
  TOP w0.225: v4(207.32,164.24) 207.08,164.48 R50810.2
  BOTTOM w0.3: U50800.K1 207.32,163.87 v4(207.32,164.24)
FBB_CLK0: length 31.2
  L10 w0.097: v4(207.98,144.91) 207.82,144.76 207.82,144.56 207.47,144.21 205.81,144.21 205.58,144.44 205.58,144.97 205.49,145.06 199.57,145.06 197.91,143.4 185.84,143.4 185.1,142.66 184,142.66 183.81,142.48 183.81,142.2 184.01,142 184.01,141.61 183.45,141.06 182.53,141.06 182.03,141.55 182.03,141.75 v4(181.88,141.9)
  BOTTOM w0.122: v4(181.88,141.9) U50000.H42 ; v4(207.98,144.91) 207.84,145.05 U50700.J10
FBB_CLK0#: length 31.2
  L10 w0.097: v4(207.23,144.91) 207.36,145.05 207.5,145.05 207.6,144.95 207.6,144.65 207.38,144.43 205.9,144.43 205.81,144.53 205.81,145.06 205.58,145.29 199.48,145.29 197.82,143.62 185.74,143.62 185.01,142.89 183.9,142.89 183.59,142.58 183.59,142.1 183.79,141.91 183.79,141.71 183.36,141.28 182.62,141.28 182.26,141.64 182.26,141.86 182.35,141.96 182.49,141.96 v4(182.65,141.8)
  BOTTOM w0.122: v4(182.65,141.8) 182.68,141.8 U50000.G42 ; U50700.K10 v4(207.23,144.91)
FBB_CLK1: length 33.6
  L3 w0.097: v4(183.41,144.69) 183.97,145.25 186.07,145.25 186.88,146.05 188.13,146.05 192.27,150.2 194.49,150.2 196.18,151.88 206.65,151.88 206.93,152.15 206.93,152.75 206.27,153.41 206.27,154.98 205.86,155.39 205.86,155.98 206.79,156.91 206.79,157.09 206.71,157.17 206.55,157.17 v4(206.51,157.21)
  BOTTOM w0.122: v4(206.51,157.21) 206.86,156.86 U50800.J10 ; v4(183.41,144.69) U50000.F47
FBB_CLK1#: length 33.6
  L3 w0.097: v4(184.05,144.63) 183.91,144.77 183.91,144.88 184.06,145.02 186.16,145.02 186.97,145.83 188.22,145.83 192.37,149.97 194.59,149.97 196.27,151.66 206.75,151.66 207.15,152.06 207.15,152.84 206.49,153.5 206.49,155.08 206.08,155.49 206.08,155.89 207.01,156.82 207.01,157 v4(207.23,157.22)
  BOTTOM w0.122: U50000.E47 v4(184.05,144.63) ; v4(207.23,157.22) U50800.K10
FBB_CMD0: length 29.1
  L10 w0.086: v4(208.73,140.4) 209.13,140.01 209.13,137.06 v1(209.08,137.01)
  BOTTOM w0.137: v1(209.08,137.01) 207.13,135.06 v2(204.47,135.06) 204.08,135.06 203.44,135.7 198.44,135.7 197.22,134.49 190.44,134.49 188.69,136.24 187.05,136.24 186.71,136.58 U50000.B35 ; U50700.H3 v4(208.73,140.4)
FBB_CMD1: length 26.8
  L8 w0.086: v1(207.66,137.46) 207.6,137.53 207.6,139.29 v4(207.23,139.66)
  BOTTOM w0.109: U50700.K3 v4(207.23,139.66) U50700.J3
  BOTTOM w0.137: U50000.A35 188.77,136.58 190.47,134.88 196.7,134.88 197.9,136.08 204.48,136.08 205.13,135.44 206.73,135.44 207.66,136.37 v1(207.66,137.46)
FBB_CMD2_RST: length 25.6
  BOTTOM w0.137: U50000.D35 185.47,136.95 187.45,136.95 187.46,136.93 188.9,136.93 190.57,135.26 196.34,135.26 197.67,136.59 204.96,136.59 R50706.1 205.6,136 207.61,138.01 U50700.J1
FBB_CMD3: length 25.7
  L8 w0.086: v4(207.23,141.16) 206.85,140.77 206.24,140.77 205.97,140.5 205.97,137.69 v1(205.52,137.25)
  BOTTOM w0.109: U50700.J4 207.41,140.97 v4(207.23,141.16) U50700.K4
  BOTTOM w0.137: v1(205.52,137.25) 205.36,137.09 197.07,137.09 195.62,135.64 190.66,135.64 189.02,137.28 U50000.A36
FBB_CMD4: length 23
  BOTTOM w0.137: U50700.L3 205.73,139.65 205.73,138.09 205.1,137.47 196.54,137.47 195.1,136.03 190.72,136.03 189.14,137.61 187.04,137.61 186.71,137.28 U50000.B36
FBB_CMD5: length 26
  BOTTOM w0.137: U50700.M4 205.36,140.78 204.98,141.16 204.98,142.27 204.84,142.41 200.41,142.41 199.82,141.82 199.82,138.76 199.19,138.13 196.38,138.13 194.66,136.41 190.72,136.41 189.25,137.88 186.95,137.88 186.7,137.63 186.36,137.63 186.01,137.28 U50000.C36
FBB_CMD6: length 27.6
  BOTTOM w0.109: U50700.K5 207.17,141.84 207.29,141.84 U50700.J5
  BOTTOM w0.137: U50000.C38 186.04,138.68 186.36,138.36 186.62,138.36 186.86,138.12 189.34,138.12 189.39,138.08 189.48,138.08 190.77,136.78 194.5,136.78 196.67,138.95 199.18,138.95 199.44,139.21 199.44,141.98 200.11,142.64 200.62,142.64 200.65,142.68 205.05,142.68 205.28,142.45 206.28,142.45 206.8,141.94 207.08,141.94 207.17,141.84
FBB_CMD7: length 28.9
  L8 w0.076: v4(208.42,142.14) 208.42,142.25 208.15,142.52 207.24,142.52 v4(207.16,142.45) v4(205.66,142)
  BOTTOM w0.109: U50700.H5 208.36,142.08 v4(208.42,142.14) ; U50700.L5 v4(205.66,142)
  BOTTOM w0.137: U50000.B38 186.65,138.68 186.97,138.36 187.33,138.36 187.41,138.43 189.7,138.43 190.97,137.17 194.1,137.17 196.89,139.96 197.97,139.96 198.9,140.9 198.9,141.97 199.81,142.88 200.13,142.88 200.17,142.93 206.17,142.93 206.55,142.55 207.06,142.55 v4(207.16,142.45)
FBB_CMD8: length 27
  BOTTOM w0.137: U50000.A38 187.21,138.67 189.94,138.67 191.05,137.57 193.96,137.57 199.66,143.26 200.38,143.26 200.41,143.23 206.27,143.23 206.61,142.89 208.61,142.89 209.48,142.02 209.48,141.15 209.34,141.02 U50700.G4
FBB_CMD9: length 29.5
  BOTTOM w0.137: U50700.G11 209.48,145.65 209.48,144.11 209.19,143.82 207.49,143.82 206.98,143.31 206.64,143.31 206.43,143.51 200.53,143.51 200.4,143.64 199.45,143.64 194.92,139.11 194.92,139.1 194.63,138.81 194.62,138.81 194.27,138.46 190.58,138.46 190.01,139.03 185.45,139.03 U50000.D38
FBB_CMD10_CKE: length 28.6
  TOP w0.137: R50705.1 207.18,144.22 v4(206.77,143.81)
  L8 w0.076: v4(205.03,144.54) 205.76,143.81 v4(206.77,143.81) v4(208.98,144.79)
  BOTTOM w0.109: U50700.M10 205.36,144.87 v4(205.03,144.54) ; U50700.G10 209.11,144.94 208.98,144.81 v4(208.98,144.79)
  BOTTOM w0.137: v4(206.77,143.81) 206.75,143.79 200.67,143.79 200.45,144.02 199.13,144.02 194.05,138.94 192.5,138.94 192.48,138.96 192.07,138.96 192.05,138.94 190.53,138.94 190.09,139.38 U50000.A39
