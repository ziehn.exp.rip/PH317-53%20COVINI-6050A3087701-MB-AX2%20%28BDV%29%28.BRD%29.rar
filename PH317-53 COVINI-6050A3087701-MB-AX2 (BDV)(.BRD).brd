# Allegro board PH317-53 COVINI-6050A3087701-MB-AX2 (BDV)(.BRD).brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
WR_LANE1_DP: length 73.1
  TOP w0.107: v1(268.85,64.77) 268.63,64.55 268.63,64.4 268.73,64.29 272.01,64.29 275.06,61.24 275.06,54.33 274.83,54.1 273.46,54.1 273.36,53.99 273.36,53.67 273.46,53.56 274.8,53.56 275.03,53.33 275.03,52.96 274.8,52.73 273.46,52.73 273.36,52.63 273.36,52.43 273.46,52.32 274.8,52.32 275.03,52.09 275.03,51.72 274.8,51.49 273.46,51.49 273.36,51.39 273.36,51.19 273.46,51.08 274.8,51.08 275.03,50.85 275.03,50.48 274.8,50.25 273.51,50.25 273.18,49.92 273.18,38.81 275.06,36.93 275.06,25.87 274.1,24.91 274.1,24.27 R1329.1
  BOTTOM w0.089: U4710.BA2 257.44,64.55 257.44,65.39 258.31,66.26 258.31,66.29 258.32,66.3
  BOTTOM w0.107: v1(268.85,64.77) 268.63,65 268.63,66.35 266.49,68.49 262.65,68.49 261.01,66.85 258.88,66.85 258.32,66.3
WT_CLK_DN: length 72.9
  TOP w0.107: R1354.1 291.84,20.29 292.13,20.58 292.45,20.58 v3(292.68,20.35)
  L3 w0.084: v3(292.68,20.35) 292.68,20.4 292.45,20.63 291.95,20.63 290.12,22.46 289.08,22.46 288.21,23.33 288.21,25.56 288.94,26.28 288.94,28.97 288.21,29.7 288.21,35.28 287.6,35.9 284.42,35.9 273.68,46.64 273.68,58.93 271.98,60.63 268.31,60.63 268.23,60.55 268.23,59.67 268.02,59.46 267.62,59.46 267.42,59.67 267.42,60.55 267.33,60.63 267.11,60.63 267.03,60.55 267.03,59.67 266.82,59.46 266.42,59.46 266.22,59.67 266.22,60.55 266.13,60.63 261.03,60.63 260.91,60.76 259.13,62.54 258.37,62.54 258.28,62.46 v1(258.28,62.25)
  BOTTOM w0.107: v1(258.28,62.25) 257.99,62.54 257.99,62.69 U4710.BC5
WT_CLK_DP: length 72.9
  TOP w0.107: v1(292.68,21.01) 292.45,20.79 292.08,20.79 R1353.1
  L3 w0.084: v1(292.68,21.01) 292.5,20.84 292.04,20.84 290.21,22.67 289.17,22.67 288.42,23.41 288.42,25.47 289.15,26.2 289.15,29.06 288.42,29.79 288.42,35.37 287.69,36.11 284.51,36.11 273.89,46.73 273.89,59.02 272.06,60.84 268.22,60.84 268.02,60.64 268.02,59.76 267.93,59.68 267.71,59.68 267.63,59.76 267.63,60.64 267.42,60.84 267.02,60.84 266.82,60.64 266.82,59.76 266.73,59.68 266.51,59.68 266.43,59.76 266.43,60.64 266.22,60.84 261.12,60.84 259.21,62.75 257.67,62.75 v3(257.61,62.82)
  BOTTOM w0.107: U4710.BB6 257.61,62.31 v3(257.61,62.82)
WT_LANE0_DN: length 72.1
  TOP w0.107: v1(292.67,22.76) 292.49,22.58 292.46,22.58 292.35,22.47 292.03,22.47 291.84,22.67 R1330.1
  L3 w0.084: v1(292.67,22.76) 292.67,22.64 292.53,22.51 292.26,22.51 292.18,22.59 292.18,23.89 292.68,24.39 292.68,28.54 292.14,29.08 292.14,32.6 288.03,36.71 286.03,36.71 275.15,47.58 275.15,48.78 274.94,48.99 274.58,48.99 274.49,49.07 274.49,49.3 274.58,49.38 274.94,49.38 275.15,49.59 275.15,49.98 274.94,50.19 274.58,50.19 274.49,50.27 274.49,50.49 274.58,50.58 274.94,50.58 275.15,50.79 275.15,51.18 274.94,51.39 274.58,51.39 274.49,51.47 274.49,51.69 274.58,51.78 274.94,51.78 275.15,51.98 275.15,52.38 274.94,52.59 274.58,52.59 274.49,52.67 274.49,52.89 274.58,52.98 274.94,52.98 275.15,53.18 275.15,53.58 274.94,53.79 274.58,53.79 274.49,53.87 274.49,54.09 274.58,54.17 274.94,54.17 275.15,54.38 275.15,54.78 274.94,54.99 274.58,54.99 274.49,55.07 274.49,55.29 274.58,55.37 274.94,55.37 275.15,55.58 275.15,55.98 274.94,56.18 274.58,56.18 274.49,56.27 274.49,56.49 274.58,56.57 274.94,56.57 275.15,56.78 275.15,57.18 274.94,57.38 274.58,57.38 274.49,57.47 274.49,57.69 274.58,57.77 274.94,57.77 275.15,57.98 275.15,58.61 272.31,61.44 264.79,61.44 264.28,61.95 262.11,61.95 261.95,62.11 v3(261.95,62.22)
  BOTTOM w0.089: v3(261.95,62.22) 261.95,62.07 261.86,61.98 261.26,61.98 261.12,62.12 259.3,62.12 259.21,62.21 U4710.BE6
WT_LANE0_DP: length 72.1
  TOP w0.107: v3(292.67,22.1) 292.5,22.26 292.15,22.26 R1331.1
  L3 w0.084: v3(292.67,22.1) 292.47,22.3 292.18,22.3 291.97,22.5 291.97,23.97 292.47,24.47 292.47,28.46 291.93,28.99 291.93,32.51 287.95,36.5 285.94,36.5 274.94,47.5 274.94,48.7 274.85,48.78 274.49,48.78 274.28,48.99 274.28,49.38 274.49,49.59 274.85,49.59 274.94,49.67 274.94,49.89 274.85,49.98 274.49,49.98 274.28,50.19 274.28,50.58 274.49,50.79 274.85,50.79 274.94,50.87 274.94,51.09 274.85,51.18 274.49,51.18 274.28,51.38 274.28,51.78 274.49,51.99 274.85,51.99 274.94,52.07 274.94,52.29 274.85,52.38 274.49,52.38 274.28,52.58 274.28,52.98 274.49,53.19 274.85,53.19 274.94,53.27 274.94,53.49 274.85,53.58 274.49,53.58 274.28,53.78 274.28,54.18 274.49,54.39 274.85,54.39 274.94,54.47 274.94,54.69 274.85,54.77 274.49,54.77 274.28,54.98 274.28,55.38 274.49,55.58 274.85,55.58 274.94,55.67 274.94,55.89 274.85,55.97 274.49,55.97 274.28,56.18 274.28,56.58 274.49,56.78 274.85,56.78 274.94,56.87 274.94,57.09 274.85,57.17 274.49,57.17 274.28,57.38 274.28,57.78 274.49,57.98 274.85,57.98 274.94,58.07 274.94,58.52 272.22,61.23 264.7,61.23 264.58,61.36 264.58,61.36 264.19,61.74 262.13,61.74 v1(261.95,61.56)
  BOTTOM w0.089: v1(261.95,61.56) 261.71,61.8 261.19,61.8 261.05,61.94 259.1,61.94 258.94,62.1 U4710.BD7
WT_LANE1_DN: length 68.9
  TOP w0.107: R1367.1 293.46,24.19 293.7,23.96 294.51,23.96 294.7,24.14 v1(294.7,24.25)
  L3 w0.084: v1(294.7,24.25) 294.7,24.12 294.56,23.98 294.25,23.98 293.28,24.95 293.28,28.79 292.74,29.33 292.74,33.67 289.16,37.25 289.04,37.37 286.86,37.37 276.38,47.85 276.38,49.43 276.17,49.64 275.96,49.64 275.87,49.72 275.87,49.94 275.96,50.03 276.17,50.03 276.38,50.23 276.38,50.63 276.17,50.84 275.96,50.84 275.87,50.92 275.87,51.14 275.96,51.22 276.17,51.22 276.38,51.43 276.38,51.83 276.17,52.03 275.96,52.03 275.87,52.12 275.87,52.34 275.96,52.42 276.17,52.42 276.38,52.63 276.38,53.03 276.17,53.23 275.96,53.23 275.87,53.32 275.87,53.54 275.96,53.62 276.17,53.62 276.38,53.83 276.38,54.23 276.17,54.43 275.96,54.43 275.87,54.52 275.87,54.74 275.96,54.82 276.17,54.82 276.38,55.03 276.38,55.42 276.17,55.63 275.96,55.63 275.87,55.72 275.87,55.94 275.96,56.02 276.17,56.02 276.38,56.23 276.38,56.62 276.17,56.83 275.96,56.83 275.87,56.91 275.87,57.14 275.96,57.22 276.17,57.22 276.38,57.43 276.38,58.22 271.35,63.25 263.53,63.25 263.4,63.38 v1(263.4,63.52)
  BOTTOM w0.089: 262.4,63.29 262.38,63.29 262.36,63.27 261.16,63.27 260.4,62.51 260.24,62.51 U4710.BG6
  BOTTOM w0.107: 262.4,63.29 263.3,63.29 263.4,63.4 v1(263.4,63.52)
WT_LANE1_DP: length 69
  TOP w0.107: v1(294.7,23.59) 294.54,23.75 293.76,23.75 R1368.1
  L3 w0.084: v1(294.7,23.59) 294.51,23.77 294.16,23.77 293.07,24.86 293.07,28.7 292.53,29.24 292.53,33.59 288.95,37.16 286.77,37.16 276.17,47.76 276.17,49.34 276.09,49.43 275.87,49.43 275.66,49.63 275.66,50.03 275.87,50.24 276.09,50.24 276.17,50.32 276.17,50.54 276.09,50.62 275.87,50.62 275.66,50.83 275.66,51.23 275.87,51.44 276.09,51.44 276.17,51.52 276.17,51.74 276.09,51.82 275.87,51.82 275.66,52.03 275.66,52.43 275.87,52.63 276.09,52.63 276.17,52.72 276.17,52.94 276.09,53.02 275.87,53.02 275.66,53.23 275.66,53.63 275.87,53.83 276.09,53.83 276.17,53.92 276.17,54.14 276.09,54.22 275.87,54.22 275.66,54.43 275.66,54.82 275.87,55.03 276.09,55.03 276.17,55.12 276.17,55.34 276.09,55.42 275.87,55.42 275.66,55.63 275.66,56.02 275.87,56.23 276.09,56.23 276.17,56.31 276.17,56.54 276.09,56.62 275.87,56.62 275.66,56.83 275.66,57.22 275.87,57.43 276.09,57.43 276.17,57.51 276.17,58.13 271.27,63.04 263.59,63.04 v3(263.4,62.86)
  BOTTOM w0.089: U4710.BF6 260.04,62.34 260.47,62.34 261.24,63.1 262.36,63.1 262.38,63.08 262.4,63.08
  BOTTOM w0.107: v3(263.4,62.86) 263.18,63.08 262.4,63.08
X401_3: length 6.6
  TOP w0.109: R410.1 287.39,94.26 R411.2 287.62,93.83 v2(287.5,93.7) 287.69,93.51 C423.2 287.69,92.4 287.8,92.29 287.8,90.49 286.88,89.57 X400.3
XCLK_BIASREF: length 4
  TOP w0.109: R4892.2 244.29,66.49 v2(244.27,66.47) 244.62,66.12 v1(244.83,66.12)
  BOTTOM w0.109: v1(244.83,66.12) 244.78,66.12 244.42,65.76 244.42,64.34 U4710.T3
XTAL24_IN: length 8.6
  TOP w0.109: v1(245.85,60.87) 246.38,61.4 246.38,67.36 v3(246.5,67.49)
  BOTTOM w0.109: U4710.U10 v1(245.85,60.87) ; v3(246.5,67.49) 246.44,67.49 246.33,67.6 246.33,68.08 L4700.1 246.24,68.22 R4719.1
XTAL24_IN_R: length 3.4
  BOTTOM w0.109: X4751.3 247.12,71.01 C4828.1 R4898.1 246.24,70.15 L4700.4 246.41,69.25 R4719.2
XTAL24_OUT: length 7.9
  TOP w0.109: v3(245.74,61.55) 246.12,61.93 246.12,66.4 245.78,66.74 v1(245.78,67.49)
  BOTTOM w0.109: v3(245.74,61.55) 245.74,61.48 U4710.U9 ; R4716.1 245.69,68.22 L4700.2 245.69,67.59 v1(245.78,67.49)
XTAL24_OUT_R: length 5.5
  BOTTOM w0.109: X4751.1 244.51,73.22 245.29,72.44 245.29,70.81 C4826.1 R4898.2 245.69,70.13 L4700.3 245.52,69.25 R4716.2
XTLI: length 9.2
  TOP w0.109: U400.8 284.88,97.41 285.3,96.98 285.3,96.72 286.15,95.87 v2(286.28,95.87) 286.34,95.87 286.34,95.86 286.67,95.86 287.03,95.5 287.46,95.5 R411.1 288.11,94.85 288.11,94.47 288.11,93.83 288.49,93.45 C422.2 288.29,92.65 288.29,91.86 288.87,91.27 X400.1
XTLO: length 4.2
  TOP w0.109: R410.2 286.02,95.11 v2(284.96,96.17) 284.81,96.32 284.81,96.97 284.48,97.3 U400.7

## Copper pours and planes (outline as drawn)
AGND_AUDIO on L2 (solid shape): outline of 833 points within 11.54,35.61 34.16,59.34
AGND_AUDIO on L4 (solid shape): outline of 833 points within 11.54,35.61 34.16,59.34
AGND_AUDIO on L6 (solid shape): outline of 833 points within 11.54,35.61 34.16,59.34
AGND_AUDIO on L7 (solid shape): outline of 833 points within 11.54,35.61 34.16,59.34
AGND_AUDIO on L9 (solid shape): outline of 833 points within 11.54,35.61 34.16,59.34
AGND_AUDIO on L11 (solid shape): outline of 833 points within 11.54,35.61 34.16,59.34
DGND on TOP (solid shape): 216.53,179.51 216.53,174.2 211.86,174.2 210.82,175.24 210.82,180.27 215.77,180.27
DGND on TOP (solid shape): 100.15,40.29 100.15,39.32 100.02,39.2 97.08,39.2 96.95,39.32 96.95,40.29 97.08,40.41 100.02,40.41
DGND on TOP (solid shape): 101.62,130.38 101.62,128.45 101.5,128.32 100.86,128.32 100.83,128.35 100.83,130.51 100.91,130.58 101.42,130.58
DGND on TOP (solid shape): 112.47,128.68 112.47,127.77 111.78,127.08 111.25,127.08 111.22,127.11 111.22,128.65 111.27,128.71 112.44,128.71
DGND on TOP (solid shape): 116.23,138.31 116.23,137.29 116.13,137.19 115.29,137.19 114.91,137.57 114.91,138.31 114.96,138.36 116.18,138.36
DGND on TOP (solid shape): 142.52,39.35 142.52,36.17 142.39,36.05 139.19,36.05 139.06,36.17 139.06,39.35 139.19,39.48 142.39,39.48
DGND on TOP (solid shape): 203.98,174.63 203.98,172.6 203.91,172.52 202.46,172.52 202.36,172.62 202.36,174.53 202.54,174.7 203.91,174.7
DGND on TOP (solid shape): 204.54,170.41 204.54,168.99 204.37,168.81 202.38,168.81 202.26,168.94 202.26,170.44 202.41,170.59 204.37,170.59
DGND on TOP (solid shape): 206.83,28.48 206.83,25.61 206.78,25.56 203.5,25.56 203.35,25.71 203.35,28.45 203.63,28.73 206.57,28.73
DGND on TOP (solid shape): 102.84,130.64 102.84,130.38 102.99,130.23 102.99,128.38 102.94,128.32 101.85,128.32 101.83,128.35 101.83,130.71 102.77,130.71
DGND on TOP (solid shape): 106.02,138.08 105.89,137.95 105.89,137.49 105.74,137.34 104.92,137.34 104.75,137.52 104.75,138.36 106.02,138.36
DGND on TOP (solid shape): 260.83,27 260.83,25.56 260.6,25.33 253.62,25.33 253.56,25.38 253.56,27.08 253.67,27.18 260.65,27.18
DGND on TOP (solid shape): 118.16,128.63 118.16,127.08 115.97,127.08 115.92,127.13 115.92,127.49 115.74,127.66 115.74,127.99 115.97,128.22 115.97,128.65 116.05,128.73 118.06,128.73
DGND on TOP (solid shape): 190.22,168.51 190.22,165.61 190.75,165.08 190.75,163.94 190.65,163.83 189.28,163.83 189.07,164.04 189.07,167.43 189.09,168.51 189.17,168.58 190.14,168.58
DGND on TOP (solid shape): 91.46,156.09 91.46,151.26 91.08,150.88 84.53,150.88 84.32,151.08 84.32,152.99 84.58,153.24 87.73,153.24 88.19,153.7 88.19,156.14 88.36,156.32 91.23,156.32
DGND on TOP (solid shape): 245.74,29.9 245.74,28.86 245.67,28.78 245.67,28.27 245.66,27.97 245.61,27.92 243.43,27.92 243.33,28.02 243.33,29.67 243.61,29.95 245.69,29.95
DGND on TOP (solid shape): 107.77,128.65 107.77,128.35 107.57,128.35 107.49,128.27 107.49,127.49 107.72,127.26 107.72,127.11 107.69,127.08 106.47,127.08 106.42,127.13 106.42,128.63 106.5,128.71 107.72,128.71
DGND on TOP (solid shape): 167.2,18.9 159.57,18.9 159.33,19.03 159.2,19.27 159.2,25.4 167.2,25.4
DGND on TOP (solid shape): 154.2,171.89 154.2,166.02 154,165.81 152.04,165.81 151.96,165.89 151.96,168.56 152.17,168.76 152.17,170.36 151.96,170.56 151.53,170.56 151.43,170.67 151.43,171.94 151.58,172.09 154,172.09
DGND on TOP (solid shape): 193.65,24.36 193.65,23.98 193.54,23.88 192.53,23.88 191.89,23.24 191.89,22.3 191.21,21.62 187.9,21.62 187.4,21.12 184.7,21.12 184.68,21.14 184.68,23.09 184.81,23.22 186.89,23.22 188.13,24.46 193.54,24.46
DGND on TOP (solid shape): 113.76,138.28 113.76,137.21 113.94,137.04 113.94,136.35 113.79,136.2 113.38,136.2 113.36,136.22 113.36,136.83 112.87,137.32 112.75,137.32 112.67,137.39 112.67,137.72 112.47,137.93 112.47,138.33 112.49,138.36 113.69,138.36
DGND on TOP (solid shape): 64.74,152.67 64.8,152.75 64.9,152.73 65.4,152.23 70.05,152.23 71.07,151.21 71.07,148.14 69.59,146.66 66.72,146.66 64.88,144.82 64.74,144.96
DGND on TOP (solid shape): 93.43,180.24 93.51,180.19 93.49,180.09 92.99,179.58 92.99,174.93 91.97,173.92 88.9,173.92 87.42,175.39 87.42,178.26 85.58,180.1 85.72,180.24
DGND on TOP (solid shape): 108.4,138.23 108.4,137.09 108.58,136.91 108.89,136.91 108.99,136.81 108.99,136.3 108.82,136.13 108.82,135.25 108.78,135.21 108.2,135.21 108.06,135.35 108.06,136.72 107.57,137.21 107.29,137.21 107.08,137.42 107.08,138.28 107.13,138.33 108.3,138.33
DGND on TOP (solid shape): 152,180.24 152.08,180.19 152.06,180.09 151.56,179.58 151.56,174.93 150.54,173.92 147.47,173.92 146,175.39 146,178.26 144.15,180.1 144.29,180.24
DGND on TOP (solid shape): 297.53,26.57 297.53,20.4 297.41,20.27 296.99,20.27 296.77,20.35 296.55,20.27 295.5,20.27 295.42,20.35 295.42,26.57 295.55,26.7 297.41,26.7
DGND on TOP (solid shape): 318,80.7 317.9,80.6 310.84,80.6 310.44,81 309.22,81 308.71,80.5 308.71,79.18 308.96,78.92 308.96,78.72 306.24,78.72 303.76,76.23 299.54,76.23 297.48,78.29 297.51,78.31 297.51,81.97 297.18,82.3 297.18,82.35 297.23,82.4 318,82.4
DGND on TOP (solid shape): 195.02,175.97 197.68,175.97 197.81,175.85 197.81,175.42 197.84,175.42 197.84,175.03 197.74,174.93 196.47,174.93 196.16,175.24 195.02,175.24 194.41,174.63 194.41,173.82 194.21,173.61 190.98,173.61 190.75,173.84 190.75,176 191,176.25 194.74,176.25
DGND on TOP (solid shape): 100.86,158.45 100.86,157.28 99.89,156.32 99.89,150.04 99.44,149.58 92.61,149.58 92.5,149.69 92.5,156.54 92.96,157 98.37,157 99.44,158.07 99.87,158.07 99.97,158.17 99.97,158.42 99.99,158.5 100.02,158.52 100.78,158.52
DGND on TOP (solid shape): 71.02,180.45 71.11,180.39 71.09,180.29 70.58,179.78 70.58,175.14 69.57,174.12 66.49,174.12 65.02,175.59 65.02,179.98 65.34,180.26 65.72,180.45
DGND on TOP (solid shape): 29.11,82.66 29.2,82.6 29.18,82.5 28.67,81.99 28.67,77.35 27.66,76.33 24.58,76.33 23.11,77.8 23.11,81.44 22.05,82.5 22.03,82.6 22.11,82.66
DGND on TOP (solid shape): 64.72,118.63 64.77,118.71 64.87,118.69 65.38,118.19 70.02,118.19 71.04,117.17 71.04,114.1 69.57,112.63 65.94,112.63 64.87,111.56 64.77,111.54 64.72,111.63
DGND on TOP (solid shape): 242.92,24.84 245.59,24.84 245.72,24.72 245.72,23.63 245.54,23.45 244.27,23.45 244.17,23.55 244.17,23.85 243.94,24.08 242.9,24.08 242.39,23.57 242.39,22 241.91,21.52 240.36,21.52 240.05,21.21 240.05,20.76 239.87,20.58 237,20.58 236.95,20.63 236.95,22.69 237.18,22.91 239.67,22.91 240.18,23.42 240.18,24.18 240.64,24.64 241.63,24.64 242.11,25.12 242.64,25.12
DGND on TOP (solid shape): 313.74,9.33 314.57,8.87 315.4,9.33 317.57,9.33 317.95,8.94 317.95,1.53 317.19,0.77 311.45,0.77 309.75,2.47 309.75,5.16 312.37,7.78 312.37,8.92 312.77,9.33
DGND on TOP (solid shape): 219.22,94.78 218.09,91.94 218.59,88.93 218.31,88.65 214.19,88.65 212.21,90.63 212.21,93.48 213.89,95.15 219.22,95.15
DGND on TOP (solid shape): 311.02,47.66 311.4,47.24 311.93,47.09 317.79,47.09 318.15,46.94 318.3,46.58 318.3,41.2 318.26,41.01 318.15,40.84 318.02,40.71 317.68,40.33 317.5,40.2 317.3,40.16 307.95,40.16 307.01,39.51 307.27,38.4 307.35,38.32 307.4,38.22 307.39,38.12 307.31,38.08 306.87,38.08 306.55,39.73 307.95,40.67 317.3,40.67 317.79,41.22 317.79,46.58 311.93,46.58 311.03,46.88 310.48,47.66
DGND on TOP (solid shape): outline of 186 points within 10.56,0.51 318.3,45.42
DGND on TOP (solid shape): outline of 178 points within 0.51,63.2 318.3,180.49
DGND on BOTTOM (solid shape): 155.39,154.57 149.21,154.57 149.21,161.07 155.39,161.07
DGND on BOTTOM (solid shape): 216.53,179.51 216.53,174.2 211.86,174.2 210.82,175.24 210.82,180.27 215.77,180.27
DGND on BOTTOM (solid shape): 15.49,74.76 15.49,73.16 15.36,73.03 13.74,73.03 13.59,73.18 13.59,74.63 13.76,74.81 15.44,74.81
DGND on BOTTOM (solid shape): 21.64,58.83 21.64,54.46 21.51,54.33 17.34,54.33 17.22,54.46 17.22,58.83 17.34,58.96 21.51,58.96
DGND on BOTTOM (solid shape): 56.33,77.85 56.33,75.95 56.23,75.85 55.24,75.85 55.11,75.97 55.11,77.88 55.19,77.96 56.23,77.96
DGND on BOTTOM (solid shape): 58.29,33.13 58.29,30.41 58.19,30.31 55.14,30.31 55.09,30.36 55.09,33.15 55.17,33.23 58.19,33.23
DGND on BOTTOM (solid shape): 68.98,142.98 68.98,142.73 67.03,140.77 66.8,140.77 65.5,142.07 65.5,143.82 66.65,144.96 67,144.96
DGND on BOTTOM (solid shape): 75.23,68.53 75.23,66.7 75.21,66.68 73.63,66.68 73.45,66.86 73.45,68.05 74.06,68.66 75.1,68.66
DGND on BOTTOM (solid shape): 79.73,150.45 79.73,150.17 77.85,148.29 77.64,148.29 75.76,150.17 75.76,150.22 77.7,152.15 78.03,152.15
DGND on BOTTOM (solid shape): 81.76,141 81.76,139.25 81.73,139.22 80.74,139.22 80.59,139.37 80.59,141.05 80.62,141.08 81.68,141.08
DGND on BOTTOM (solid shape): 154.43,76.33 154.43,74.73 154.35,74.65 150.36,74.65 150.21,74.81 150.21,75.85 150.72,76.36 154.4,76.36
DGND on BOTTOM (solid shape): 219.25,100.77 219.25,96.24 219.1,96.09 217.67,96.09 217.57,96.19 217.57,100.89 217.7,101.02 219,101.02
DGND on BOTTOM (solid shape): 231.62,48.62 231.62,46.03 231.42,45.83 228.88,45.83 228.75,45.95 228.75,48.54 228.93,48.72 231.52,48.72
DGND on BOTTOM (solid shape): 234.08,59.95 234.08,53.67 233.96,53.55 231.52,53.55 231.39,53.67 231.39,59.95 231.52,60.07 233.96,60.07
DGND on BOTTOM (solid shape): 286.03,32.41 286.03,30.94 285.9,30.81 284.43,30.81 284.3,30.94 284.3,32.41 284.43,32.54 285.9,32.54
DGND on BOTTOM (solid shape): 78.86,129.57 79.02,129.42 79.02,128.53 78.79,128.3 78.48,128.3 78.1,128.68 78.1,129.52 78.23,129.65 78.86,129.65
DGND on BOTTOM (solid shape): 301.01,32.34 301.01,28.81 301.44,28.38 301.44,28.12 299.49,28.12 298.29,29.32 298.29,32.44 298.37,32.52 300.83,32.52
DGND on BOTTOM (solid shape): 145.18,159.9 145.18,153.85 144.93,153.6 141.45,153.6 140.81,154.23 140.81,157.03 141.63,157.84 141.63,159.64 141.98,160 145.08,160
DGND on BOTTOM (solid shape): 229.05,51.54 229.05,49.99 228.98,49.91 228.52,49.91 228.27,50.17 227.35,50.17 227.25,50.27 227.25,51.51 227.38,51.64 228.95,51.64
DGND on BOTTOM (solid shape): 265.83,33.48 265.83,31.93 265.78,31.88 262.1,31.88 261.95,32.03 261.95,33.13 262.05,33.23 262.99,33.23 263.29,33.53 265.78,33.53
DGND on BOTTOM (solid shape): 51.91,31.04 51.91,27.94 51.86,27.89 49.5,27.89 49.5,30.23 49.2,30.53 48.66,30.53 48.51,30.69 48.51,31.4 48.59,31.47 51.48,31.47
DGND on BOTTOM (solid shape): 72.69,88.55 73.17,88.55 73.4,88.32 73.4,85.63 71.9,84.13 71.9,83.19 71.85,83.14 71.5,83.14 71.37,83.26 71.37,88.55 71.52,88.7 72.54,88.7
DGND on BOTTOM (solid shape): 73.56,111.99 73.56,111.62 73.55,108.64 73.56,108.56 73.33,108.33 70.94,108.33 70.79,108.49 70.79,111.87 71.09,112.17 73.38,112.17
DGND on BOTTOM (solid shape): 91.46,156.14 91.46,151.26 91.08,150.88 84.4,150.88 84.32,150.96 84.32,152.99 84.58,153.24 87.73,153.24 88.19,153.7 88.19,156.14 88.36,156.32 91.28,156.32
DGND on BOTTOM (solid shape): 10.59,74.93 10.59,74.07 10.59,74.04 10.92,73.71 12.19,73.71 12.57,73.33 12.57,69.65 12.32,69.4 3.43,69.4 3.04,69.78 3.04,74.6 3.55,75.11 10.41,75.11
DGND on BOTTOM (solid shape): 81.86,108.94 81.86,101.81 80.95,100.89 76.83,100.89 76.63,101.1 76.63,102.95 76.98,103.31 79.27,103.31 79.68,103.71 79.68,103.99 79.68,109.2 79.75,109.27 81.53,109.27
DGND on BOTTOM (solid shape): 82.62,66.81 82.47,66.65 81,66.65 80.95,66.7 80.95,67.82 80.69,68.08 78.1,68.08 78.05,68.08 78,68.13 78,69.06 78.1,69.16 78.1,69.73 82.62,69.73
DGND on BOTTOM (solid shape): 93.98,57.84 93.98,56.06 93.6,55.68 88.39,55.68 87.5,54.79 87.5,51.87 86.99,51.36 83.18,51.36 82.55,52 82.55,56.19 82.04,56.7 82.04,57.97 82.55,58.47 93.34,58.47
DGND on BOTTOM (solid shape): 143.91,177.8 143.91,174.45 145.01,173.36 145.01,170.89 144.65,170.54 142.72,170.54 142.47,170.79 142.47,173.49 141.83,174.12 140.74,174.12 140.59,174.27 140.59,178.03 140.79,178.24 143.48,178.24
DGND on BOTTOM (solid shape): 306.73,11.54 306.73,6.25 306.22,5.74 303.78,5.74 303.55,5.97 303.55,8.44 303.76,8.64 304.75,8.64 305.1,9 305.1,11.51 305.18,11.59 306.68,11.59
DGND on BOTTOM (solid shape): 67.23,107.65 67.23,106.86 67.56,106.53 68.7,106.53 68.7,106.2 68.68,106.18 67.84,106.18 67.66,106 64.54,106 64.36,106.18 64.36,107.45 64.87,107.95 66.93,107.95
DGND on BOTTOM (solid shape): 38.6,34.98 38.6,33.58 38.48,33.46 34.03,33.46 33.4,32.82 33.4,32.01 33.12,31.73 29.94,31.73 29.84,31.83 29.84,33.02 30.27,33.46 31.54,33.46 32.13,34.04 32.13,34.98 32.51,35.36 38.22,35.36
DGND on BOTTOM (solid shape): 64.74,152.67 64.8,152.75 64.9,152.73 65.4,152.23 70.05,152.23 71.07,151.21 71.07,148.14 69.59,146.66 66.72,146.66 64.88,144.82 64.74,144.96
DGND on BOTTOM (solid shape): 93.43,180.24 93.51,180.19 93.49,180.09 92.99,179.58 92.99,174.93 91.97,173.92 88.9,173.92 87.42,175.39 87.42,178.26 85.58,180.1 85.72,180.24
DGND on BOTTOM (solid shape): 152,180.24 152.08,180.19 152.06,180.09 151.56,179.58 151.56,174.93 150.54,173.92 147.47,173.92 146,175.39 146,178.26 144.15,180.1 144.29,180.24
DGND on BOTTOM (solid shape): 223.11,50.3 223.11,49.53 223.39,49.25 223.67,49.25 223.77,49.15 223.77,46.08 223.64,45.95 221.56,45.95 221.33,46.18 221.33,48.52 221.71,48.9 221.92,48.9 222.37,49.36 222.37,50.3 222.5,50.42 222.98,50.42
DGND on BOTTOM (solid shape): 318,80.7 317.9,80.6 310.84,80.6 310.44,81 309.22,81 308.71,80.5 308.71,79.18 308.96,78.92 308.96,78.72 306.24,78.72 303.76,76.23 299.54,76.23 297.48,78.29 297.51,78.31 297.51,81.97 297.18,82.3 297.18,82.35 297.23,82.4 318,82.4
DGND on BOTTOM (solid shape): 65.26,81.04 65.26,78.32 65.07,78.13 63.98,78.13 63.7,78.41 63.7,79.18 63.57,79.3 62.58,79.3 62.51,79.23 62.51,79.07 62.43,79 61.08,79 60.91,79.18 60.91,79.86 61.08,80.04 63.57,80.04 63.73,80.19 63.73,81.16 63.8,81.23 65.07,81.23
DGND on BOTTOM (solid shape): 71.02,180.45 71.11,180.39 71.09,180.29 70.58,179.78 70.58,175.14 69.57,174.12 66.49,174.12 65.02,175.59 65.02,179.98 65.34,180.26 65.72,180.45
DGND on BOTTOM (solid shape): 29.11,82.66 29.2,82.6 29.18,82.5 28.67,81.99 28.67,77.35 27.66,76.33 24.58,76.33 23.11,77.8 23.11,81.44 22.05,82.5 22.03,82.6 22.11,82.66
DGND on BOTTOM (solid shape): 64.72,118.63 64.77,118.71 64.87,118.69 65.38,118.19 70.02,118.19 71.04,117.17 71.04,114.1 69.57,112.63 65.94,112.63 64.87,111.56 64.77,111.54 64.72,111.63
DGND on BOTTOM (solid shape): 313.74,9.33 314.57,8.87 315.4,9.33 317.57,9.33 317.95,8.94 317.95,1.53 317.19,0.77 311.45,0.77 309.75,2.47 309.75,5.16 312.37,7.78 312.37,8.92 312.77,9.33
DGND on BOTTOM (solid shape): 219.22,94.78 218.09,91.94 218.59,88.93 218.31,88.65 214.19,88.65 212.21,90.63 212.21,93.48 213.89,95.15 219.22,95.15
DGND on BOTTOM (solid shape): 165.68,23.6 165.68,19.97 166.61,19.04 166.63,18.94 166.55,18.88 159.7,18.88 159.33,19.03 159.18,19.4 159.18,20.7 158.89,21.58 158.14,22.12 158.08,22.18 158.1,22.27 160.91,25.07 164.21,25.07
DGND on BOTTOM (solid shape): 260.95,35.4 257.95,35.4 257.95,36.34 257.95,37.9 258.6,37.9 258.6,35.9 258.6,35.87 258.61,35.82 258.62,35.76 258.65,35.72 258.68,35.67 258.72,35.63 258.77,35.6 258.81,35.57 258.87,35.56 258.92,35.55 258.95,35.55 259.95,35.55 259.98,35.55 260.03,35.56 260.08,35.57 260.13,35.6 260.18,35.63 260.22,35.67 260.25,35.72 260.28,35.76 260.29,35.82 260.3,35.87 260.3,35.9 260.3,37.9 260.3,37.93 260.29,37.98 260.28,38.04 260.25,38.08 260.22,38.13 260.18,38.17 260.13,38.2 260.09,38.23 260.03,38.24 259.98,38.25 259.95,38.25 258.95,38.25 258.92,38.25 258.87,38.24 258.81,38.23 258.77,38.2 258.72,38.17 258.68,38.13 258.65,38.08 258.62,38.04 258.61,37.98 258.6,37.93 258.6,37.9 257.95,37.9 257.95,38.4 260.95,38.4
DGND on BOTTOM (solid shape): 39.62,84.12 39.67,84.05 39.87,83.85 39.9,83.76 39.83,83.68 34.39,82.59 28.86,82.27 2,82.27 1.3,81.98 1.02,81.28 1.02,69.28 1.3,68.58 2,68.3 8.06,68.3 10.19,67.41 11.08,65.28 11.08,63.2 10.57,63.2 10.57,65.28 9.83,67.05 8.06,67.79 2,67.79 0.94,68.23 0.51,69.28 0.51,81.28 0.94,82.34 2,82.78 28.87,82.78 34.25,83.09 39.54,84.13
DGND on BOTTOM (solid shape): outline of 184 points within 10.57,0.51 318.3,45.42
DGND on BOTTOM (solid shape): outline of 163 points within 43.6,78.69 318.3,180.49
DGND on L3 (solid shape): 100.07,153.24 100.07,149.63 99.87,149.43 92.88,149.43 92.55,149.76 92.55,153.19 92.81,153.44 99.87,153.44
DGND on L3 (solid shape): 117.78,154.46 117.78,149.81 117.65,149.69 112.26,149.69 112.04,149.91 112.04,154.61 112.26,154.84 117.4,154.84
DGND on L3 (solid shape): 292.88,76.99 292.88,73.23 292.78,73.13 291.08,73.13 290.95,73.26 290.95,76.91 291.08,77.04 292.83,77.04
DGND on L3 (solid shape): outline of 159 points within 298.14,68.58 304.87,75.44
DGND on L3 (solid shape): outline of 193 points within 292.4,50.83 295.09,58.65
DGND on L5 (solid shape): 100.66,153.98 100.66,149.66 100.4,149.41 92.48,149.41 92.22,149.66 92.22,153.98 92.48,154.23 100.4,154.23
DGND on L5 (solid shape): 91.46,156.09 91.46,151.26 91.08,150.88 84.53,150.88 84.32,151.08 84.32,152.99 84.58,153.24 87.73,153.24 88.19,153.7 88.19,156.14 88.36,156.32 91.23,156.32
DGND on L5 (solid shape): 117.75,154.49 117.75,153.73 117.75,153.73 117.75,149.89 117.62,149.76 112.47,149.76 112.06,150.17 112.06,153.6 112.06,153.6 112.06,154.64 112.26,154.84 117.4,154.84
DGND on L8 (solid shape): 91.46,156.09 91.46,151.26 91.08,150.88 84.53,150.88 84.32,151.08 84.32,152.99 84.58,153.24 87.73,153.24 88.19,153.7 88.19,156.14 88.36,156.32 91.23,156.32
DGND on L8 (solid shape): 117.7,157.71 117.7,153.7 117.65,153.65 117.65,149.89 117.52,149.76 112.39,149.76 111.86,150.3 111.86,152.61 111.43,153.04 100.83,153.04 100.35,152.56 100.35,149.51 100.23,149.38 92.33,149.38 92.2,149.51 92.2,157.56 92.68,158.04 117.37,158.04
DGND on L10 (solid shape): 117.7,157.71 117.7,149.81 117.57,149.69 112.47,149.69 111.86,150.3 111.86,152.61 111.43,153.04 100.83,153.04 100.35,152.56 100.35,149.51 100.25,149.41 92.3,149.41 92.2,149.51 92.2,157.56 92.68,158.04 117.37,158.04
DGND on L10 (solid shape): outline of 702 points within 295.25,49.51 308.53,57.41
DGND on TOP: 131.47,137.09 131.47,139.25 132.13,139.25 132.2,139.17 132.2,138.87 132.38,138.69 133.37,138.69 133.6,138.92 133.6,143.54 134.67,144.61 136.27,144.61 136.47,144.4 136.47,138.81 134.74,137.09
DGND on TOP: 174.89,131.25 174.89,132.23 174.66,132.46 174.36,132.46 174.18,132.28 174.05,132.28 173.99,132.22 173.39,132.22 173.22,132.05 173.22,131.87 172.99,131.64 172.76,131.64 172.76,131.25
DGND on TOP: 184.98,75.19 184.76,75.42 184.76,79.18 183.66,80.27 175.56,80.27 172.34,77.04 166.62,77.04 166.52,77.14 166.52,83.09 166.95,83.52 174.88,83.52 175.23,83.16 194.61,83.16 194.99,82.78 194.99,82.58 195.02,82.55 213.15,82.55 213.41,82.3 213.41,76.23 213.15,75.97 207.9,75.97 207.74,76.13 207.74,77.6 207.16,78.18 205.41,78.18 205.2,78.39 205.2,80.47 195.32,80.47 194.61,79.76 194.61,75.54 194.26,75.19
DGND on TOP: 107.48,137.15 107.31,137.15 107.13,137.33 107.13,137.75 107.51,138.12 108.19,138.12 108.43,137.87 108.43,137.13 108.84,136.73 108.84,131.42 107.34,131.42 107.21,131.55 107.21,134.88 107.85,135.51 107.85,136.78
DGND on TOP: 117.22,138.12 118.11,138.12 118.53,137.69 118.53,137.13 118.36,136.96 117.34,136.96 117.22,137.09
DGND on TOP: 309.93,9.2 309.93,7.24 310.11,7.06 311.53,7.06 311.88,7.42 311.88,9.15 311.76,9.27 310,9.27
DGND on TOP: 222.27,69.75 223.36,68.66 226.46,68.66 226.74,68.94 226.74,71.63 226.13,72.24 226.13,73.03 226.49,73.38 227.2,73.38 227.2,75.82 226.92,76.1 223.82,76.1 222.27,74.55
DGND on TOP: 114.91,137.44 114.91,137.85 115.01,137.95 115.96,137.95 116.23,137.68 116.23,136.93 116.18,136.88 115.74,136.88 115.74,136.89 115.62,137.01 115.34,137.01
DGND on TOP: 165.8,126.22 165.8,126.68 165.66,126.81 165.02,126.81 164.76,127.07 164.76,127.17 164.63,127.31 163.61,127.31 163.54,127.24 163.54,126.15 163.37,125.98 162.43,125.98 161.46,125.02 161.46,124.84 161.56,124.74 161.83,124.74 162.16,124.41 162.16,124.12 162.22,124.06 163.25,124.06 163.37,124.18 163.37,125.36 163.51,125.5 164.18,125.5 164.32,125.64 164.32,125.98 164.47,126.14 165.72,126.14
DGND on TOP: 146.73,170.08 146.73,165.79 146.91,165.61 148.64,165.61 148.64,170.08 148.43,170.29 146.94,170.29
DGND on TOP: 113.04,137.15 112.75,137.15 112.59,137.31 112.59,137.81 112.68,137.9 113.59,137.9 113.77,137.72 113.77,137.21 114.17,136.81 114.17,134.52 115.01,133.68 115.01,131.5 114.93,131.42 113.51,131.42 113.36,131.58 113.36,136.83
DGND on TOP: 227,52.89 230.91,52.89 230.91,53.78 227.73,53.78 226.49,55.02 226.49,56.06 226.39,56.16 225.29,56.16 225.22,56.09 225.22,53.01 225.37,52.86 226.97,52.86
DGND on TOP: 110.31,127.27 110.31,128.07 109.83,128.54 109.59,128.54 109.17,128.12 109.17,127.27
DGND on TOP: 100.71,126.83 100.53,127 100.53,128.27 100.83,128.58 100.83,135.64 102.05,136.86 102.05,137.49 102.5,137.94 103.34,137.94 103.61,137.67 103.61,137.23 102.85,136.47 102.85,133.69 102.84,133.68 102.84,130.38 102.64,130.38 102.46,130.2 102.46,128.65 102.59,128.53 103.09,128.53 103.47,128.14 103.47,127.48 103.17,127.18 101.39,127.18 101.04,126.83
DGND on TOP: 24.15,64.67 24.15,63.2 24.23,63.12 25.07,63.12 25.14,63.2 25.14,64.7 25.09,64.75 24.23,64.75
DGND on TOP: 203.68,19.64 203.73,19.59 207.03,19.59 207.24,19.79 207.24,21.39 206.98,21.64 206.19,21.64 206.17,21.62 206.17,21.11 206.07,21.01 203.7,21.01 203.68,20.98
DGND on TOP: 207.79,176.2 207.92,176.08 210.16,176.08 210.28,176.2 210.28,179.63 210.16,179.76 207.92,179.76 207.79,179.63
DGND on TOP: 258.72,19.82 258.57,19.66 255.62,19.66 255.55,19.74 255.55,20.7 255.75,20.91 258.62,20.91 258.72,20.81
DGND on TOP: 136.19,161.27 142.49,161.27 142.8,160.96 142.8,153.7 142.95,153.55 144.45,153.55 144.83,153.93 144.83,160.35 143.96,161.22 143.96,162.87 143.81,163.02 136.17,163.02 135.91,162.77 135.91,161.55
DGND on TOP: 171.59,134.86 171.59,135.57 171.46,135.7 171.22,135.7 171.08,135.56 171.08,135.14 171.02,135.08 170.65,135.08 170.47,134.91 170.47,133.37 170.64,133.2 170.89,133.2 170.97,133.27 170.97,133.65 171.12,133.8 171.71,133.8 172.02,134.11 172.4,134.11 172.61,133.9 172.96,133.9 173.06,133.8 173.06,133.41 173.15,133.31 173.4,133.31 173.51,133.42 173.51,134.34 173.33,134.51 171.94,134.51
DGND on TOP: outline of 236 points within 162.67,120.31 179.84,141.24 ; 1 cut-out
DGND on TOP: 92.83,129.37 92.94,129.26 93.77,129.26 93.95,129.44 93.95,135.59 93.85,135.69 92.91,135.69 92.83,135.61
DGND on TOP: 306.5,8.94 306.5,6.02 306.32,5.85 303.93,5.85 303.73,6.05 303.73,7.7 303.96,7.93 305.08,7.93 305.23,8.08 305.23,8.94 305.3,9.02 306.42,9.02
DGND on TOP: 308.23,47.45 311.19,47.45 311.52,47.2 311.93,47.12 318.24,47.12 318.33,47.03 318.33,40.64 317.82,40.13 307.95,40.13 307.56,40.05 307.24,39.83 300.66,39.83 298.09,42.4 298.09,45.37 300.48,47.76 303.12,47.76 305.47,45.41 306.89,45.41 307.18,45.7 307.18,46.41
DGND on TOP: 161.6,129.63 161.46,129.78 161.46,130.12 161.5,130.15 161.96,130.15 161.96,130.26 162.03,130.34 162.51,130.34 162.71,130.53 162.71,130.8 162.11,130.8 162,130.91 162,134.16 161.85,134.32 161.85,135.33 162.56,136.05 162.56,136.48 163.37,136.48 163.37,135.84 163.5,135.72 164.06,135.72 164.21,135.87 164.21,136.43 164.31,136.53 164.79,136.53 164.79,135.33 164.98,135.14 164.98,131.04 164.4,131.04 164.4,128.48 164.3,128.38 163.62,128.38 163.29,128.71 163.29,129.47 163.13,129.63
DGND on TOP: 144.83,74.6 144.27,74.04 144.27,72.09 144.14,71.96 142.41,71.96 142.21,72.16 142.21,75.64 142.82,76.25 144.6,76.25 144.83,76.03
DGND on BOTTOM: 134.79,154.84 136.39,154.84 137.89,153.34 137.89,145.42 137.31,144.83 132.64,144.83 132.2,145.27 132.2,151.74 133.27,152.81 133.93,152.81 134.72,153.6 134.72,154.77
DGND on BOTTOM: 162.51,132.1 162.51,131.3 162.06,130.85 161.88,130.85 161.84,130.89 161.84,132.47 161.9,132.53 162.08,132.53
DGND on BOTTOM: 163.39,125.3 163.05,125.64 163.05,125.82 163.25,126.01 163.25,126.06 163.24,126.07 163.24,127.54 163.34,127.64 163.44,127.64 163.9,127.18 163.9,127.04 163.79,126.93 163.79,126.63 163.9,126.52 163.9,126.35 163.8,126.26 163.8,125.89 163.9,125.79 163.9,125.67 163.53,125.3
DGND on BOTTOM: 62.2,86.59 61,85.8 59.71,85.17 59.71,84.86 59.84,84.74 61.29,84.74 61.44,84.59 62.76,84.59 62.79,84.61 62.79,86.57 62.61,86.74 62.35,86.74
DGND on BOTTOM: 152.18,166.16 152.62,166.16 153.33,166.87 153.33,168.14 153.26,168.2 152.29,168.2 152.04,167.95 152.04,166.3
DGND on BOTTOM: 128.39,73.33 136.14,73.33 136.52,72.95 136.52,71.56 136.27,71.3 128.65,71.3 128.14,71.81 128.14,73.08
DGND on BOTTOM: 73.71,131.42 73.71,132.46 73.33,132.85 73.33,133.28 79.37,139.32 79.37,139.47 77.52,141.33 77.52,142.24 80.39,145.11 80.39,145.27 81.1,145.98 81.76,145.32 81.76,138.2 81.07,137.52 81.07,134.39 80.11,133.43 79.14,133.43 78.86,133.15 78.86,128.04 78.27,127.45 78.27,125.7 78.18,125.61 76.12,125.61 76.07,125.66 76.07,126.57 75.74,126.9 73.22,126.9 72.95,127.18 72.95,130.92 73.05,131.02 73.3,131.02
DGND on BOTTOM: 165.31,126.38 165.31,126.49 164.78,127.02 164.78,127.22 165.3,127.75 165.3,127.88 164.87,128.32 164.87,128.64 165.37,129.14 165.37,129.28 165.34,129.28 164.94,129.68 164.94,130.3 164.88,130.37 164.7,130.37 164.6,130.27 164.6,128.21 164.84,127.97 164.84,127.69 164.42,127.27 164.42,126.98 164.53,126.88 164.53,126.65 164.37,126.49 164.37,126.3 164.76,125.9 164.84,125.9
DGND on BOTTOM: 185.21,72.27 184.81,72.67 184.81,80.39 174.9,80.39 174.67,80.17 174.67,79.18 172.56,77.07 165.76,77.07 165.5,77.32 165.5,82.76 165.66,82.91 194.48,82.91 194.61,82.78 194.61,72.85 194.03,72.27
DGND on BOTTOM: 174.43,138.99 174.43,139.81 174.36,139.89 174.13,139.89 173.38,139.14 173.38,138.24 173.84,137.78 173.95,137.78 174.07,137.9 174.07,138.02 173.96,138.14 173.96,138.46 174.23,138.74 174.23,138.79
DGND on BOTTOM: 181.11,55.28 181.11,50.4 181.29,50.23 182.41,50.23 182.81,50.63 186.98,50.63 187.13,50.79 187.13,53.15 186.47,53.81 186.47,56.96 186.09,57.34 183.63,57.34 183.52,57.24 183.52,55.36 183.45,55.28
DGND on BOTTOM: 161.49,128.58 161.49,127.78 161.93,127.34 162.12,127.34 162.15,127.37 162.15,128.96 162.1,129.01 161.92,129.01
DGND on BOTTOM: 168.1,122.4 168.57,122.4 168.86,122.69 168.86,123.17 168.81,123.22 168.81,123.31 168.94,123.44 169.07,123.44 169.56,122.95 169.56,122.74 169.04,122.22 169.04,122.17 169.16,122.06 169.16,121.82 169.06,121.72 168.92,121.72 168.59,122.05 168.12,122.05 167.84,121.77 167.53,121.77 167.47,121.83 167.47,122.4 167.45,122.42 167.45,123.38 167.51,123.44 167.66,123.44 168.13,122.97 168.13,122.81 168.1,122.77
DGND on BOTTOM: 136.01,155.1 137.33,155.1 137.59,155.35 137.59,159.44 137.33,159.69 136.01,159.69 135.76,159.44 135.76,155.35
DGND on BOTTOM: 104.04,72.04 104.04,71.66 104.54,71.15 106.65,71.15 106.91,71.4 106.91,73.31 106.75,73.46 104.8,73.46 104.77,73.43 104.77,72.77
DGND on BOTTOM: 126.87,60.25 143.25,60.25 143.51,60 143.51,58.42 143.34,58.26 142.78,58.26 142.54,58.02 142.54,56.47 142.39,56.32 140.36,56.32 139.62,55.58 139.62,51.54 139.32,51.24 128.39,51.24 126.49,53.14 126.49,59.87 ; 1 cut-out
DGND on BOTTOM: 178.65,129.17 178.65,129.97 178.22,130.4 178.02,130.4 177.97,130.35 177.97,130.1 177.96,130.09 177.96,129.69 177.95,129.68 177.95,129.52 177.95,129.51 177.95,128.98 177.96,128.98 177.96,128.8 178.05,128.71 178.19,128.71
DGND on BOTTOM: 191.12,55.33 191.12,50.46 191.3,50.28 192.42,50.28 192.83,50.68 196.99,50.68 197.14,50.84 197.14,53.2 196.48,53.86 196.48,57.01 196.1,57.39 193.64,57.39 193.54,57.29 193.54,55.41 193.46,55.33
DGND on BOTTOM: 227.45,33.3 227.45,32.41 231.09,32.41 231.16,32.49 231.16,32.9 230.76,33.3
DGND on BOTTOM: 164.31,131.27 164.76,130.82 164.94,130.82 164.97,130.86 164.97,133.19 164.92,133.25 164.74,133.25 164.31,132.82
DGND on BOTTOM: 130.46,170.92 136.43,170.92 136.68,170.67 136.68,166.09 136.2,165.61 133.58,165.61 133.38,165.81 133.38,168.5 133.12,168.76 128.93,168.76 128.81,168.89 128.81,170.03 129.31,170.03 129.44,170.16 129.44,170.66 129.31,170.79 128.93,170.79 128.68,171.04 128.68,172.27 128.77,172.37 130.17,172.37 130.2,172.34 130.2,171.17
DGND on BOTTOM: 138.43,73.46 145.54,73.46 145.67,73.33 145.67,72.19 145.54,72.06 138.43,72.06 138.3,72.19 138.3,73.33
DGND on BOTTOM: 239.14,63.53 239.14,42.93 259.43,42.93 259.43,63.53 ; 2 cut-outs
DGND on BOTTOM: 161.23,55.26 161.23,50.38 161.41,50.2 162.52,50.2 162.93,50.61 167.1,50.61 167.25,50.76 167.25,53.12 166.59,53.78 166.59,56.93 166.21,57.31 163.74,57.31 163.64,57.21 163.64,55.33 163.57,55.26
DGND on BOTTOM: 178.62,134.09 178.62,134.9 178.17,135.34 177.99,135.34 177.95,135.31 177.95,133.72 178,133.67 178.19,133.67
DGND on BOTTOM: 201.16,55.31 201.16,50.43 201.34,50.25 202.45,50.25 202.86,50.66 207.03,50.66 207.18,50.81 207.18,53.17 206.52,53.83 206.52,56.98 206.14,57.36 203.67,57.36 203.57,57.26 203.57,55.38 203.49,55.31
DGND on BOTTOM: 221.66,76.08 221.66,68.69 221.26,68.28 219.12,68.28 218.77,67.92 218.77,65.56 219.15,65.18 219.15,64.75 219.94,64.75 219.94,65.18 220.06,65.31 229.28,65.31 229.38,65.21 229.38,64.8 229.43,64.75 230.2,64.75 230.22,64.77 230.22,65.31 230.45,65.54 230.45,67.87 230.17,68.15 227.96,68.15 227.61,68.51 227.61,76.1 227.38,76.33 221.92,76.33
DGND on BOTTOM: 170.59,124.4 170.59,123.6 171.04,123.16 171.22,123.16 171.26,123.19 171.26,124.78 171.21,124.83 171.02,124.83
DGND on BOTTOM: 175.86,134.04 175.86,134.83 175.35,135.33 175.22,135.33 174.85,134.96 174.85,134.71 175.12,134.44 175.12,133.87 175.14,133.85 175.14,133.69 175.2,133.63 175.44,133.63
DGND on BOTTOM: 100.2,147.63 100.19,147.64 99.93,147.64 98.14,149.43 92.73,149.43 91.97,150.19 91.97,154.79 92.15,154.97 95.58,154.97 95.75,154.79 95.75,153.98 96.06,153.67 96.69,153.67 99.97,150.4 99.97,149.51 101.09,148.39 101.09,147.63
DGND on BOTTOM: 68.81,71.02 68.81,68.86 69.31,68.35 73.2,68.35 73.83,68.99 74.85,68.99 75,69.14 75,71 74.9,71.1 68.88,71.1
DGND on BOTTOM: 160.17,129.78 160.53,129.41 160.72,129.41 160.75,129.45 160.75,131.78 160.7,131.84 160.52,131.84 160.17,131.49
DGND on BOTTOM: 177.21,138.28 177.21,139.08 176.77,139.53 176.58,139.53 176.55,139.49 176.55,137.9 176.6,137.85 176.78,137.85
DGND on BOTTOM: 160.1,124.26 160.54,123.81 160.73,123.81 160.76,123.85 160.76,126.18 160.71,126.24 160.53,126.24 160.1,125.81
DGND on BOTTOM: 172.9,121.49 172.9,123.8 172.59,124.1 172.44,124.1 172.36,124.02 172.36,121.96 172.07,121.66 172.07,121.45 172.09,121.42 172.83,121.42
DGND on BOTTOM: 151.13,65.21 151.13,51.74 151.38,51.49 155.95,51.49 156.33,51.87 156.33,59.62 157.98,61.27 157.98,66.48 156.97,67.49 153.41,67.49
DGND on BOTTOM: 163.92,122.11 163.92,122.36 163.81,122.47 163.81,122.84 163.87,122.9 163.87,123.05 163.47,123.46 163.35,123.46 162.89,123 162.89,122.86 163.41,122.34 163.41,122.11 163.25,121.95 163.25,121.77 163.31,121.7 163.52,121.7
DGND on BOTTOM: 178.64,124.29 178.64,125.09 178.2,125.53 178.01,125.53 177.98,125.5 177.98,123.29 178.18,123.09 178.46,123.09 178.48,123.12 178.48,124.13
DGND on BOTTOM: 173.68,127 173.58,126.9 173.58,124.69 173.75,124.53 173.75,121.8 173.84,121.7 174,121.7 174.29,122 174.29,122.12 174.31,122.14 174.31,125.41 174.48,125.58 174.48,125.83 174.27,126.04 174.16,126.04 173.92,126.27 173.92,126.59 174.16,126.83 174.16,127.51 174.05,127.62 174.05,130.52 174.19,130.66 174.19,130.92 174.39,131.12 174.39,131.49 174.38,131.5 174.38,131.81 174.47,131.9 174.47,132.14 174.4,132.21 174.15,132.21 174.06,132.3 174.06,132.41 174,132.48 174,134.42 174.21,134.64 174.3,134.64 174.4,134.74 174.4,135.65 174,136.05 173.8,136.05 173.74,135.99 173.74,135.97 173.55,135.78 173.55,132.32 173.47,132.24 173.47,131.07 173.68,130.86
DGND on BOTTOM: 166.7,131.98 166.7,132.78 166.26,133.22 166.07,133.22 166.04,133.19 166.04,131.6 166.09,131.55 166.28,131.55
DGND on BOTTOM: 99.31,170.87 105.28,170.87 106.04,170.11 106.04,166.55 105.66,166.17 102.61,166.17 102.23,166.55 102.23,168.46 101.98,168.71 97.79,168.71 97.66,168.84 97.66,169.98 98.17,169.98 98.29,170.11 98.29,170.62 98.17,170.74 97.79,170.74 97.53,171 97.53,172.22 97.63,172.32 99.03,172.32 99.06,172.29 99.06,171.12
DGND on BOTTOM: 165.29,122.31 165.29,122.13 164.89,121.72 164.75,121.72 164.4,122.07 164.4,122.4 164.81,122.81 164.81,123.04 164.32,123.52 164.32,123.7 164.76,124.13 164.89,124.13 164.95,124.08 164.95,123.9 164.78,123.74 164.78,123.52 165.29,123.01 165.29,122.83 165.2,122.74 165.2,122.4
DGND on BOTTOM: 101.72,178.11 102.23,177.6 135.61,177.6 135.89,177.88 135.89,179.4 135.53,179.76 101.98,179.76 101.72,179.51
DGND on BOTTOM: 168.11,132.68 168.11,133.48 167.66,133.93 167.48,133.93 167.44,133.89 167.44,132.31 167.49,132.25 167.68,132.25
DGND on BOTTOM: 237.11,43.39 237.74,43.39 238.25,42.88 238.25,42.32 238.51,42.07 239.57,42.07 239.7,41.94 239.7,41.71 239.57,41.58 238.25,41.58 238.15,41.48 238.15,41.48 238.15,41.43 237.84,41.13 237.51,41.13 236.98,41.66 236.6,41.66 236.47,41.79 236.47,42.75
DGND on BOTTOM: outline of 89 points within 170.55,124.54 173.07,135.97
DGND on BOTTOM: 175.41,125.89 175.8,126.28 175.8,126.61 175.4,127.02 175.4,127.37 175.74,127.7 175.74,127.96 175.62,128.08 175.62,128.25 175.85,128.48 175.85,128.63 175.7,128.78 175.7,128.96 175.87,129.13 175.87,129.3 175.74,129.43 175.74,130.07 175.37,130.44 175.16,130.44 175.07,130.36 175.07,130.08 175.06,130.07 175.06,128.18 175.2,128.04 175.21,128.04 175.25,127.99 175.25,127.66 175,127.41 175,126.89 175.29,126.6 175.29,126.23 174.99,125.93 174.99,125.22 174.84,125.06 174.84,124.93 175.24,124.53 175.34,124.53 175.41,124.6
DGND on BOTTOM: 231.14,32.92 231.72,32.34 232.46,32.34 232.61,32.19 232.61,31.12 232.53,31.04 231.7,31.04 230.12,32.62 230.12,32.92
DGND on BOTTOM: 141.93,142.85 142.21,142.57 145.39,142.57 145.48,142.66 145.48,144.03 145.41,144.1 142.36,144.1 141.93,143.67
DGND on BOTTOM: 164.76,133.61 164.42,133.95 164.42,134.33 164.44,134.35 164.44,134.98 164.56,135.11 164.56,135.14 164.56,135.15 164.56,137.44 164.73,137.6 164.73,137.85 164.56,138.02 164.56,139.33 164.56,139.33 164.56,139.39 164.3,139.64 164.3,139.82 164.41,139.93 164.54,139.93 164.66,139.8 164.93,139.8 165.03,139.91 165.2,139.91 165.3,139.81 165.3,139.62 164.98,139.29 164.98,138.81 165.03,138.75 165.03,138.06 165.08,138.02 165.08,136.56 165.2,136.44 165.2,136.04 164.82,135.67 164.82,135.39 165.07,135.14 165.07,134.51 164.83,134.27 164.83,134 164.99,133.84 164.99,133.72 164.88,133.61
DGND on BOTTOM: 235.68,35.87 235.81,35.74 238.35,35.74 238.48,35.87 238.48,37.11 238.35,37.24 235.81,37.24 235.68,37.11
DGND on BOTTOM: 160.1,132.67 160.54,132.22 160.73,132.22 160.76,132.26 160.76,135.29 160.71,135.35 160.53,135.35 160.1,134.92
DGND on BOTTOM: 178.49,123.2 178.49,123.34 178.39,123.44 178.01,123.44 177.95,123.38 177.95,123.26 178.11,123.1 178.11,122.82 177.97,122.68 177.97,122.5 178.02,122.45 178.02,121.75 178.05,121.72 178.26,121.72 178.59,122.05 178.59,123.09
DGND on BOTTOM: 84.16,63.08 83.69,63.55 83.69,66.07 83.13,66.62 83.13,72.78 83.82,73.46 103.76,73.46 103.88,73.33 103.88,73.08 103.25,72.44 103.25,71.56 102.87,71.17 85.98,71.17 85.85,71.05 85.85,68.76 85.98,68.63 150.49,68.63 151,68.13 151,63.05 150.62,62.67 111.11,62.67 111.13,62.64 111.13,59.09 110.78,58.73 102.5,58.73 101.89,58.12 94.92,58.12 94.05,58.99 85.95,58.99 84.73,60.21 84.73,60.23 84.16,60.79 ; 1 cut-out
DGND on BOTTOM: 260.2,65.15 259.61,64.57 259.61,63.89 259.99,63.51 260.35,63.51 260.85,64.01 261.62,64.01 261.79,64.19 261.79,65.05 261.69,65.15
DGND on BOTTOM: 74.16,52.38 78.48,52.38 78.74,52.63 78.74,54.79 78.23,55.3 74.04,55.3 73.91,55.17 73.91,52.63
DGND on BOTTOM: 171.57,125.65 171.57,125.84 171.12,126.29 171.12,126.56 171.25,126.69 171.25,126.87 171.18,126.94 171.02,126.94 170.6,126.51 170.6,126.27 170.91,125.96 170.91,125.32 171.02,125.21 171.17,125.21 171.24,125.27 171.24,125.32
DGND on BOTTOM: 120.09,170.87 126.06,170.87 126.82,170.11 126.82,166.55 126.44,166.17 123.39,166.17 123.01,166.55 123.01,168.46 122.76,168.71 118.57,168.71 118.44,168.84 118.44,169.98 118.95,169.98 119.08,170.11 119.08,170.62 118.95,170.74 118.57,170.74 118.31,171 118.31,172.22 118.41,172.32 119.81,172.32 119.84,172.29 119.84,171.12
DGND on BOTTOM: 308.23,47.45 311.19,47.45 311.52,47.2 311.93,47.12 318.24,47.12 318.33,47.03 318.33,40.51 317.95,40.13 307.95,40.13 307.56,40.05 307.24,39.83 300.66,39.83 298.09,42.4 298.09,45.37 300.48,47.76 303.12,47.76 305.48,45.39 306.88,45.39 307.18,45.7 307.18,46.41
DGND on BOTTOM: outline of 115 points within 152.02,120.26 155.19,142.7
DGND on BOTTOM: 112.98,166.17 112.6,166.55 112.6,168.46 112.34,168.71 108.15,168.71 108.03,168.84 108.03,169.98 108.53,169.98 108.66,170.11 108.66,170.62 108.53,170.74 108.15,170.74 107.9,171 107.9,172.22 108,172.32 109.39,172.32 109.42,172.29 109.42,171.13 109.68,170.87 115.53,170.87 115.66,170.75 115.66,170.19 115.89,169.95 116.28,169.95 116.41,169.83 116.41,166.55 116.03,166.17
DGND on BOTTOM: 172,138.4 172,137.6 172.44,137.15 172.63,137.15 172.66,137.19 172.66,138.77 172.61,138.83 172.42,138.83
DGND on BOTTOM: 49.32,87.25 49.32,84.2 49.48,84.05 52.5,84.05 52.63,84.18 52.63,86.92 52.04,87.51 49.58,87.51
DGND on BOTTOM: 162.93,129.15 163.27,128.81 163.27,128.22 163.25,128.2 163.25,128.1 163.34,128.01 163.44,128.01 163.92,128.49 163.92,128.69 163.45,129.15 163.45,129.35 163.97,129.87 163.97,130.03 163.58,130.42 163.58,133.97 163.64,134.04 163.8,134.04 163.92,134.15 163.92,134.32 163.8,134.44 163.58,134.44 163.58,134.64 163.52,134.7 163.52,134.98 163.97,135.44 163.97,135.62 163.59,136 163.59,136.72 163.54,136.77 163.54,137.1 163.59,137.15 163.59,139.32 163.89,139.61 163.89,139.84 163.8,139.93 163.56,139.93 163.21,139.59 163.21,138.54 163.27,138.49 163.27,138.18 162.96,137.87 162.96,131.13 162.94,131.11 162.94,129.9 163,129.84 163,129.74 163.04,129.71 163.04,129.38 162.93,129.27
DGND on BOTTOM: 168.1,129.18 168.1,129.98 167.66,130.43 167.47,130.43 167.44,130.39 167.44,128.81 167.49,128.76 167.68,128.76
DGND on BOTTOM: 168.09,137.73 167.65,138.17 167.46,138.17 167.43,138.14 167.43,135.8 167.48,135.75 167.67,135.75 168.09,136.17
DGND on BOTTOM: 162.17,123.23 162.17,123.3 162,123.47 162,123.76 162.48,124.24 162.48,124.4 162.33,124.56 162.33,124.79 162.5,124.97 162.5,125.09 162.33,125.26 162.33,125.48 162.43,125.58 162.43,125.87 161.98,126.32 161.98,126.54 162.14,126.7 162.14,126.87 162.07,126.94 161.91,126.94 161.5,126.53 161.5,126.35 162.02,125.83 162.02,125.6 161.58,125.16 161.58,124.91 161.97,124.53 161.97,124.18 161.49,123.71 161.49,123.59 161.98,123.1 162.05,123.1
DGND on BOTTOM: 211.19,55.33 211.19,50.46 211.36,50.28 212.48,50.28 212.89,50.68 217.05,50.68 217.21,50.84 217.21,53.2 216.54,53.86 216.54,57.01 216.16,57.39 213.7,57.39 213.6,57.29 213.6,55.41 213.52,55.33
DGND on BOTTOM: outline of 271 points within 154.75,107.65 189.29,154.21 ; 3 cut-outs
DGND on BOTTOM: 171.55,127.99 171.19,128.35 170.98,128.35 170.54,127.91 170.54,127.83 171.05,127.33 171.17,127.33 171.55,127.72
DGND on BOTTOM: 80.9,75.87 80.39,76.38 80.39,79.43 79.88,79.43 79.04,80.27 79.04,83.8 78.66,84.18 77.39,84.18 76.43,85.14 76.43,99.6 76.88,100.05 81.63,100.05 90.52,108.94 125.22,108.94 125.75,108.41 136.62,108.41 137.28,107.75 137.28,95.43 140.46,92.26 140.46,86.29 140.15,85.98 131.26,85.98 129.61,84.33 124.36,84.33 123.9,84.79 123.9,85.7 123.69,85.91 122.58,85.91 122.48,86.01 122.48,86.31 122.3,86.49 118.82,86.49 118.49,86.16 118.49,84.38 118.23,84.13 116.84,84.13 116.58,84.38 116.58,85.4 116.2,85.78 111.81,85.78 111.12,86.47 107.39,86.47 107.08,86.16 107.08,84.71 107.06,84.69 99.56,84.69 98.65,85.6 98.14,85.6 97.99,85.45 97.38,85.45 97.08,85.14 97.08,84.64 96.8,84.36 89.28,84.36 88.06,85.58 86.74,85.58 86.23,85.07 86.23,84.64 85.9,84.31 80.9,84.31 80.9,81.84 105.28,81.84 105.34,81.78 145.22,81.78 146.55,80.45 146.55,76.38 146.05,75.87 ; 3 cut-outs
DGND on BOTTOM: 112.04,153.42 112.04,150.02 112.32,149.74 117.78,149.74 117.85,149.81 117.85,153.67 117.7,153.83 116.74,153.83 116.61,153.95 116.61,154.82 116.48,154.94 113.86,154.94 113.76,154.84 113.76,153.95 113.56,153.75 113,153.75 112.98,153.78 112.39,153.78
DGND on BOTTOM: 171.13,55.26 171.13,50.38 171.31,50.2 172.42,50.2 172.83,50.61 177,50.61 177.15,50.76 177.15,53.12 176.49,53.78 176.49,56.93 176.11,57.31 173.64,57.31 173.54,57.21 173.54,55.33 173.47,55.26
DGND on BOTTOM: 143.46,88.32 143.46,88.8 143.58,88.93 145.18,88.93 145.67,88.45 149.48,88.45 149.73,88.7 149.73,93.15 148.84,94.03 145.54,94.03 144.9,93.4 141.47,93.4 141.09,93.02 141.09,88.42 141.25,88.27 143.41,88.27
DGND on BOTTOM: 137.56,137.9 137.72,137.75 142.87,137.75 143,137.87 143,138.56 142.74,138.81 137.82,138.81 137.56,138.56
DGND on BOTTOM: 208.33,76.05 207.97,76.41 207.97,77.65 207.36,78.26 205.81,78.26 205.69,78.39 205.69,79.96 205.1,80.55 199.54,80.55 199.36,80.72 199.36,82.1 199.54,82.27 201.34,82.27 202.26,83.19 202.26,84.71 202.23,84.71 202.1,84.84 202.1,85.93 202.26,86.08 203.37,86.08 203.48,85.98 203.48,83.01 203.55,82.93 204.63,82.93 205.43,83.73 210.35,83.73 213.15,80.93 213.15,76.23 212.98,76.05
DGND on BOTTOM: 169.83,131.59 169.83,131.77 169.71,131.9 169.71,132.13 169.86,132.28 169.86,132.46 169.02,133.29 169.02,133.57 169.5,134.04 169.5,134.22 169.13,134.59 168.96,134.59 168.84,134.47 168.84,133.91 168.62,133.69 168.62,133.08 169,132.7 169.06,132.7 169.06,132.69 169.36,132.39 169.36,132.25 169.25,132.14 169.25,131.9 169.63,131.52 169.76,131.52
DGND on BOTTOM: 303.73,33.94 304.49,33.94 304.75,34.19 304.75,36.73 304.49,36.99 303.73,36.99 303.48,36.73 303.48,35.26 303.07,34.85 303.07,34.12 303.23,33.95 303.72,33.95
DGND on BOTTOM: 204.47,171.78 206.45,171.78 206.6,171.94 206.6,174.58 206.5,174.68 204.42,174.68 204.37,174.63 204.37,171.89
DGND on L2: outline of 170 points within 0.51,0.51 318.3,180.49 ; 1 cut-out
