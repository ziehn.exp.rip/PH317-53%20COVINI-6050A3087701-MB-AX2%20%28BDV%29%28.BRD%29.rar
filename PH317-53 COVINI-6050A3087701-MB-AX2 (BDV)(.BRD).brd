# Allegro board PH317-53 COVINI-6050A3087701-MB-AX2 (BDV)(.BRD).brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
P2V5: length 82.8
  L5 w0.762: v5(83.51,60.81) 84.07,60.25 129.51,60.25 129.99,60.73 153.13,60.73 155.62,63.23 155.62,66.96 153.69,68.89 v5(153.69,69.07) v5(153.06,69.7)
  BOTTOM w0.381: 144.12,87.65 C4131.1 ; C4133.1 156.21,73.02 ; 156.21,71.23 C4132.1 ; 145.03,87.65 C4134.1
  vias: v5(148.21,80.85) v5(148.74,80.27)
P3V3_NV_SEQ: length 174.5
  TOP w0.254: R51593.2 152.85,87.97 v1(152.88,87.94) 152.96,87.94 R51592.1
  L3 w0.254: v1(112.52,55.69) 112.52,55.93 114.37,57.79 117.01,57.79 v1(118.49,59.26) ; v1(112.52,55.69) 105.01,55.69 v1(103.88,54.56) ; v1(112.52,55.69) 112.52,54.49 113.74,53.27 115.78,53.27 v1(117.53,51.51) ; v1(119.8,51.51) 126.87,51.51 127.94,50.45 129.89,50.45 130.71,49.64 133.73,49.64 v1(134.21,50.12) 134.75,49.58 137.91,49.58 138.25,49.91 146.4,49.91 146.91,49.41 v1(149.4,49.41)
  L5 w0.254: v1(119.8,51.51) 119.32,52 118.01,52 v1(117.53,51.51)
  L8 w0.254: v1(152.88,87.94) 153.67,87.15 153.67,75.63 153.67,75.21 154.77,74.11 154.77,62.27 152.17,59.67 152.17,52.17 v1(149.4,49.41)
  BOTTOM w0.254: v1(103.88,54.56) 104.33,54.56 U53550.5 ; v1(103.88,54.56) 103.88,54.01 U53555.5 ; v1(103.88,54.56) C53550.1 ; C53580.1 118.08,59.26 v1(118.49,59.26) 118.61,59.26 118.93,58.95 U53580.5 ; v1(134.21,50.12) 134.44,49.88 R53530.1 ; U53500.5 107.19,49.97 106.95,49.74 C53500.1 106.93,47.89 108.66,46.16 113.81,46.16 115.35,47.69 115.35,49.06 U53540.5 116.65,50.36 116.65,50.7 C53540.1 R53541.2 v1(117.53,51.51) ; 125.73,45.95 125.44,45.95 124.05,47.34 124.05,49.25 123.35,49.96 U53590.5 121.46,49.96 C53590.1 121.15,50.33 120.37,51.11 C53570.1 ; 125.73,45.95 125.73,44.5 R51595.1 ; 125.73,45.95 126.79,45.95 127,45.74 R51596.2 ; C53570.1 120.12,51.24 v1(119.8,51.51) ; C53570.1 120.37,51.67 120.63,51.92 121.04,51.92 121.29,52.18 U53570.5 ; v1(112.52,55.69) 112.52,55.71 112.2,56.03 U53585.5 ; R55600.2 142.79,105.31 C53520.1 142.97,104.27 v2(143.58,103.66) 143.84,103.41 R53511.1 144.57,103.34 R53510.1 144.24,102.56 143.9,102.22 U53520.5 143.5,101.95 142.64,101.1 140.31,101.1 139.42,100.21 139.42,97.16 141.17,95.4 144.85,95.4 145.41,95.96 145.42,95.96 150.18,95.96 152.37,93.76 152.37,88.45 v1(152.88,87.94)
P3V3_RTC: length 38.2
  TOP w0.254: C4875.1 C4876.1 260.66,32.5 R4833.2 260.66,34.47 260.88,34.69 260.88,38.18 258.57,40.49 v1(258.57,40.8)
  L10 w0.254: v1(258.57,40.8) 258.09,40.31 258.04,40.31 256.6,38.87 254.59,38.87 248.6,32.87 244.78,32.87 244.78,32.87 244.35,32.87 v1(242.72,31.25)
  BOTTOM w0.254: v1(242.72,31.25) 242.08,31.89 D4700.3 241.25,32.19 v2(242.26,33.2) 242.56,33.5 R4764.1 C4712.1 244.95,33.5 R4762.2 ; v1(258.57,40.8) 258.82,41.04 U4710.BD49 U4710.BC49
P3V3A: length 637.5
  TOP w0.254: R330.1 234.77,25.48 235.07,25.78 235.07,26.4 235.43,26.75 237.05,26.75 v1(237.18,26.62) ; v1(254.1,44.17) v1(253.51,44.17) ; R4909.2 256.48,51.26 v1(256.66,51.44) ; v1(247.63,36.19) 247.63,37.81 249.55,39.73 249.55,43.39 250.59,44.43 250.59,45.8 249.83,46.56 249.83,47.37 ; v1(257.25,61.75) 257.4,61.6 C4813.1 258.01,60.76 258.37,60.4 R4915.2 ; R4827.1 260.12,56.92 260.5,56.54 R4810.1 R4812.1 261.84,56.37 264.72,56.37 ; R4827.1 259.58,57.05 v1(260.12,57.59) ; R4827.1 R4825.1 ; R149.1 256,55.35 R4819.1 256.44,56.16 v1(256.59,56.01) ; R7.1 235.84,21.14 v1(235.84,20.58) ; R4713.2 255.98,64.56 255.98,63.23 255.84,63.1 255.84,61.79 C4870.1 256.77,61.37 v1(256.91,61.23) ; v1(255.84,57.33) 255.84,57.78 256.16,58.1 R4882.1 ; v1(259.18,31.72) 259.18,32.34 R4747.2 R4728.2 ; 264.72,56.37 264,55.65 264,53.9 264.89,53.01 v1(264.89,52.81) 264.89,49.62 v1(264.78,49.51) 264.5,49.51 R4912.2 ; 264.72,56.37 v1(264.73,56.37) ; C4815.1 243.17,54.52 v1(243.25,54.44) ; R4820.1 271.44,59.03 v1(271.5,59.08) ; v1(228.9,22.74) 228.83,22.66 227.38,22.66 225.37,20.65 XU300.8 U300.8 224.48,20.65 223.3,21.84 222.49,21.84 R55.2 C309.1 222.32,21.08 221.92,20.68 221.92,20.04 221.54,19.67 214.34,19.67 R7017.1 214.09,20.83 v1(213.99,20.92) ; C33.1 270.81,56.67 v1(270.18,57.31)
  TOP w0.356: C1300.1 264.62,20.94 264.71,21.03 U1300.4
  TOP w0.381: v1(253.92,53.27) 254.3,53.64 R4803.1 255.42,53.64 v1(255.83,53.24) 256.23,53.64 R4826.1 ; C4829.1 254.1,53.02 ; C4817.1 254.88,46.85 v1(254.81,46.92) ; 253.21,53.02 R4906.2 253.21,52.63 C4872.1 ; v1(254.81,46.92) 255.09,47.2 255.51,47.2 R4726.2 ; v1(254.81,46.92) 254.28,47.45 R4727.2 ; 253.75,54.26 C4869.1 ; 249.85,48.22 R4783.2 ; 249.42,48.61 C4868.1 ; 263.02,22.43 263.02,20.8 263.49,20.33 R1300.2 264.42,20.33 C1300.1 ; C4867.1 247.69,47.94
  L3 w0.254: v1(59.36,66.91) 59.36,52.35 66.43,45.27 66.43,40.99 73.21,34.2 75.62,34.2 75.86,33.96 98.73,33.96 99.16,34.4 105.33,34.4 105.66,34.73 111.32,34.73 111.72,34.33 v1(115.97,34.33) 116.37,34.73 132.18,34.73 133.85,33.05 v1(135.28,33.05) ; v1(259.18,31.72) 258.68,31.72 254.34,36.06 v1(253.74,36.06) 247.76,36.06 v1(247.63,36.19) 246.35,34.9 243.63,34.9 v1(243.1,35.44) 242.59,35.94 239.11,35.94 237.82,34.65 234.9,34.65 v5(234.08,33.84)
  L3 w0.508: v5(234.08,33.84) 232.02,35.89 215.13,35.89 214.65,35.41 213.05,35.41 211.77,36.69 205.47,36.69 204.93,36.15 196.9,36.15 196.57,35.82 191.11,35.82 190.4,35.11 190.4,35 189.78,34.38 177.3,34.38 175.31,32.39 168.78,32.39 168.18,31.79 160.59,31.79 158.06,34.32 154.1,34.32 152.45,32.67 135.66,32.67 v1(135.28,33.05)
  L5 w0.254: v1(219.99,44.91) 219.72,44.65 v1(211.84,44.65) ; v1(235.84,20.58) 230.91,20.58 228.9,22.58 v1(228.9,22.74) ; v1(256.59,56.01) 256.13,56.47 254.15,56.47 254.06,56.38 245.63,56.38 243.68,54.44 v1(243.25,54.44)
  L8 w0.254: v1(34.85,56.84) 32.34,59.35 v1(31.82,59.35) ; v5(234.08,33.84) 234.08,33.99 233.73,34.34 230.7,34.34 229.84,35.21 224.33,35.21 221.92,37.62 220.01,37.62 219.26,36.87 v1(219.26,36.66) ; v1(65.5,111.51) 65.76,111.26 65.76,101.78 v1(66.34,101.2) 65.76,100.61 65.76,93.25 v1(66.67,92.33) 66.19,92.33 64.13,90.27 64.13,88.75 63.04,87.66 63.04,83.37 61.14,81.47 61.14,79.25 61.46,78.92 v1(61.46,73.66) 61.46,70.16 59.36,68.05 v1(59.36,66.91) ; v1(271.5,59.08) 270.76,59.08 270.18,58.5 v1(270.18,57.31) 269.93,57.06 269.04,57.06 268.34,56.36 265.69,56.36 265.68,56.37 v1(264.73,56.37)
  L10 w0.254: v1(31.82,59.35) 32.34,59.35 35.46,62.46 41.12,62.46 45.56,66.91 v1(59.36,66.91) ; v1(72.16,100.56) 70.71,100.56 70.08,101.2 v1(66.34,101.2)
  L10 w0.381: v1(294.89,26.09) 294.51,26.09 291.51,23.09 291.51,21.42 290.5,20.4 265.43,20.4 264.79,21.03 264.79,22.63 v5(263.78,23.65)
  BOTTOM w0.254: R7006.1 219.99,46.72 v1(219.99,44.91) 219.99,42.68 222.47,40.19 222.47,36.22 222.09,35.84 219.73,35.84 219.26,36.31 v1(219.26,36.66) 219.26,36.82 218.82,37.27 R24.1 ; U4710.AW9 256.87,61.16 v1(256.91,61.23) ; R4711.2 R4708.2 ; R4708.2 264.2,49.61 R4911.1 ; R4708.2 264.66,49.63 v1(264.78,49.51) 264.98,49.71 R4908.2 ; U4710.AN44 253.24,43.89 v1(253.51,44.17) ; v1(253.74,36.06) 253.74,35.97 254,35.71 C4816.1 253.42,35.44 R4720.2 R4760.2 R4774.2 ; R7016.1 66.51,101.02 v1(66.34,101.2) ; U3500.1 235.44,20.58 v1(235.84,20.58) 236.04,20.37 C3502.1 C3501.1 237.06,22.06 R3502.2 237.37,22.11 238.53,23.27 238.53,25.05 237.18,26.39 v1(237.18,26.62) 237.18,27.44 237.51,27.77 237.51,31.09 238.12,31.7 238.12,34.06 237.61,34.57 234.87,34.57 ; R705.1 134.65,31.79 Q701.3 ; R4699.2 243.02,35.51 v1(243.1,35.44) ; v1(34.85,56.84) 35.5,57.49 Q3000.1 ; R3501.2 231.92,29.11 232.25,29.44 232.25,29.72 232.62,30.08 R56.2 232.62,30.57 233.31,31.26 C7010.1 ; R354.1 213.47,21.4 213.92,20.96 213.96,20.96 v1(213.99,20.92) ; R4913.1 263.62,54.89 264.15,55.41 R4717.2 R4702.2 264.7,56.39 v1(264.73,56.37) ; v1(270.18,57.31) 270.18,56.24 270.58,55.84 U4700.5 ; R4834.2 247.11,35.51 247.49,35.89 247.49,36.05 v1(247.63,36.19) 247.77,36.33 R4767.2 ; U4710.AT44 254.24,44.17 v1(254.1,44.17) ; R7008.1 63.85,74.32 63.19,73.66 v1(61.46,73.66) ; v1(211.84,44.65) R306.2 R304.2 ; U4710.AY8 v1(257.25,61.75) U4710.BB7 ; R7065.2 67.43,92.33 v1(66.67,92.33) ; PAD282.1 131.88,37.27 v2(129.99,37.27) 117.95,37.27 115.97,35.28 v1(115.97,34.33) R282.2 ; v1(59.36,66.91) v2(62.4,66.91) 63.35,66.91 63.43,66.83 R4742.1 ; R4733.2 264.17,52.58 R4828.1 264.41,52.81 v1(264.89,52.81) 266.14,52.81 266.62,52.33 R4802.1 ; U4710.AP26 253.92,53.27 v1(253.92,53.27) v1(253.16,53.27) 253.16,53.27 U4710.AN26 ; v1(294.89,26.09) 295.77,26.09 R2403.2 ; v1(228.9,22.74) R3500.2 ; R4116.2 84.22,108.93 R41.2 82.5,107.88 82.5,101.88 81.18,100.56 v1(72.16,100.56) ; U4710.V23 245.28,54.44 v1(243.25,54.44) ; R60522.1 69.42,110.94 68.81,111.56 67.23,111.56 67.15,111.64 65.63,111.64 v1(65.5,111.51) R7043.1 ; v1(253.49,54.39) U4710.AN21 ; CN603.48 v1(31.82,59.35)
  BOTTOM w0.508: Q701.3 134.89,32.66 v1(135.28,33.05) 133.98,34.34 133.98,36.06
  vias: v1(247.93,47.99) v1(248.84,48.26) v1(248.84,47.68) v1(249.76,48.01) v1(263.78,25.12) v1(263.78,24.31) v2(234.36,31.7) v5(234.08,33.1) v5(234.85,33.48)
P3V3A_5A_PWEN: length 67.1
  TOP w0.102: R148.1 v1(209.2,20.55)
  L5 w0.102: v1(226.84,20.48) 226.49,20.12 209.62,20.12 v1(209.2,20.55)
  L8 w0.102: v1(209.2,20.55) 209.05,20.4 207.54,20.4 206.04,21.9 204.57,21.9 v1(204.06,21.39) ; v1(190.32,28.27) 195.74,28.27 196.53,29.06 198.07,29.06 198.99,29.98 201.47,29.98 v1(202.38,30.89)
  BOTTOM w0.102: v1(202.38,30.89) 202.13,30.64 202.13,29.49 202.21,29.42 202.21,26.83 203.09,25.95 U1.25 203.09,23.49 202.35,22.75 R314.2 203.1,22.36 v1(204.06,21.39) ; D7005.3 190.38,27.18 190.32,27.25 v1(190.32,28.27) 189.99,27.94 R7003.1 ; v1(226.84,20.48) v2(226.84,21.97) 225.55,23.27 225.55,26.7 226.87,28.02 227.53,28.02 229.1,29.59 U2.3
P3V3A_KBLED: length 32.9
  L8 w0.254: v1(137.26,41.13) 136.95,41.43 v1(135.87,41.43) 135.64,41.66 132.98,41.66 v1(132.75,41.43) ; v1(142.04,41.07) 141.47,41.63 140.6,41.63 v1(140.04,41.08)
  L8 w0.508: v1(137.26,41.13) 137.41,41.28 139.83,41.28 v1(140.04,41.08)
  BOTTOM w0.254: Q700.5 135.84,41.41 135.86,41.43 v1(135.87,41.43) ; Q700.2 132.78,41.41 v1(132.75,41.43) 132.55,41.63 R701.1 v2(132.05,42.42) 132.25,42.62 134.06,42.62 134.23,42.8 R700.1 ; C700.2 138.06,31.94 135.93,34.07 Q701.2
  BOTTOM w0.305: U702.31 v1(142.04,41.07) ; U702.27 v1(140.04,41.08) 140.04,41.73 C706.1
  BOTTOM w0.508: v1(137.26,41.13) 137.26,40.82 136.22,39.78 R703.2 135.8,39.52 135.25,38.96 C701.1 135.25,34.96 135.84,34.37 Q701.2
P3V3A_LAN: length 37.2
  TOP w0.254: 274.9,93.65 273.22,93.65 272.17,94.71 R417.1 271.74,94.71 R418.1 ; 274.9,93.65 C426.1 ; 274.9,93.65 274.9,93.02 276.77,91.15 276.77,91.07 v1(277.39,91.07) ; R419.2 v1(285.6,105.74) ; U400.16 v1(287.45,100.71) 288.06,100.71 288.22,100.87 C419.1
  TOP w0.381: 281.27,93.35 C414.1 281.27,93.12 ; 281.66,92.01 C418.1 281.27,92.46 ; 281.27,94.24 C413.1 281.27,94.01 ; v1(277.39,91.07) R406.2 ; Q400.2 282.69,91.02 283.19,91.52 284.15,91.52 284.62,91.99 R400.1 284.62,92.55 284.23,92.94 R405.2 ; 281.66,95.57 C415.1 281.27,95.13 ; C427.1 v1(280.39,91.85) ; v1(279.27,91.85) C428.1
  L8 w0.254: v1(280.39,91.85) 281.31,92.76 282.85,92.76 283.87,93.78 288.89,93.78 290.13,92.54 v1(290.93,92.54)
  BOTTOM w0.254: R416.2 291.39,93 v1(290.93,92.54) 290.66,92.27 R402.2
  vias: v2(280.26,92.69)
P3V3A_PB: length 64.4
  TOP w0.254: R2424.1 R2423.1 R2422.1 R2405.1 R2404.1 295.61,127.27 296.18,127.27 v1(296.29,127.17) 296.42,127.04 C2425.1 296.59,126.32 296.59,126.26 296.62,126.24 296.62,125.3 295.87,124.55 U2403.13 ; v1(288.24,122.05) 288.46,122.05 288.99,121.52 288.99,121.34 C2419.1 290.52,121.34 291.11,120.76 292.3,120.76 U2403.1 ; R2421.2 299,121.04 299.51,120.53 R2420.2 R2426.2 299.51,119.05 297.94,117.48 294.41,117.48 293.87,118.01 288.95,118.01 v1(288.03,118.93) 288.5,119.39 R2427.2 R2428.2
  L5 w0.254: v1(296.29,127.17) 291.57,127.17 288.24,123.83 v1(288.24,122.05)
  BOTTOM w0.254: R2417.2 280.05,118.5 v1(280.05,119) ; R2408.1 R2407.1 289.6,113.67 R2406.1 289.88,114.71 R2413.1 289.88,115.66 R2412.1 289.49,116.19 289.91,116.61 289.91,117.93 v2(289.06,118.77) 288.19,118.77 v1(288.03,118.93) 288.03,119.01 C2409.1 287.11,119.1 U2401.13 ; R2418.2 280.12,117.11 v1(280.12,116.67) ; v1(280.02,115.04) 280.02,115.38 R2409.2 280.32,115.54 281.45,114.41 C2408.1 282.01,114.33 282.95,115.26 U2401.1 ; v1(280.54,119.82) 280.63,119.72 R2415.2 ; R2416.2 v1(281.09,120.82) ; CN601.3 v1(273.68,94.21)
P3V3A_WLAN: length 33.5
  TOP w0.254: R1350.1 288.82,25.53 288.54,25.25 288.54,24.99 Q1312.1 287.35,23.8 v1(286.07,23.8) ; v1(286.07,23.8) 286.07,24.83 Q1313.1 286.04,25.74 R1351.1 ; v1(286.07,23.8) 286.07,23.32 286.41,22.98 R1359.2 ; R1357.1 282.52,22.99 v1(280.79,22.99) 280.97,22.81 280.97,21.97 R1360.2
  TOP w0.381: C1314.1 292.25,28.06 ; 291.86,26.72 C1313.1 ; R1350.1 289.21,25.91 ; 269.74,29.08 C1319.1 ; C1318.1 269.04,26.84 ; 268.17,29.05 C1316.1 ; 268.64,25.51 C1315.1 ; 268.13,23.19 C1317.1
  L10 w0.254: v1(280.79,22.99) 285.31,22.99 286.07,23.75 v1(286.07,23.8)
  BOTTOM w0.254: CN1300.4 272.7,26.18 273.12,25.76 279.63,25.76 280.31,25.07 280.31,23.47 v1(280.79,22.99) ; v1(289.7,26.41) 289.7,26.41 CN1300.72
  vias: v2(268.32,27.92) v5(270.63,27.74) v5(270.63,27) v5(271.37,27.74) v5(271.37,27) v5(290.83,27.74) v5(290.83,27) v5(291.56,27.74) v5(291.56,27)
P3V3AL: length 654.5
  TOP w0.254: R7603.2 24.88,31.44 v1(24.84,31.4) ; v1(193.24,160.76) 193.2,160.76 192.95,161.01 192.95,161.99 ; v1(217.07,31.6) 217.04,31.62 R360.1 R359.1 216.56,33.96 R361.1 R362.1 ; R514.2 11.83,53.99 v1(11.83,53.78) ; v1(217.17,29.34) 217.17,30.01 R7015.2 ; 192.95,161.99 U250.VDD ; 192.95,161.99 C254.2
  L3 w0.254: v1(239.95,32.74) 239.95,32.69 239.2,31.94 232.09,31.94 231.37,31.22 231.37,29.77 230.83,29.24 222.93,29.24 222.35,29.82 217.65,29.82 v1(217.17,29.34) ; v1(57.6,27.59) 56.12,26.11 53.77,26.11 50.64,22.99 39.23,22.99 36.85,25.38 30.68,25.38 26.13,29.92 26.13,30.1 v1(24.84,31.4) ; v1(195.6,33.76) 195.58,33.79 193.01,33.79 192.18,32.95 178.98,32.95 177.43,31.4 177.06,31.4 177.06,31.4 176.42,31.4 175.69,30.67 174.96,30.67 174.71,30.67 173.4,29.37 160.88,29.37 158.38,31.87 154.33,31.87 153.7,31.23 128.99,31.23 126.8,33.42 109.75,33.42 v1(109.32,33.85) 108.82,34.34 107.39,34.34 105.79,32.74 70.28,32.74 68.02,35 66.37,35 v1(61.82,39.55)
  L5 w0.254: v1(196.9,43.54) 193.82,46.61 152.14,46.61 151,45.47 150,45.47 v1(149.42,44.9) 149,45.32 144.27,45.32 143.79,44.83 v1(143.79,43.79) ; v1(149.8,85.07) 148.71,86.16 146.63,86.16 145.15,87.63 145.15,94.5 144.69,94.96 144.69,112.23 146.02,113.57 146.02,119.79 144.37,121.44 144.37,122.03 143.91,122.48 143.91,125.1 145.16,126.34 145.16,139.25 147.42,141.51 147.42,148.24 153.51,154.33 181.77,154.33 188.78,161.34 192.66,161.34 v1(193.24,160.76)
  L5 w0.305: v1(216.99,41.91) 213.61,41.91 v1(212.44,43.08) 212.34,42.98 208.63,42.98 207.79,43.82 206.09,43.82 v1(204.67,45.24) 204.59,45.24 204.09,45.74 202.51,45.74 v1(202,45.23) 198.59,45.23 v1(196.9,43.54)
  L8 w0.254: v1(149.8,85.07) 149.81,85.07 152.22,82.66 152.22,73.54 151.69,73.01 151.69,65.51 152.55,64.65 152.55,61.85 150.75,60.05 150.75,55.78 147.44,52.48 147.44,49.48 143.79,45.83 v1(143.79,43.79) ; v1(215.45,20.92) 213.79,19.26 203.4,19.26 203.04,18.9 v1(197.02,18.9) ; v1(194.54,32.11) 194.54,32.7 v1(195.6,33.76) 195.6,33.69 196.32,32.97 215.69,32.97 v1(217.07,31.6) 217.07,39.12 v1(216.71,39.48) ; v1(61.82,39.55) 61.82,40.16 58.79,43.19 57.24,43.19 56.59,43.84 54.02,43.84 v1(50.85,47.02)
  L10 w0.254: v1(11.83,53.78) 11.83,49.54 13.16,48.22 13.16,43.08 22.43,33.81 23.32,33.81 24.84,32.29 v1(24.84,31.4)
  BOTTOM w0.254: v1(149.42,44.9) R52074.1 150.19,42.42 150.49,42.12 R52072.2 ; R326.1 v1(204.67,45.24) ; R60013.2 61.82,39.72 v1(61.82,39.55) v2(61.82,38.61) 61.82,31.65 59.02,28.85 CN254.1 CN254.2 v1(57.6,27.59) ; U1.114 216.43,32.33 217.07,31.7 v1(217.07,31.6) ; v1(215.45,20.92) 215.77,21.24 R392.1 L1.1 217.59,20.64 219.72,20.64 220.47,21.39 221.81,21.39 222.42,22 222.42,25.35 221.79,25.99 220.65,25.99 219.74,26.9 v2(219.74,26.98) R7014.1 219.73,29.22 C62.1 218.67,29.22 218.31,28.86 217.6,28.86 217.17,29.29 v1(217.17,29.34) 216.73,29.34 216.34,29.74 R367.2 215.52,29.74 215.31,29.53 U1.121 ; v1(195.6,33.76) 195.6,33.99 195.86,34.24 196.89,34.24 C307.1 197.13,34.16 197.76,33.53 U1.50 ; v1(50.85,47.02) 51.04,47.21 R60007.2 ; v1(239.95,32.74) 239.93,32.74 R4751.1 ; U1.26 202.69,23.75 202.43,23.5 C306.1 202.35,23.22 202.1,22.97 201.78,22.97 201.5,22.69 R314.1 201.5,19.63 200.85,18.98 197.1,18.98 v1(197.02,18.9) 197.02,19.31 195.37,20.96 195.37,23.16 D300.3 192.44,24.48 192.03,24.9 192.03,27.23 192.31,27.51 R321.1 192.79,27.57 193.11,27.89 193.12,27.89 194.21,28.99 TP60191.1 194.24,30.26 194.54,30.56 PAD60191.2 194.63,31.16 194.63,32.02 v1(194.54,32.11) ; v1(109.32,33.85) 109.32,34.55 108.73,35.13 R255.1 ; v1(212.44,43.08) 213.1,43.08 213.36,43.34 C308.1 213.13,43.8 213.13,43.8 R28.2 212.42,43.8 211.08,42.46 211.08,41.37 211.09,41.36 U1.92 ; R348.1 R336.1 215.13,41.22 215.52,41.61 216.68,41.61 v1(216.99,41.91) 217.24,41.91 217.8,41.36 R324.1 217.8,40.19 217.08,39.48 v1(216.71,39.48) ; v1(196.9,43.54) R337.1 ; R343.2 v1(202,45.23)
P3V3AL_EC_AVCC: length 4.1
  BOTTOM w0.254: R326.2 204.31,43.8 204.31,43.8 C310.1 203.78,43.26 203.65,43.13 v2(203.65,42.22) 203.89,41.99 U1.74
P3V3AL_EC_FSPI: length 4.3
  BOTTOM w0.254: R24.2 217.25,37.04 217.25,36.38 C313.1 216.97,36.1 215.96,36.1 215.65,35.79 215.56,35.79 215.31,35.54 U1.106
P3V3AL_EC_VSTBY_PLL: length 6.2
  BOTTOM w0.254: L1.2 216.68,22.94 216.48,23.15 v2(216.48,23.37) C316.1 216.48,24.98 215.9,25.56 215.9,26.37 215.13,27.14 U1.127
P3V3AL_RTC_BAT: length 4.8
  BOTTOM w0.254: v2(156.16,36.4) 156.87,36.4 R4832.2 ; v2(156.16,36.4) 156.16,38.48 156.26,38.59 D4711.3 ; v2(156.16,36.4) 155.46,36.4 R4769.2
P3V3AL_RTC_BAT_BOT: length 14.5
  L10 w0.254: v1(158.19,33.2) 158.67,32.72 162.72,32.72 v1(163.2,33.2)
  BOTTOM w0.254: D4711.1 157.8,36.89 R4832.1 157.8,35.92 158.19,35.53 v1(158.19,33.2) ; TP16.1 165.83,34.14 165.62,34.35 CN4700.1 v1(163.2,33.2)
P3V3AL_RTC_BAT_R: length 95.4
  L5 w0.254: v1(154.56,38.08) 154.84,37.8 160.47,37.8 160.47,37.8 160.64,37.8 160.89,37.8 162.72,35.97 166.05,35.97 168.46,38.38 186.31,38.38 186.61,38.69 189.15,38.69 189.84,38 196.58,38 198.41,36.17 201.65,36.17 204.95,32.87 217.19,32.87 218.28,31.78 220.67,31.78 220.75,31.86 240.79,31.86 v3(241.91,30.74)
  BOTTOM w0.254: v3(241.91,30.74) 242.2,30.45 D4700.1 ; v1(154.56,38.08) 154.54,38.06 R4769.1
P3V3AL_SM: length 12.6
  TOP w0.381: CN1.2 261.39,94.28 261.23,94.45 C51.2 ; C51.2 260.61,94.05 261.38,93.28 CN1.1 ; C51.2 v3(260.61,95.28) ; U50.VDD v1(256.83,100.43)
  L3 w0.381: v1(256.83,100.43) 256.83,99.06 v3(260.61,95.28)
P3V3DS: length 151.6
  TOP w0.254: R67006.1 R67007.1 v1(134.77,47.69) 135.26,47.2 137.64,47.2 138.33,47.88 138.33,48.62 139.56,49.86 139.56,52.09 R67014.1 ; C7570.1 206.65,29.19 207.16,29.19 ; v1(260.47,40.67) 261.06,40.67 264.16,37.57 v1(264.16,37.14)
  L3 w0.254: v1(263.84,40.75) 263.9,40.8 263.9,41.75 264,41.85 v1(264,44.63)
  L5 w0.254: v1(91.36,48.52) 92.78,48.52 93.79,47.5 130.65,47.5 130.84,47.69 v1(134.77,47.69) ; v5(230.43,31.09) 230.48,31.04 239.37,31.04 240.28,30.13 243.35,30.13 244.17,30.94 244.17,33.15 245.64,34.62 251.28,34.62 251.96,35.31 257.07,35.31 257.88,34.49 260.75,34.49 261.31,35.06 261.31,36.22 262.25,37.17 264.13,37.17 v1(264.16,37.14)
  L8 w0.254: v1(295.88,30.33) 295.14,31.07 289.2,31.07 288.79,30.66 281.53,30.66 274.61,37.58 264.75,37.58 264.31,37.14 v1(264.16,37.14) ; v1(260.47,40.67) 262.82,40.67 262.87,40.72 263.82,40.72 v1(263.84,40.75)
  BOTTOM w0.254: v1(264.16,37.14) 264.18,37.11 C4824.1 C4825.1 ; U2502.5 296.21,30.66 v1(295.88,30.33) ; R4793.2 264.27,44.89 v1(264,44.63) 263.55,44.18 R4805.1 ; R4804.1 264.03,40.93 v1(263.84,40.75) ; U4710.BE48 U4710.BE49 259.37,41.32 259.37,41.24 259.94,40.67 v1(260.47,40.67)
  BOTTOM w0.381: C7019.1 229.79,29.94 ; C7017.1 225.89,32.01
  vias: v5(31.24,60.53) v5(32,60.53) v5(207.62,28.19) v5(207.62,27.44) v5(208.37,28.19) v5(208.37,27.44) v5(209.11,28.19) v5(209.11,27.44) v5(209.84,27.44) v5(209.87,28.19) v5(226.08,31.3) v5(226.08,30.56) v5(226.84,31.3) v5(226.84,30.56) v5(229.69,31.09) v5(229.69,30.36) v5(230.45,30.36)
P3V3DS_PB: length 2.2
  TOP w0.381: R406.1 277.01,92.27 v1(276.78,92.5)
  BOTTOM w0.254: R408.1 274.9,90.2 v1(274.85,90.15)
  vias: v1(276.2,92.51) v1(276.5,93.04) v2(283.36,87.81) v5(282.71,89.07) v5(282.71,88.33)
P3V3S: length 422.5
  TOP w0.254: U500.9 18.41,60.13 17.83,60.71 v1(17.83,60.89) ; R4305.1 v1(274.99,74.32) R4302.1 ; v1(261.26,53.27) 261.26,52.99 261.01,52.73 260.63,52.73 260.19,52.3 R4714.1 260.19,51.92 260.01,51.74 R4815.1 260.01,51.1 259.48,50.57 257.22,50.57 256.56,49.91 R4715.1 ; R55820.1 v1(286.37,50.04) ; C7551.1 v1(295.68,80.83) ; v1(282.11,81.82) 282.33,81.6 R56450.1 R56451.1 ; R4214.1 127.89,74.47 129.79,72.57 v1(129.79,71.58) 128.75,70.54 R4220.1 ; U500.1 21.89,59.42 22.15,59.68 22.15,61.39 21.87,61.67 C516.1 22.43,62.06 22.79,62.42 C517.1 ; CN301.1 208.82,30.14 v1(208.45,29.77) ; R525.1 22.96,61.47 22.96,62.4 C517.1 ; v1(177.31,32.08) 177.14,31.91 R1903.1 ; v1(83.46,156.9) 83.49,156.93 R66602.2 ; v1(148.49,77.63) 147.9,77.63 146.92,78.61 R4212.1 R4210.1 ; R7010.1 268.12,47.7 268.13,47.71 R4784.2 268.13,48.59 267.9,48.82 R4779.2 267.9,50.37 R4831.1 R4839.1 267.9,51.79 v1(267.6,52.09) ; v1(146.77,121.3) 146.45,120.98 v1(142.78,120.98) 142.78,124.73 v1(142.87,124.82) ; R4837.1 266.8,54.54 v1(266.34,54.54) 266.29,54.59 266.11,54.59 265.81,54.89 R4705.1 ; v1(247.42,49.41) 246.86,49.41 246.4,48.94 R4707.1 R4768.1 244.62,48.94 R4763.1 243.81,48.89 R4766.1 R4765.1 242.26,48.77 R4773.1 ; v1(271.73,52.78) 271.47,53.04 R4842.1 ; C509.1 15.21,62.81 C508.1 v1(14.15,63.1) ; R4916.2 255.71,58.8 R4808.2 R4806.2 R4809.2 255.41,61.37 R4935.2 255.28,61.66 254.73,62.21 254.73,63.18 R4807.2 254.83,63.69 254.64,63.88 R4919.2 253.82,64.98 253.82,66.07 255.75,68 v1(255.75,68.1) ; v1(152.98,68.18) 152.73,68.18 152.55,68.35 C4130.1 C4129.1 151.83,66.9 151.99,66.74 R4218.1 151.09,65.96 R4216.1 ; v1(296.85,46.82) 297.18,47.15 C7552.1 ; C532.1 23.21,52.28 22.6,52.89 v1(21.97,52.89) 21.92,52.89 21.61,53.19 U500.36 ; C517.1 v1(23.86,62.42) ; R55821.1 v1(286.34,48.87) ; R504.2 v1(12.9,59.04)
  TOP w0.381: R4822.1 v5(237.29,33.2)
  L3 w0.254: v1(204.64,21.39) 204.64,21.7 204.9,21.95 208.1,21.95 v1(208.84,21.21) ; v1(246,35.56) 246,35.54 245.97,35.56 245.97,36.34 246.77,37.14 249.2,37.14 250.19,38.13 v1(250.19,38.26)
  L5 w0.254: v1(129.79,71.58) 136.04,71.58 136.75,72.29 141.27,72.29 142.59,73.61 147.34,73.61 148.74,72.21 149,71.95 149.72,71.95 152.98,68.69 v1(152.98,68.18) ; v1(208.84,21.21) 208.84,21.47 209.62,22.25 215.87,22.25 216.76,23.14 216.76,25.33 217.04,25.62 v1(217.04,25.87) ; v1(83.46,156.9) 83.72,156.9 84.3,156.32 84.3,154.38 83.69,153.78 83.69,141.51 80.06,137.88 80.06,130.47 80.06,129.04 78,126.98 78,126.86 78,84.28 75.51,81.79 75.51,75.09 75.13,74.7 75.13,72.42 74.16,71.45 v1(68.22,71.45) ; v1(261.26,53.27) 261.26,53.2 260.84,52.78 259.97,52.78 259.76,52.58 254.56,52.58 253.59,51.62 253.59,50.65 252.82,49.89 247.9,49.89 v1(247.42,49.41)
  L8 w0.254: v1(177.31,32.08) 177.52,32.08 178.59,33.15 182.29,33.15 184.35,35.21 v5(184.35,37.75) ; v1(217.04,25.87) 217.04,26.11 215.08,28.07 212.29,28.07 211.4,28.96 209.22,28.96 208.45,29.72 v1(208.45,29.77)
  L8 w0.508: v5(226.49,36.9) 227.31,36.07 230.43,36.07 231.21,35.28 235.21,35.28 v5(237.29,33.2) 237.29,34.6 238.17,35.49 240.36,35.49 241.12,36.25 245.31,36.25 v1(246,35.56)
  L10 w0.254: v1(283.13,57.03) 283.13,55.76 286.37,52.52 v1(286.37,50.04)
  BOTTOM w0.254: v1(208.35,36.07) 208.35,31.78 208.45,31.68 v1(208.45,29.77) ; R4780.2 268.67,41.11 R4781.2 ; R4780.2 R4782.2 ; R4780.2 v1(269.31,41.84) ; Q7003.G 187.43,34.71 186.2,35.94 ; C3000.1 20.37,81.64 20.29,81.72 20.11,81.54 v5(20.09,81.56) ; R4453.1 143.56,111.99 145.28,113.72 v1(145.28,115.95) 147.61,115.95 147.86,115.7 U4450.1 147.86,113.73 147.85,113.72 C4450.1 ; U1700.10 96.75,38.39 96.39,38.03 96.39,37.51 C1714.1 ; v1(14.15,63.1) 12.9,61.84 v1(12.9,59.04) ; R4754.1 R4757.1 v1(246,35.56) ; v1(283.13,57.03) 282.7,57.45 R325.1 282.7,58.16 282.72,58.18 Q303.2 282.72,59.01 282.27,59.46 282.27,59.9 282.72,60.35 Q303.5 282.72,61.08 283.01,61.38 R327.1 ; v5(20.09,80.83) 19.16,80.83 U3000.5 ; v1(267.09,51.24) 266.94,51.08 R4755.1 ; C1713.1 101.39,37.29 100.35,38.33 U1700.1 ; U1700.16 96.75,41.12 95.75,42.12 95.6,42.12 95.15,42.57 C1715.1 ; R53505.2 111.45,48.46 v1(111.71,48.72) ; R52073.1 151.13,44.72 R52070.2 ; R55600.1 141.56,105.34 v1(140.64,105.34) ; R55602.1 140.31,99.9 v1(140.55,100.14) ; C1712.1 101.4,42.25 100.35,41.2 U1700.25 ; R50012.2 142.28,120.98 v1(142.78,120.98) ; R51511.2 143.36,125.07 143.11,124.82 v1(142.87,124.82) ; v1(146.77,121.3) 147.26,120.81 R4452.1 ; v1(250.19,38.26) 249.8,37.87 R4818.2 249.8,37.56 249.53,37.3 R4811.2 249.53,35.92 R4749.1 248.82,35.92 R4761.1 ; R4775.1 265.89,56.72 v1(265.73,56.87) ; v1(92.48,53.48) 92.48,53.04 91.82,52.38 R1905.2 90.18,52.24 88.31,50.37 81.86,50.37 80.95,51.28 R1904.1 ; Q4702.2 266.29,54.59 v1(266.34,54.54) 266.39,54.59 Q4702.5 ; R4300.1 62.2,56.84 v1(62.63,57.28) 62.3,57.62 R4301.1 ; R328.1 215.6,42.62 v1(215.78,42.81) 215.95,42.98 R329.1 ; v1(271.23,70.87) 271.24,70.87 271.47,70.64 R56282.2 ; R318.1 204.64,21.73 v1(204.64,21.39) ; v1(217.04,25.87) 217.29,26.12 R317.1 ; R344.1 v1(205.56,45.23) ; R319.1 208.4,21.64 v1(208.84,21.21) ; R25.1 v1(196.47,42.51)
  BOTTOM w0.3: 146.25,79.41 148.04,77.63 v1(148.49,77.63)
  BOTTOM w0.305: C4105.1 C4104.1 v1(145.36,84.81) 145.89,84.81 146.16,84.54 CN4100.255 146.16,81.66 146.25,81.57 146.25,79.41 ; v1(152.98,68.18) 152.9,68.1 151.46,68.1 151.16,68.41 CN4125.255
  BOTTOM w0.381: R56290.2 298.59,33.71 296.77,33.71 296.01,34.47 296.01,35.17 U56250.5 294.73,36.45 ; 294.73,37.49 v5(294.73,38.12) ; C1712.1 102.43,42.25 C1711.1 103.52,42.71 v1(103.76,42.47) ; v5(100.28,45.57) 99.6,46.25 R1702.1 99.18,46.25 R1704.1 ; v1(92.82,42.36) 92.23,41.77 R1705.1 91.44,40.82 R1707.1 R1709.1 91.44,38.4 93.02,36.83 93.7,36.83 93.7,36.83 94.48,36.83 94.49,36.83 94.66,36.83 94.97,37.14 R1701.1 95.31,37.03 C1714.1 ; v5(94.36,44) 94.48,43.87 C1715.1 ; v1(105.22,42.27) 105.68,41.82 R1703.1 R1706.1 R1708.1 105.68,38.71 105.05,38.08 R1718.1 103.29,37.69 102.89,37.29 C1713.1
  vias: v2(62.1,54.03) v2(185.09,36.35) v2(224.66,38.21) v2(236.29,32.82) v5(25.4,62.31) v5(26.22,62.32) v5(62.66,55.1) v5(63.4,55.1) v5(64.13,55.08) v5(152.27,44.94) v5(185.11,37.75) v5(185.87,37.75) v5(224.89,36.9) v5(225.24,37.62) v5(225.65,36.9) v5(226.01,37.62)
P3V3S_DP: length 35.1
  TOP w0.254: U55800.36 v1(294.68,57.61) ; U55800.3 v1(289.81,57.61) ; U55800.9 v1(289.86,54.61) ; U55800.27 294.41,53.11 v1(294.56,53.26) ; U55800.33 v1(294.66,56.11) ; U55800.15 v1(289.84,51.61) ; U55800.24 v1(294.51,51.61)
  TOP w0.432: R55810.2 R55830.2 R55832.2 R55831.2 288.79,47.56 288.3,48.04 R55821.2
  TOP w0.508: R55821.2 288.3,50.02 R55820.2 289.71,50.04 v1(289.86,50.19)
  BOTTOM w0.305: 294.66,56.14 v1(294.66,56.11)
  BOTTOM w0.432: C55821.1 294.41,57.89 v1(294.68,57.61) 294.81,57.48 294.81,56.29 294.66,56.14 ; C55820.1 294.33,56.44 v1(294.66,56.11) 294.66,55.58 C55823.1 294.53,54.84 C55826.1 294.56,54 v1(294.56,53.26) 294.53,53.23 C55827.1 294.53,52.05 294.51,52.03 v1(294.51,51.61) 294.53,51.59 C55822.1 294.53,50.4 294.15,50.02 290.04,50.02 v1(289.86,50.19) 289.94,50.27 289.94,51.51 v1(289.84,51.61) 289.84,54.59 v1(289.86,54.61) 289.86,54.94 C55825.1 290.2,55.89 290.12,55.97 C55824.1 290.12,56.85 289.81,57.16 v1(289.81,57.61)
P3V3S_DPP: length 14.1
  TOP w0.254: R51630.2 297.9,51.43 v1(299.18,50.14)
  L5 w0.254: v1(299.18,50.14) 299.18,50.04 300.96,48.26 303.88,48.26
  BOTTOM w0.254: CN56200.20 307.24,49.28 C56202.1 C56201.1 306.55,48.39
  BOTTOM w0.381: 302.95,35.27 C56252.1 ; C56200.1 306.29,47.95 ; C56251.1 302.95,37.1 ; D56222.2 306.67,46.63
  vias: v2(308,44.58) v5(302.99,37.62) v5(303.81,37.65) v5(303.86,38.48) v5(307.29,48.64) v5(307.26,47.37) v5(307.77,48.03)
P3V3S_EC_VCC: length 5.9
  BOTTOM w0.254: U1.11 208.69,24.28 208.96,24.01 209.8,24.01 210.31,23.5 211.2,23.5 211.96,22.74 C304.1 212.92,22.66 R354.2
P3V3S_HDMI: length 97.3
  TOP w0.254: U56400.7 289.71,69.92 ; 290.75,69.72 290.11,70.36 U56400.8 ; R56414.2 285.71,68.36 286.18,68.83 286.18,68.89 286.5,69.21 C56421.2 286.6,69.17 ; U56400.31 289.31,78.06 v1(289.33,78.08) ; C56420.1 290.67,69.24 290.6,69.17
  TOP w0.292: U56400.3 288.11,70.89 287.32,70.11 287.09,70.11 286.56,69.57 C56421.2
  TOP w0.432: R56430.2 290.78,67.53 291.07,67.81 291.13,67.81 v1(291.36,68.04) 291.39,68.07 291.39,68.86 291.01,69.24 C56420.1 290.75,69.72 ; v1(278.03,69.52) 278.61,70.11 v2(279.32,70.11) L56400.1 ; 286.6,69.17 R56432.2 287.38,69.4 v1(287.78,69.8) ; 289.71,69.92 289.93,69.7 R56436.2 290.6,69.17 ; R56411.2 288.85,81.28 v1(288.34,81.79) 287.96,81.41 R56410.2 ; R56472.2 291.82,65.38 292.33,65.89 v1(292.38,65.89) 292.38,67.08 292.38,67.09 L56408.2 ; R56672.2 v1(300.89,62.89) ; R56413.2 R56414.2
  TOP w0.508: R56451.2 R56450.2 282.4,80.4 v1(282.04,80.04) ; v1(296.08,80.04) 296.1,80.02 R56452.1
  L5 w0.508: v1(296.08,80.04) 296.16,79.96 296.16,70.34 v1(295.2,69.37) 292.38,66.55 v1(292.38,65.89) ; v1(300.89,62.89) 300.4,63.38 300.4,66.55 299.89,67.06 v1(299.67,67.06)
  L8 w0.508: v1(292.38,65.89) 292.88,65.38 294.69,65.38 295.96,64.11 299.67,64.11 v1(300.89,62.89) ; v1(278.03,69.52) 278.3,69.8 v1(287.78,69.8) 288.95,69.8 290.71,68.04 v1(291.36,68.04) 292.37,68.04 293.7,69.37 v1(295.2,69.37)
  BOTTOM w0.381: v1(299.67,67.06) 299.59,67.14 299.59,68.12 299.97,68.5 R56670.2 301,68.5 R56675.2
  BOTTOM w0.508: v1(282.04,80.04) 286.58,80.04 v1(288.34,81.79) 289.31,80.82 289.31,78.11 v1(289.33,78.08) 294.13,78.08 v1(296.08,80.04)
P3V3S_LCDVDD2: length 0.8
  BOTTOM w0.381: C3001.1 20,76.33 ; C3002.1 20,75.44
  vias: v2(21.79,75.95) v5(20.82,76.61) v5(20.82,75.87) v5(27.07,67.21) v5(27.81,67.21)
P3V3S_SENSOR: length 33.2
  TOP w0.254: v1(150.9,46.92) 150.64,47.17 150.64,49.86 148.89,51.62 v1(148.89,56.25)
  L3 w0.254: v1(148.89,56.25) 148.89,56.04 147.52,54.66 141.48,54.66 v3(140.65,55.49) 140.65,52.43 v1(140.26,52.04)
  BOTTOM w0.254: v1(150.9,46.92) 151.3,46.51 R52073.2 R52074.2 ; R52036.2 R52037.2 v3(140.65,55.49) ; R52000.2 149.95,52.8 149.1,53.65 R52061.2 149.1,54.01 149.48,54.38 149.48,55.3 149.1,55.67 R52006.2 v1(148.89,56.25) ; R52039.2 R52038.2 v1(140.26,52.04)
P3V3S_TP: length 25.1
  TOP w0.254: v1(133.2,30.61) 131.95,30.61 130.97,31.59 v2(122.37,31.59) v1(121.41,31.59)
  BOTTOM w0.254: R285.2 120.24,30.47 121.09,30.47 121.41,30.79 Q281.5 v1(121.41,31.59) Q281.2 121.41,33.92 121.45,33.96 R288.2 R287.2
  BOTTOM w0.381: PAD282.2 132.97,33.51 133.78,32.69 133.78,31.17 133.41,30.81 133.4,30.81 v1(133.2,30.61) CN280.1
P5V0:
  vias: v5(18.94,74.32) v5(19.43,73.77) v5(19.99,73.23) v5(49.78,74.86) v5(49.78,74.1) v5(49.78,73.33)
P5V0A_PB: length 12.3
  TOP w0.254: D101.1 314.34,86.61 314.72,86.99 v1(314.72,94.93) ; v1(312.99,94.85) 312.99,93.62 D102.2
  BOTTOM w0.381: 289.91,120.08 C2407.1
  vias: v1(290.8,119.84) v1(290.78,119.03) v2(282.55,90.61) v5(283.97,90.25) v5(284.39,90.85) v5(284.83,90.25) v5(290.06,119.82) v5(290.06,119.06)
P5V0A_USB1: length 5.3
  TOP w0.254: D2400.5 v1(297.56,132.48) ; C2404.1 301.26,122.66 CN2400.1 ; D2402.5 292.99,129.36 293.72,130.1 293.75,130.1 v1(294.13,130.1)
  BOTTOM w0.381: 300.6,140.61 C2415.1 300.6,139.71
  vias: v2(298.29,119.08) v5(300.58,119.43) v5(300.59,118.67) v5(300.6,117.94) v5(301.67,141.08) v5(301.69,140.31)
P5V0DS: length 325.4
  TOP w0.254: R145.2 224.46,46.26 227.81,46.26 228.72,47.17 228.72,48.67 229.44,49.38 229.44,51.46 229.18,51.72 U7003.4 ; R55230.2 205.08,168.23 v1(206.4,169.55) ; v1(286.64,34.19) 287.21,34.19 R2501.1 ; v5(304.11,10.14) 304.25,10 U2500.6 ; U2501.1 283.23,32.43 283.1,32.56 v5(282.62,32.56) v5(281.89,32.56) ; R2500.1 v1(290.04,30.38) ; v1(289.2,29.65) 289.05,29.49 R2557.2 ; v1(280.08,30.89) 280.67,30.89 R2559.1
  TOP w0.381: C7547.1 262.08,24.82 ; 281.28,32.89 C2505.1 ; 303.84,8.53 C2549.1 ; C2506.1 282.61,33.28
  TOP w0.508: TP60200.1 261.39,25.05 261.39,27.08 259.9,28.57 254.72,28.57 254.43,28.27 249.96,28.27 246.73,31.5 244.5,31.5 243.91,32.08 237.36,32.08 235.84,33.61 235.84,35.87 234.26,37.44 233.19,37.44 232.41,38.23 232.41,39.53 230.2,41.74 230.2,42.27 228.66,43.81 228.66,47.11
  L3 w0.254: v1(206.4,169.55) 205.89,169.04 200.96,169.04 199.92,168 195.17,168 193.95,169.22 192.99,169.22 190.34,171.86 190.34,176.97 189.02,178.29 155.8,178.29 154.28,176.77 154.28,170.56 154.61,170.23 v1(155.42,170.23) ; v1(294.93,20.97) 295.91,19.99 v1(296.77,19.99) 300.78,19.99 v1(301.62,20.83)
  L5 w0.254: v5(60.8,74.15) 61.38,74.15 65.58,78.35 65.58,80.72 68.5,83.65 68.5,84.86 68.96,85.32 68.96,86.67 68.96,86.67 68.96,88.46 v1(70.13,89.62) 70.04,89.62 69.65,90.01 69.65,92.37 v1(70.74,93.45) ; v1(193.42,159.08) 195.58,156.92 195.58,100.08 200.81,94.85 200.81,91.01 203.33,88.5 v1(203.33,88.01) ; v1(286.64,34.19) 286.64,33.68 289.94,30.38 v1(290.04,30.38)
  L8 w0.254: v5(261.43,24) 257.43,24 254.89,26.55 248.89,26.55 245.46,29.98 244.85,29.98 243.07,31.75 242.19,31.75 241.42,30.99 241.42,30.03 240.76,29.37 235.48,29.37 234.79,30.05 232.38,30.05 232,29.67 229.23,29.67 228.98,29.92 228.98,30.28 v1(228.65,30.61) ; v1(193.42,159.08) 194.81,160.48 194.89,160.48 201.16,166.75 203.6,166.75 v1(206.4,169.55)
  BOTTOM w0.254: U8.3 295.75,22.1 295.35,21.7 C2402.1 294.56,21.7 294.48,21.7 C2403.1 294.46,20.97 v1(294.93,20.97) ; U2.4 228.7,30.66 v1(228.65,30.61) ; R55210.2 203.2,88.76 203.2,88.14 v1(203.33,88.01) ; R55220.2 206.76,169.55 v1(206.4,169.55) ; R143.2 72.08,89.01 71.46,89.62 U7006.5 v1(70.13,89.62) ; v5(278.13,64.19) 278.32,64 U7002.2 ; v1(155.42,170.23) 155.21,170.02 C67609.1 154.68,170.01 U67600.8 ; v1(301.62,20.83) 301.82,21.03 R2401.2 ; v5(279.22,64.27) 279.12,64.16 U7002.4 ; R2402.2 v1(296.77,19.99) ; R7038.2 R7039.2 70.36,93.82 v1(70.74,93.45)
  BOTTOM w0.381: v5(279.22,64.27) v5(279.22,65) ; 277.49,65.19 C7016.1
  vias: v5(60.07,74.55) v5(60.07,73.79) v5(71.17,28.88) v5(71.9,28.88) v5(72.67,28.86) v5(79.57,55.14) v5(79.57,54.35) v5(80.31,55.14) v5(80.31,54.35) v5(153.84,165.1) v5(154.25,164.42) v5(154.61,165.1) v5(261.43,23.27) v5(261.43,22.53) v5(261.43,21.77) v5(262.17,24) v5(262.17,23.27) v5(262.17,22.53) v5(262.17,21.77) v5(276.98,65) v5(277.42,64.41) v5(278.05,64.92) v5(283.13,33.18) v5(303.88,9.33) v5(304.67,9.32)
P5V0S: length 75.9
  TOP w0.254: R51672.2 296.95,65.3 296.95,66.17 296.71,66.41 R51671.2 v1(296.71,67.95) 295.33,67.95 R51682.2 R51681.2 ; U55300.4 198.21,169.93 C55300.2 199.19,170.35 v1(199.01,170.52)
  TOP w0.381: 30.47,54.89 C519.1
  L3 w0.254: v5(146,171.31) v5(146.74,171.31) 155.14,179.71 188.92,179.71 191.26,177.37 191.26,172.9 192.55,171.61 193.01,171.61 193.37,171.24 197.29,171.24 198.01,170.52 v1(199.01,170.52)
  BOTTOM w0.254: PAD4300.1 v5(65.96,57.26) ; Q250.3 v5(156.12,33.27) v5(156.85,33.27)
  BOTTOM w0.381: R251.1 156.33,34.34 Q250.3 ; 298.88,65.37 C56610.1
  vias: v2(274.19,58.65) v2(298.9,64.19) v5(31.22,50.18) v5(31.21,49.41) v5(44.95,80.85) v5(44.98,80.09) v5(45.72,80.85) v5(45.72,80.12) v5(82.39,59.38) v5(83.13,59.38) v5(83.97,59.38) v5(84.71,59.38) v5(271.65,36.4) v5(271.65,35.64) v5(272.41,36.4) v5(272.41,35.64)
P5V0S_AUDIO_AVDD: length 25.2
  TOP w0.254: v1(26.77,52.89) R500.2 ; U500.26 17.61,53.12 17.38,52.89 16.24,52.89
  TOP w0.381: v1(13.03,52.78) C504.1 13.17,52.01 13.89,52.73 C505.1 15.13,52.73 15.29,52.89 16.24,52.89
  L10 w0.381: v1(26.77,52.89) 25.04,51.16 25.04,49.71 24.13,48.8 18.59,48.8 16.81,50.57 15.95,50.57 13.75,52.78 v1(13.03,52.78)
P5V0S_FAN1: length 0.4
  BOTTOM w0.381: 70.05,58.31 C4304.1
P5V0S_FAN2: length 0.4
  BOTTOM w0.381: 280.16,71.54 C4308.1
P5V0S_HDMI: length 16.5
  TOP w0.254: v3(302.66,62.77) 302.62,62.77 R56680.2 ; R56678.2 v1(297.41,66.63)
  L3 w0.254: 302.71,65.89 303.93,65.89 306.24,68.2 CN56600.18 ; 302.71,65.89 302.66,65.84 v3(302.66,62.77) ; 302.71,65.89 298.9,65.89 298.17,66.63 v1(297.41,66.63)
  BOTTOM w0.381: D56610.2 304.44,65.87
P5V0S_KBLED: length 3.5
  BOTTOM w0.381: C250.1 153,33.44 C255.2 ; C250.1 151.81,32.97 ; C250.1 151.36,33.44 ; 152.56,33.44 C255.2 ; C255.2 153.01,32.92 ; 145.53,33.62 C252.1
  vias: v2(147.47,33.25)
P5V0S_PVDD: length 14.8
  TOP w0.254: v1(23.49,59.87) 23.49,59.77 23.26,59.54 23.26,58.25 22.94,57.92 U500.46 ; U500.41 23.38,55.92 23.54,55.76 v1(23.92,55.76) ; 25.62,55.35 25.65,55.32 C515.1 R513.2
  TOP w0.381: v1(23.49,59.87) 23.49,60.18 24.31,60.99 C520.1 24.88,60.99 24.93,61.04 C521.1
  TOP w0.432: v1(23.92,55.76) 24.18,55.5 C514.1 25.47,55.5 25.62,55.35
  BOTTOM w0.508: v1(23.49,59.87) 23.49,56.19 v1(23.92,55.76)
P5VDS_EN: length 26.5
  L8 w0.102: v1(193.54,33.3) 193.62,33.3 194.71,34.4 208.89,34.4 v1(210.56,36.07)
  BOTTOM w0.102: v1(193.54,33.3) 193.32,33.07 R6901.2 ; v1(210.56,36.07) 210.56,37.06 210.72,37.21 210.72,37.97 211.51,38.76 212.8,38.76 213.17,39.13 U1.97 214.29,39.56 214.28,39.57 R348.2
PVBAT: length 66.8
  TOP w0.381: C7549.1 125.34,34.71 ; 72.93,59.46 C7563.1 ; 75.83,155.91 C7562.1 ; 237.12,31.04 C7560.1 ; 140,46.27 C7565.1 ; 65.4,105.02 C7548.1 ; C7561.1 45.8,78.79
  TOP w0.762: 136.09,179.23 143.33,179.23 144.34,178.21 144.34,174.7 146.73,172.32 150.52,172.32 153.31,175.11 153.31,177.47 155.14,179.3 187.55,179.3
  BOTTOM w0.254: v5(49.83,38.21) 50.26,38.64 C7545.1 ; R5000.1 154.19,41.77 v1(154.19,41.77)
  vias: v2(47.65,47.98) v2(80.77,177.93) v2(135.23,177.96) v5(46.78,38.21) v5(46.81,37.37) v5(47.47,78.79) v5(47.47,78.01) v5(47.52,38.21) v5(47.55,37.37) v5(48.28,38.21) v5(48.31,37.37) v5(49.07,38.21) v5(49.09,37.37) v5(49.86,37.37) v5(63.44,102.49) v5(63.47,103.99) v5(63.47,103.25) v5(64.21,103.99) v5(64.21,103.26) v5(64.18,102.49) v5(65.12,86.28) v5(65.5,87.05) v5(65.88,87.79) v5(65.86,86.29) v5(66.24,87.05) v5(73.83,154.46) v5(73.83,153.67) v5(73.83,152.84) v5(74.62,154.46) v5(74.62,153.67) v5(74.62,152.84) v5(75.38,154.46) v5(75.38,153.67) v5(75.38,152.84) v5(82.55,179.33) v5(82.55,178.44) v5(82.55,177.55) v5(83.36,179.33) v5(83.36,178.44) v5(83.36,177.55) v5(84.15,179.33) v5(84.15,178.44) v5(84.15,177.55) v5(94.92,178.87) v5(94.92,177.98) v5(94.99,177.12) v5(95.73,178.87) v5(95.73,177.98) v5(95.73,177.09) v5(96.52,178.87) v5(96.52,177.98) v5(96.52,177.09) v5(222.58,44.02) v5(223.21,43.64) v5(223.85,44.04) v5(224.48,43.67) v5(225.1,44.07) v5(225.7,43.64) v5(226.27,44.12) v5(226.84,43.65)
PVBAT_CPU: length 15
  TOP w0.254: v1(88.09,171.54) 87.93,171.7 R66199.1
  BOTTOM w0.254: 98.42,176.71 97.53,175.82 95.88,175.82 94.36,174.3 94.36,173.03 92.88,171.56 91.64,171.56 90.59,170.5 89.11,170.5 88.09,171.53 v1(88.09,171.54)
  vias: v2(101.5,172.09) v2(135.66,173.1) v5(102.51,173.92) v5(102.51,173.03) v5(103.27,173.92) v5(103.27,173.03) v5(112.88,173.92) v5(112.88,173.03) v5(113.64,173.92) v5(113.64,173.03) v5(123.29,173.92) v5(123.29,173.03) v5(124.06,173.92) v5(124.06,173.03) v5(133.66,173.97) v5(133.66,173.08) v5(134.42,173.97) v5(134.42,173.08)
PVBAT_GT: length 0.5
  BOTTOM w0.381: 78.92,144.06 C66312.1
  vias: v2(76.32,145.55)
PVBAT_SA:
  vias: v2(139.24,175.34) v5(137.83,174.96) v5(138.57,174.96)
PVBAT_VRAM_DGPU: length 35.2
  L8 w0.254: v1(217.04,63.15) 218.34,63.15 221.94,66.75 232.08,66.75 234.08,68.76 234.08,72.19 235.04,73.14 242.78,73.14 243.15,73.51 243.15,73.69 244.34,74.88 v1(244.34,75.06)
  BOTTOM w0.254: R67218.1 244.34,75.27 v1(244.34,75.06)
  vias: v2(218.74,63.76)
PVCCGT: length 34.6
  TOP w0.254: v1(104.13,143.32) 104.15,143.32 104.9,142.58 R4525.2
  TOP w0.381: C4627.1 98.27,126.28 ; 94.45,128.59 C4659.1 ; 88.09,138.2 C4785.1 ; 98.6,126.74 C4661.1 ; C4683.1 100.01,139.27 ; 90.23,130.48 C4628.1 ; 90.18,133.96 C4680.1 ; 96.29,136.62 C4760.1 ; 100.1,126.02 C4657.1 ; 95.32,126.71 C4687.1 ; C4663.1 87.88,127.17 ; 98.58,136.62 C4761.1 ; 89.27,128.16 C4682.1 ; 94.43,135.6 C4688.1 ; 86.72,129.73 C4629.1 ; 100.39,139.27 C4681.1 ; 92.95,125.96 C4630.1 ; 97.24,139.32 C4658.1 ; 90.02,128.34 C4797.1 ; 91.18,134.56 C4660.1 ; C4631.1 92.7,127.75 ; 90.7,131.82 C4656.1 ; 94.2,136.84 C4668.1
  L10 w0.254: v1(100.98,143.99) 103.31,143.99 103.97,143.32 v1(104.13,143.32)
  BOTTOM w0.203: U4555.BL16 89.44,128.01 v1(89.11,127.68) ; U4555.BR16 86.84,128.01 v1(86.51,127.68) ; U4555.AT33 100.66,141.06 v1(100.98,141.38) ; v1(88.46,127.68) 88.79,128.01 U4555.BM16 ; v1(87.16,127.68) 87.49,128.01 U4555.BP16 ; v1(92.32,140.73) 91.99,141.06 U4555.BG33 ; U4555.BL17 89.44,128.93 v1(89.11,129.26) ; U4555.BD34 94.35,141.71 v1(94.68,141.38) 94.36,141.06 U4555.BD33
  BOTTOM w0.254: U4555.BG36 92,143.01 v1(92.32,143.33) ; 100.07,126.46 U4555.AT14 100.38,126.19 100.82,126.63 ; v1(91.31,133.58) U4555.BJ23 U4555.BK23 ; U4555.BK20 U4555.BJ20 v1(91.31,131.22) ; U4555.BK21 U4555.BJ21 v1(91.31,132.01) ; C7511.2 84.24,149.5 C4589.1 ; v1(91.26,136.15) 91.06,135.95 U4555.BJ26 U4555.BK26 ; v1(91.31,134.37) U4555.BJ24 U4555.BK24 ; 99.73,126.42 U4555.AU14 99.14,126.47 v1(99.01,126.47) 98.88,126.47 U4555.AW14 98.22,126.47 v1(98.09,126.47) ; U4555.BD13 v1(93.52,125.82) 93.86,126.06 U4555.BD14 ; U4555.BL23 v1(89.76,133.98) ; v1(91.31,130.43) U4555.BJ19 U4555.BK19 ; U4555.BJ27 U4555.BK27
  vias: v1(75,122.69) v1(75,122.03) v1(75,121.42) v1(75,120.83) v1(84.95,130.44) v1(87.16,144.74) v1(87.65,142.84) v1(87.81,129.26) v1(87.81,127.68) v1(89.09,141.85) v1(89.17,139.44) v1(89.74,134.76) v1(89.75,137.12) v1(89.96,142.68) v1(89.96,142.03) v1(90.8,144.74) v1(91.53,143.99) v1(91.54,143.32) v1(91.53,142.68) v1(91.53,142.03) v1(91.54,141.41) v1(91.84,136.73) v1(91.9,136.15) v1(92.32,142.03) v1(92.48,137.8) v1(92.76,128.07) v1(93.11,143.99) v1(93.11,142.68) v1(93.11,140.08) v1(93.52,126.47) v1(93.77,128.07) v1(93.89,144.64) v1(93.89,143.33) v1(93.89,142.03) v1(93.89,140.73) v1(94.02,137.91) v1(94.41,128.09) v1(94.63,133.76) v1(94.63,132.54) v1(94.63,131.32) v1(94.63,130.1) v1(94.68,142.68) v1(94.68,140.08) v1(94.68,139.44) v1(95.06,128.09) v1(95.35,126.46) v1(95.47,144.64) v1(95.47,143.33) v1(95.47,137.91) v1(96.26,143.99) v1(96.26,142.68) v1(96.26,141.38) v1(96.26,140.08) v1(96.26,126.47) v1(96.54,137.87) v1(96.67,128.1) v1(97.04,144.64) v1(97.04,142.03) v1(97.04,140.73) v1(97.04,139.44) v1(97.83,143.99) v1(97.83,142.68) v1(97.83,140.08) v1(98.12,146.24) v1(98.62,144.64) v1(98.62,143.33) v1(98.62,142.03) v1(98.62,140.73) v1(98.77,137.91) v1(98.88,146.24) v1(99.01,125.82) v1(99.41,142.68) v1(99.41,141.38) v1(99.41,140.08) v1(99.46,128.86) v1(99.47,126.82) v1(100.06,134.01) v1(100.06,132.79) v1(100.06,131.58) v1(100.06,130.36) v1(100.19,144.64) v1(100.19,143.33) v1(100.19,139.44) v1(100.53,146.07) v1(100.98,142.68) v1(100.98,140.08) v1(101.29,146.07) v5(72.56,122.61) v5(72.56,121.87) v5(72.59,121.14) v5(72.59,120.4) v5(72.82,125.63) v5(72.82,124.9) v5(72.84,124.16) v5(72.84,123.42) v5(73.35,122.61) v5(73.35,121.87) v5(73.38,121.14) v5(73.38,120.4) v5(73.61,125.63) v5(73.61,124.9) v5(73.63,124.16) v5(73.63,123.42) v5(74.16,122.61) v5(74.16,121.87) v5(74.19,121.14) v5(74.19,120.4) v5(74.39,125.63) v5(74.39,124.9) v5(74.42,124.16) v5(74.42,123.42) v5(74.95,120.09) v5(75.21,125.63) v5(75.21,124.9) v5(75.23,124.16) v5(75.23,123.42) v5(92.92,147.66) v5(92.92,146.57) v5(92.92,145.38) v5(92.96,148.55) v5(93.98,148.55) v5(93.96,147.66) v5(93.96,146.57) v5(93.96,145.38) v5(95.12,148.54) v5(95.09,147.66) v5(95.13,146.57) v5(95.23,145.38) v5(96.01,148.52) v5(96.03,147.6) v5(96.03,146.56) v5(96.14,145.34) v5(96.8,134.47) v5(96.8,133.51) v5(96.8,132.59) v5(96.8,131.75) v5(96.8,130.79) v5(96.8,129.82) v5(96.8,128.91) v5(97.58,134.47) v5(97.58,133.51) v5(97.58,132.59) v5(97.58,131.75) v5(97.58,130.79) v5(97.58,129.82) v5(97.58,128.91)
PVCCIO: length 48.6
  TOP w0.254: v1(82.67,135.77) 83.87,134.57 87.81,134.57 R4535.2
  TOP w0.381: 122.22,131.48 C4733.1 ; 121.89,127.78 R4524.2 ; 122.29,129.92 C4731.1 ; C4783.1 121.01,136.29 ; 122.25,135.47 R4544.2
  L5 w0.254: 125.6,126.55 126.87,125.28 126.87,120.45 128.75,118.57 v1(128.75,115.93) ; v1(108.15,125.2) 108.15,125.91 108.66,126.42 120.75,126.42
  BOTTOM w0.203: U4555.H26 U4555.J26 121.56,136.19 121.2,136.55 v1(121.2,136.57) 121.56,136.94 U4555.J27 U4555.H27
  BOTTOM w0.254: U4555.AG12 v1(108.15,125.2) ; TP60500.1 80.21,110.65 C7571.1
  BOTTOM w0.305: U4555.H21 U4555.G21
  BOTTOM w0.508: v1(128.75,115.93) 128.75,110.42 127.63,109.3 125.85,109.3 125.35,109.81 R4501.1
  vias: v1(121.05,134.22) v5(75.79,115.32) v5(75.79,114.58) v5(75.79,113.82) v5(76.53,115.32) v5(76.53,114.58) v5(76.53,113.85) v5(120.93,132.77) v5(120.93,132.03) v5(120.93,131.3) v5(120.98,129.37) v5(120.98,128.6) v5(120.98,127.84)
PVCCSA: length 7.2
  TOP w0.381: R4517.2 120.43,142.56 ; C4780.1 124.22,141.96 ; C4789.1 120.37,139.27 ; 121.16,139.48 C4787.1 ; 122.25,142.89 C4790.1 ; 122.43,141.96 C4782.1 ; 119.75,140.25 C4779.1 ; C4778.1 119.75,142.03 ; C4781.1 119.48,139.27 ; 141.79,160.49 C4791.1
  BOTTOM w0.203: U4555.K30 U4555.J30 U4555.K29 ; U4555.L36 120.35,143.01 v1(120.67,143.33) 120.34,143.66 U4555.L37
  BOTTOM w0.381: C7546.1 138.16,154.44
  vias: v1(119.88,140.08) v1(119.88,139.44) v1(120.63,144.66) v1(120.67,144) v1(120.69,142.69) v1(120.67,142.04) v1(120.67,140.73) v1(120.67,139.44) v1(121.48,144) v1(121.46,143.36) v1(121.47,142.69) v1(121.46,142.04) v1(121.46,141.38) v1(121.45,140.76) v1(128.01,144.45) v5(139.24,155.88) v5(139.24,154.87) v5(139.26,158.93) v5(139.26,157.92) v5(139.26,156.9) v5(139.26,154.08) v5(140.13,155.36) v5(140.13,154.33) v5(140.15,158.34) v5(140.15,157.39) v5(140.15,156.37)
PVCCST: length 378.6
  TOP w0.254: v1(92.32,140.11) 92.47,139.96 R4538.1 R4509.1 ; v1(248.83,67.4) 248.97,67.26 248.97,64.54 247.93,63.5 247.93,61.12 245.79,58.98 243.96,58.98 240.92,55.93 234.24,55.93 ; v5(129.67,138.18) 130.26,137.6 C4541.1 ; R66104.1 R66100.1 R66101.1 C66100.1 82.72,156.65 R4533.1 82.99,156 v1(83.36,155.63)
  TOP w0.381: 126.02,137.26 C4729.1 ; R4570.2 232.84,54.56 233.24,54.97 233.88,54.97 234.24,55.32 234.24,56.72 232.08,58.88 232.08,60.15 230.93,61.29 v1(228.14,61.29) ; 122.15,137.59 C4730.1
  L3 w0.254: v1(122.63,139.76) 122.42,139.56 122.42,139.25 121.15,137.98 v1(121.15,137.31) ; v1(92.32,140.11) 92.36,140.11 92.79,140.54 92.79,140.93 92.51,141.2 92.51,141.56 92.79,141.84 92.79,142.23 92.51,142.5 92.51,142.87 92.79,143.14 92.79,143.53 92.37,143.95 92.24,143.95 91.27,144.91 91.27,144.94 90.99,145.21 90.7,145.21 89.69,146.23 89.69,146.72 87.44,148.97 86.4,150.01 84.79,150.01 83.97,150.83 83.97,155.1 83.44,155.63 v1(83.36,155.63)
  L5 w0.254: v1(92.32,140.11) 92.18,140.11 91.71,140.57 91.69,140.57 90.88,141.38 90.88,142.45 90,143.32 87.36,143.32 86.18,142.14 86.18,139.88 85.95,139.65 83.44,139.65 80.44,136.66 80.44,130.62 80.44,128.88 78.38,126.82 78.38,84.12 75.89,81.63 75.89,74.93 75.66,74.7 75.66,71.71 74.95,71 74.95,70.34 v1(75.55,69.74)
  L5 w0.381: v5(129.67,138.18) 131.62,138.18 140.81,128.99 140.81,120.68 144.27,117.22 144.27,113.87 142.74,112.34 142.74,94.95 143.77,93.93 143.77,75.89 144.47,75.19 148.07,75.19 152.14,71.12 216.44,71.12 224.59,62.97 227.04,62.97 228.14,61.87 v1(228.14,61.29)
  L8 w0.254: v1(92.32,140.11) 92.32,138.99 91.92,138.59 90.88,138.59 90.62,138.33 90.62,136.15 90.78,135.99 90.78,135.95 91.06,135.66 118.46,135.66 119.61,136.81 119.61,137.54 119.99,137.93 120.39,137.93 121,137.31 v1(121.15,137.31) ; v1(250.82,73.13) 250.82,73.1 251.27,72.65 251.43,72.65 251.81,72.27 251.81,71.2 248.83,68.21 v1(248.83,67.4)
  L10 w0.254: v1(75.55,69.74) 75.55,68.01 74.29,66.75 71.88,66.75 69.77,68.86 v1(68.44,68.86)
  BOTTOM w0.203: v1(122.63,139.76) 122.63,139.65 U4555.H30
  BOTTOM w0.254: U4555.J28 121.55,137.75 121.15,137.36 v1(121.15,137.31) ; R4786.2 248.48,67.78 248.51,67.76 248.51,67.72 v1(248.83,67.4) ; R4739.1 68.01,68.86 v1(68.44,68.86) ; R4743.1 R4736.2 250.25,73.83 250.82,73.25 v1(250.82,73.13)
  BOTTOM w0.305: U4555.H28 U4555.J28
PVCCSTG: length 246.2
  TOP w0.254: R7034.2 221.89,53.41 221.89,60.68 222.96,61.75 227.04,61.75 227.45,61.34 v1(227.45,61.29) ; v1(120.49,136.92) 120.68,137.12 120.68,137.51 121.08,137.91 C4766.1 ; R4515.2 89.2,140.94 88.53,140.27 v1(88.47,140.27) 87.49,140.27 86.88,139.66 R4507.1 86.93,139.55 86.93,139.19 86.45,138.71 R4516.2 86.08,138.71 R4510.2
  TOP w0.381: v1(227.45,61.29) 227.45,60.96 227.83,60.58 229.26,60.58 229.77,60.07 v2(229.77,59.54) 229.77,57.81 227.76,55.81 227.76,55.58 C7205.1
  L5 w0.381: v1(120.49,136.92) 120.44,136.92 120.42,136.9 119.96,136.9 119.64,137.22 119.64,137.67 120.56,138.59 122.4,138.59 123.28,139.47 125.32,139.47 125.61,139.18 125.72,139.18 126.63,138.27 126.63,136.35 139.65,123.34 139.65,121.13 143.77,117 143.77,114.08 142.24,112.55 142.24,94.74 143.24,93.73 143.24,75.7 144.26,74.68 146.89,74.68 149.19,72.39 150.03,72.39 151.81,70.62 216.23,70.62 224.38,62.46 226.83,62.46 227.45,61.84 v1(227.45,61.29)
  L8 w0.254: v1(120.49,136.92) 118.85,135.28 90.9,135.28 90.12,136.07 88.16,136.07 86.67,137.56 86.67,139.38 87.55,140.27 v1(88.47,140.27)
  BOTTOM w0.203: U4555.H29 121.95,138.23 121.48,138.23 121.07,137.82 120.97,137.82 120.7,137.55 120.7,137.14 v1(120.49,136.92)
  BOTTOM w0.254: U4555.G30 122.26,138.68 U4555.H29
PVCCSTG_DIS: length 2.5
  TOP w0.102: Q9.3 225.07,49.89 v2(225.07,49.97) 225.03,50 R7034.1
PVCCSTG_DISCHARGE_EN: length 3.5
  TOP w0.102: Q9.6 Q9.5 223.38,48.19 R145.1 222.66,48.28 v2(222.37,48.57) 222.37,49.31 R146.2
PVCCSTG_EN: length 194.9
  TOP w0.102: U7003.3 228.78,51.81 228.88,51.71 228.88,51.59 229.13,51.34 229.13,49.76 v1(228.75,49.38) 228.19,48.82 C7034.1 227.69,48.82 227.68,48.81 R7030.2 226.83,48.81 226.2,48.19 Q9.2
  L3 w0.102: v1(70.23,91.25) 70.66,90.82 70.66,84.31 74.78,80.19 74.78,70.92 75.49,70.21 75.93,70.21 76.2,69.94 76.2,68.35 77.17,67.38 80.22,67.38 95.35,52.25 115.77,52.25 117.01,51.01 126.59,51.01 127.45,50.14 129.77,50.14 130.63,49.27 143.08,49.27 143.38,48.97 150.92,48.97 151.63,49.68 222.43,49.68 222.73,49.38 v1(228.75,49.38)
  BOTTOM w0.102: v1(70.23,91.25) 70.23,91.25 70.23,91.29 70.05,91.47 69.34,91.47 68.79,92.02 R7070.2
VBUS_EN: length 11.4
  BOTTOM w0.102: U8.4 295.91,22.61 295.55,22.97 295.55,24.34 294.41,25.48 294.41,28.45 294.66,28.71 v2(294.66,28.81) 294.66,30.59 294.94,30.86 294.94,31.6 294.58,31.97 U2502.2
VCC_XTAL: length 10.6
  BOTTOM w0.254: 243.33,67.39 244.14,66.58 244.14,64.5 U4710.P2 243.78,64.13 U4710.P3
  BOTTOM w0.381: R4864.1 242.46,72.06 242.28,71.88 C4809.1 C4845.1 242.1,70.31 C4877.1 242.1,68.21 C4846.1 242.11,68.05 242.68,67.48 242.92,67.48 243.01,67.39 243.33,67.39
