# Allegro board PH317-53 COVINI-6050A3087701-MB-AX2 (BDV)(.BRD).brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
M_B_DQ<54>: length 71.6
  L3 w0.076: v1(117.31,121.89) 117.33,121.89 117.47,121.75 117.47,116.99 121.01,113.45 122.49,113.45 124.25,111.69 124.97,109.95 124.97,96.59 139.45,82.11 139.45,74.45 141.26,72.65 141.26,66.26 v3(141.41,64.78)
  BOTTOM w0.076: U4555.R7 117.24,121.89 v1(117.31,121.89)
  BOTTOM w0.109: CN4125.216 v3(141.41,64.78)
M_B_DQ<55>: length 73.4
  L3 w0.076: v3(144.24,65.09) 143.92,65.41 143.92,67.42 143.79,67.55 143.79,68.17 142.73,69.23 142.73,73.26 141.47,74.52 141.47,82.18 126.49,97.16 126.49,111.53 123.71,114.32 122.07,114.32 122.05,114.33 122.05,114.33 118.95,117.42 118.95,120.89 118.6,121.24 118.6,122.18 v1(118.26,122.53)
  BOTTOM w0.076: U4555.P8 118.17,122.54 v1(118.26,122.53)
  BOTTOM w0.109: CN4125.228 144.41,64.93 v3(144.24,65.09)
M_B_DQ<56>: length 76.7
  L3 w0.076: v1(120.92,124.52) 121.33,124.12 121.33,123.75 121.54,123.55 121.54,122.89 122.35,122.08 122.35,121.51 123.02,120.84 123.02,119.88 126.03,116.87 126.71,116.87 130.46,113.12 130.46,98.78 147.24,81.99 147.24,78.21 149.78,75.68 149.78,74.63 149.66,74.52 149.52,74.52 149.41,74.41 149.41,74.25 149.52,74.14 149.66,74.14 149.78,74.03 149.78,73.87 149.66,73.76 149.52,73.76 149.41,73.64 149.41,73.49 149.52,73.38 149.66,73.38 149.78,73.26 149.78,73.11 149.66,72.99 149.52,72.99 149.41,72.88 149.41,72.72 149.52,72.61 149.66,72.61 149.78,72.5 149.78,72.34 149.66,72.23 149.52,72.23 149.41,72.12 149.41,71.96 149.52,71.85 149.66,71.85 149.78,71.74 149.78,71.58 149.66,71.47 149.52,71.47 149.41,71.36 149.41,71.2 149.52,71.09 149.66,71.09 149.78,70.98 149.78,70.82 149.66,70.71 149.52,70.71 149.41,70.6 149.41,70.44 149.52,70.33 149.66,70.33 149.78,70.22 149.78,70.06 149.66,69.95 149.52,69.95 149.41,69.83 149.41,69.68 149.52,69.57 149.66,69.57 149.78,69.45 149.78,69.3 149.66,69.18 149.52,69.18 149.41,69.07 149.41,68.91 149.52,68.8 149.66,68.8 149.78,68.69 149.78,68.53 149.66,68.42 149.52,68.42 149.41,68.31 149.41,68.15 149.52,68.04 149.66,68.04 149.78,67.93 v3(149.78,67.46)
  BOTTOM w0.076: U4555.L11 v1(120.92,124.52)
  BOTTOM w0.109: v3(149.78,67.46) 149.56,67.67 149.56,69.86 CN4125.249
M_B_DQ<57>: length 77.4
  L3 w0.076: v3(145.93,64.34) 145.5,64.34 145.34,64.5 145.34,65.21 145.21,65.34 144.9,65.34 144.73,65.51 144.73,65.92 145.14,66.33 145.14,68.23 144.83,68.54 144.83,73.07 143.28,74.63 143.28,81.88 127.54,97.62 127.54,111.96 124.63,114.86 122.33,114.86 119.89,117.31 119.89,120.94 119.15,121.68 119.15,122.78 119.5,123.13 119.5,123.69 119.57,123.77 119.57,124.06 v1(120.04,124.52)
  BOTTOM w0.076: v1(120.04,124.52) U4555.M11
  BOTTOM w0.109: CN4125.232 145.41,63.81 v3(145.93,64.34)
M_B_DQ<58>: length 73.5
  L3 w0.076: v3(149.91,63.09) 148.57,64.43 148.57,75.62 146.41,77.78 146.41,81.65 129.62,98.43 129.62,112.77 126.17,116.22 125.73,116.22 122.89,118.11 122.86,118.14 121.79,119.74 121.79,121.05 120.9,121.94 v1(120.9,121.95)
  BOTTOM w0.076: U4555.L7 120.8,121.88 v1(120.9,121.95)
  BOTTOM w0.109: CN4125.250 v3(149.91,63.09)
M_B_DQ<59>: length 73.5
  L3 w0.076: v3(145.93,68.24) 145.93,68.24 146.04,68.35 146.04,68.66 145.93,68.77 145.5,68.77 145.39,68.88 145.39,69.06 145.5,69.17 146.2,69.17 146.3,69.27 146.3,69.45 146.19,69.56 145.5,69.56 145.39,69.67 145.39,69.82 145.5,69.94 145.93,69.94 146.04,70.05 146.04,70.21 145.93,70.32 145.5,70.32 145.39,70.43 145.39,70.59 145.5,70.7 145.77,70.7 145.88,70.81 145.88,70.97 145.77,71.08 145.5,71.08 145.39,71.19 145.39,71.35 145.5,71.46 145.72,71.46 145.83,71.57 145.83,71.73 145.72,71.84 145.5,71.84 145.39,71.95 145.39,73.55 144.91,74.03 144.91,78.13 143.92,79.12 143.92,82.05 128.11,97.85 128.11,112.17 124.99,115.3 122.37,115.3 120.38,117.3 120.38,120.94 119.58,121.73 119.58,122.16 119.97,122.55 v1(119.98,122.55)
  BOTTOM w0.076: U4555.M8 119.72,122.25 v1(119.98,122.55)
  BOTTOM w0.109: v3(145.93,68.24) 145.66,68.52 CN4125.233
M_B_DQ<60>: length 76
  L3 w0.076: v3(149.78,65.99) 149.58,65.79 149.27,65.79 149.13,65.92 149.13,75.85 146.96,78.02 146.96,81.88 130.18,98.67 130.18,113 126.48,116.7 126.1,116.7 125.96,116.7 122.85,119.81 122.85,120.77 122.18,121.44 122.18,121.98 121.37,122.8 121.37,123.43 120.93,123.87 v1(120.92,123.87)
  BOTTOM w0.076: v1(120.92,123.87) 120.92,123.87 120.91,123.86 U4555.L10
  BOTTOM w0.109: CN4125.245 148.66,69.4 148.66,69.4 148.66,66.61 149.28,65.99 v3(149.78,65.99)
M_B_DQ<61>: length 75.5
  L3 w0.076: v3(145.95,66.74) 145.95,66.52 145.77,66.34 145.56,66.34 145.42,66.48 145.42,68.35 145.11,68.65 145.11,73.19 143.64,74.66 143.64,75.04 143.87,75.27 143.87,75.61 143.64,75.84 143.64,81.93 127.82,97.76 127.82,112.08 124.79,115.1 122.33,115.1 120.16,117.27 120.16,120.92 119.34,121.75 119.34,122.59 119.66,122.92 119.66,123.55 v1(120.03,123.92)
  BOTTOM w0.076: U4555.M10 v1(120.03,123.92)
  BOTTOM w0.109: CN4125.237 146.76,69.85 146.76,67.12 146.38,66.74 v3(145.95,66.74)
M_B_DQ<62>: length 72.4
  L3 w0.076: v3(146.58,65.62) 146.58,69.74 145.21,76.61 145.21,79.72 144.77,80.16 144.77,81.59 128.39,97.97 128.39,112.29 125.13,115.56 123.91,115.56 121.18,118.28 121.18,120.76 120.76,121.17 120.58,121.17 119.98,121.78 v1(119.98,121.91)
  BOTTOM w0.076: U4555.M7 v1(119.98,121.91)
  BOTTOM w0.109: v3(146.58,65.62) 146.48,65.53 146.48,61.58 CN4125.236
M_B_DQ<63>: length 74.6
  L3 w0.076: v3(149.89,64.56) 148.85,65.6 148.85,75.73 146.68,77.9 146.68,81.76 129.9,98.55 129.9,112.89 126.34,116.45 125.8,116.45 123.03,118.29 122.07,119.74 122.07,121 121.35,121.72 121.35,122.15 v1(120.92,122.57)
  BOTTOM w0.076: v1(120.92,122.57) 120.6,122.25 U4555.L8
  BOTTOM w0.109: v3(149.89,64.56) 148.91,63.58 CN4125.246
M_B_DQS0_DN: length 73.9
  L3 w0.076: v3(88.46,123.74) 88.46,123.58 88.24,123.36 87.65,123.36 87.48,123.18 86.79,123.18 85.75,123.74 85.11,123.74 84.46,123.09 83.74,123.09 83.22,122.57 82.56,122.57 82.28,122.29 82.28,122.25
  L3 w0.081: v1(87.22,67.25) 87.22,67.14 86.88,66.8 86.74,66.8 86.61,66.94 86.61,68.72 85.73,69.59 84.88,69.59 82.18,72.29 82.18,73.11 80.12,75.17 80.12,75.85 77.9,78.07 77.9,79.2 78.5,82.22 78.7,82.9 79.05,83.88 79.72,86.08 79.72,109.86 78.81,110.78 78.81,118.78 82.28,122.25
  BOTTOM w0.076: U4555.BN9 v3(88.46,123.74)
  BOTTOM w0.099: CN4125.11 88.16,68.87 88.46,68.57 88.46,67.98 87.61,67.13 87.34,67.13 v1(87.22,67.25)
M_B_DQS0_DP: length 73.9
  L3 w0.076: 82.1,122.39 82.13,122.41 82.17,122.41 82.49,122.73 83.15,122.73 83.67,123.25 84.39,123.25 85.04,123.9 85.79,123.9 86.83,123.35 87.41,123.35 v1(87.8,123.74)
  L3 w0.081: v3(87.22,66.58) 86.65,66.58 86.38,66.84 86.38,68.62 85.64,69.37 84.79,69.37 81.96,72.19 81.96,73.02 79.9,75.08 79.9,75.75 77.67,77.98 77.67,79.23 78.28,82.28 78.49,82.97 78.84,83.95 79.5,86.11 79.5,109.77 78.58,110.69 78.58,118.87 82.1,122.39
  BOTTOM w0.076: U4555.BP9 87.8,123.73 v1(87.8,123.74)
  BOTTOM w0.099: v3(87.22,66.58) 87.58,66.93 87.69,66.93 88.66,67.9 CN4125.13
M_B_DQS1_DN: length 72.7
  L3 w0.076: 86.33,119.61 86.33,119.63 86.36,119.66 86.36,120.22 87.97,121.83 88.6,121.83 88.74,121.69 89.25,121.69 89.53,121.98 89.53,122.29 89.48,122.34 89.48,123.3 89.83,123.65 v1(89.83,123.83)
  L3 w0.081: 86.33,119.61 86.33,118.93 84.89,117.49 84.62,117.49 82.37,115.24 82.37,111.75 84.11,110.01 84.11,93.4 84.52,92.98 84.52,75.3 91.41,68.42 91.41,66.16 91.11,65.86 91.11,65.18 91.4,64.89 v3(92.27,64.89)
  BOTTOM w0.076: U4555.BL9 v1(89.83,123.83)
  BOTTOM w0.099: CN4125.32 93.41,63.37 93.17,63.61 93.17,64.38 92.66,64.89 v3(92.27,64.89)
M_B_DQS1_DP: length 72.8
  L3 w0.076: 86.55,119.61 86.55,119.63 86.52,119.66 86.52,120.15 88.03,121.67 88.53,121.67 88.67,121.53 89.32,121.53 89.7,121.91 89.7,122.36 89.65,122.41 89.65,122.6 89.73,122.68 89.89,122.68 90.01,122.8 90.01,123.07 v3(89.9,123.17)
  L3 w0.081: 86.55,119.61 86.55,118.84 84.98,117.26 84.71,117.26 82.59,115.14 82.59,111.84 84.33,110.1 84.33,93.49 84.75,93.08 84.75,75.4 91.63,68.51 91.63,66.06 91.34,65.77 91.34,65.27 91.5,65.11 91.74,65.11 91.84,65.21 91.84,65.44 91.97,65.56 92.27,65.56 v1(92.28,65.55)
  BOTTOM w0.076: v3(89.9,123.17) 90.21,123.17 90.32,123.06 U4555.BJ9
  BOTTOM w0.099: v1(92.28,65.55) 93.37,64.47 93.37,63.69 93.61,63.45 93.61,62.95 93.91,62.65 CN4125.34
M_B_DQS2_DN: length 70.8
  L3 w0.076: v3(92.63,123.2) 92.77,123.34 93,123.34 93.12,123.23 93.12,122.93 92.98,122.79 92.98,121.74 91.64,120.4 91.64,118.14 86.94,113.45 86.9,113.45 86.89,113.43
  L3 w0.081: v1(96.62,66.86) 96.75,66.73 97.12,66.73 97.28,66.89 97.28,67.94 89.69,75.53 89.69,102.75 88.69,103.75 88.69,110.28 86.59,112.39 86.59,113.13 86.89,113.43
  BOTTOM w0.076: U4555.BG9 92.58,123.21 v3(92.63,123.2)
  BOTTOM w0.099: CN4125.53 98.59,69.89 98.59,68.83 98.96,68.46 98.96,68 97.35,66.4 97.08,66.4 v1(96.62,66.86)
M_B_DQS2_DP: length 70.7
  L3 w0.076: v1(93.52,123.22) 93.52,123.1 93.15,122.72 93.15,121.67 91.8,120.33 91.8,118.07 87.06,113.33 87.06,113.29 87.05,113.28
  L3 w0.081: v3(96.62,66.19) 96.62,66.26 96.85,66.5 97.21,66.5 97.51,66.8 97.51,68.03 89.91,75.62 89.91,102.84 88.91,103.84 88.91,110.38 86.81,112.48 86.81,113.04 87.05,113.28
  BOTTOM w0.076: v1(93.52,123.22) U4555.BF9
  BOTTOM w0.099: v3(96.62,66.19) 97.43,66.19 99.16,67.92 CN4125.55
M_B_DQS3_DN: length 69
  L3 w0.076: v3(95.37,123.2) 95.76,122.81 95.76,121.51 95.09,120.85 95.09,119.1 94.98,118.98 94.98,118.72 94.96,118.7 94.96,118.62 94.95,118.61 94.95,118.6
  L3 w0.081: 94.95,118.6 94.95,114.42 94.94,114.41 93.56,113.03 93.56,85.68 95.42,83.82 95.42,75.33 101.66,69.09 101.66,65.46 101.94,65.18 102.28,65.18 v1(102.5,64.96)
  BOTTOM w0.076: v3(95.37,123.2) 95.33,123.21 U4555.BC9
  BOTTOM w0.099: CN4125.74 103.91,61.75 103.91,62.82 104.21,63.12 104.21,63.32 103.32,64.2 103.32,65.05 103.01,65.36 102.76,65.36 102.5,65.1 v1(102.5,64.96)
M_B_DQS3_DP: length 68.9
  L3 w0.076: 95.17,118.6 95.18,118.61 95.18,118.62 95.14,118.66 95.14,118.91 95.26,119.03 95.26,120.78 95.92,121.44 95.92,123.1 96.04,123.22 v1(96.26,123.22)
  L3 w0.081: 95.17,118.6 95.17,114.33 95.17,114.32 93.78,112.93 93.78,85.77 95.64,83.91 95.64,75.43 101.88,69.18 101.88,65.55 102.03,65.4 102.3,65.4 102.52,65.62 v3(102.52,65.75)
  BOTTOM w0.076: v1(96.26,123.22) U4555.BB9
  BOTTOM w0.099: v3(102.52,65.75) 102.7,65.56 103.1,65.56 103.53,65.14 103.53,64.29 104.41,63.4 CN4125.76
M_B_DQS4_DN: length 70.1
  L3 w0.076: 116.26,111.27 116.25,111.28 116.25,111.32 112.46,115.1 112.46,121 112.16,121.3 112.16,122.9 112.28,123.02 112.28,123.2 112.21,123.28 111.86,123.28 v3(111.78,123.2)
  L3 w0.081: v1(131.22,67.53) 131.36,67.39 131.68,67.39 131.86,67.57 131.86,68.35 131.4,68.81 131.4,69.23 131.86,69.69 131.86,69.95 131.43,70.38 131.43,70.9 131.86,71.33 131.86,71.72 130.61,72.97 130.61,74.15 129.17,75.59 129.17,82.73 117.56,94.34 117.56,109.97 116.26,111.27
  BOTTOM w0.076: v3(111.78,123.2) 111.78,123.2 U4555.AC9
  BOTTOM w0.099: v1(131.22,67.53) 131.22,67.41 131.37,67.27 131.39,67.27 131.48,67.18 131.63,67.18 131.96,67.51 131.96,68.5 131.62,68.84 131.62,69.92 CN4125.177
M_B_DQS4_DP: length 70.2
  L3 w0.076: v1(112.7,123.2) 112.7,123.2 112.33,122.83 112.33,121.37 112.63,121.07 112.63,115.17 116.36,111.44 116.41,111.44 116.42,111.43
  L3 w0.081: v3(131.22,66.87) 131.52,67.16 131.77,67.16 132.09,67.48 132.09,68.45 131.63,68.9 131.63,69.14 132.09,69.6 132.09,70.05 131.66,70.48 131.66,70.8 132.09,71.23 132.09,71.81 130.83,73.07 130.83,74.24 129.39,75.68 129.39,82.82 117.79,94.43 117.79,110.06 116.73,111.11 116.42,111.43
  BOTTOM w0.076: v1(112.7,123.2) U4555.AA9
  BOTTOM w0.099: CN4125.179 132.16,67.43 131.71,66.98 131.34,66.98 v3(131.22,66.87)
M_B_DQS5_DN: length 71.9
  L3 w0.076: v3(114.57,123.2) 114.93,122.84 114.93,116.36 119.87,111.42 120.28,111.42 120.57,111.13 120.57,111.09 120.58,111.08
  L3 w0.081: 120.58,111.08 121.22,110.44 121.22,96.16 134.52,82.86 134.52,75.28 136.24,73.56 136.24,66.82 136.8,65.47 136.8,64.96 v1(136.6,64.76)
  BOTTOM w0.076: v3(114.57,123.2) 114.53,123.21 U4555.W9
  BOTTOM w0.099: CN4125.198 136.91,62.65 137.06,62.8 137.06,63.42 136.81,64.01 136.81,64.54 v1(136.6,64.76)
M_B_DQS5_DP: length 72
  L3 w0.076: v1(115.47,123.22) 115.1,122.85 115.1,116.43 119.94,111.59 120.34,111.59 120.68,111.25 120.72,111.25 120.74,111.24
  L3 w0.081: v3(137.26,64.76) 137.02,64.99 137.02,65.51 136.47,66.86 136.47,73.65 134.74,75.37 134.74,82.95 121.44,96.25 121.44,110.53 120.74,111.24
  BOTTOM w0.076: v1(115.47,123.22) U4555.V9
  BOTTOM w0.099: v3(137.26,64.76) 137.01,64.51 137.01,64.05 137.26,63.46 137.26,62.8 137.41,62.65 137.41,61.75 CN4125.200
M_B_DQS6_DN: length 73.9
  L3 w0.076: 123.49,113.14 123.48,113.15 123.48,113.19 123,113.67 121.08,113.67 117.69,117.06 117.69,122.85 v1(117.32,123.22)
  L3 w0.081: v3(143.11,66.4) 142.32,66.4 141.75,66.98 141.75,72.85 139.94,74.65 139.94,82.31 125.51,96.74 125.51,111.12 123.49,113.14
  BOTTOM w0.076: v1(117.32,123.22) 117.3,123.23 U4555.R9
  BOTTOM w0.099: v3(143.11,66.4) 143.07,66.44 142.58,66.44 142.16,66.87 CN4125.219
M_B_DQS6_DP: length 74
  L3 w0.076: v3(118.21,123.22) 117.93,123.22 117.86,123.15 117.86,117.12 121.15,113.83 123.07,113.83 123.59,113.31 123.64,113.31 123.65,113.29
  L3 w0.081: 123.65,113.29 125.73,111.21 125.73,96.83 140.16,82.4 140.16,74.75 141.97,72.94 141.97,67.07 142.42,66.62 142.74,66.62 142.82,66.71 142.82,66.88 143.01,67.06 v1(143.11,67.06)
  BOTTOM w0.076: v3(118.21,123.22) U4555.P9
  BOTTOM w0.099: CN4125.221 142.66,68.8 142.36,68.5 142.36,66.95 142.66,66.64 142.77,66.64 142.94,66.81 142.97,66.81 143.11,66.94 v1(143.11,67.06)
M_B_DQS7_DN: length 74.5
  L3 w0.076: 126.18,115.21 126.14,115.24 126.14,115.27 125.63,115.79 124.42,115.79 121.42,118.78 121.42,120.85 120.93,121.34 120.73,121.34 120.37,121.71 120.37,121.72 120.36,121.73 120.36,122.89 120.37,122.9 v3(120.05,123.22)
  L3 w0.081: 126.18,115.21 128.91,112.48 128.91,98.14 145.7,81.35 145.7,76.66 147.55,73.2 147.55,64.12 v1(147.33,63.9)
  BOTTOM w0.076: v3(120.05,123.22) U4555.M9
  BOTTOM w0.099: v1(147.33,63.9) 147.56,63.67 147.56,62.8 147.41,62.65 CN4125.240
M_B_DQS7_DP: length 74.5
  L3 w0.076: 126.33,115.37 126.28,115.37 125.7,115.95 124.49,115.95 121.59,118.85 121.59,120.92 121,121.51 120.8,121.51 120.53,121.78 120.53,121.79 120.53,121.8 120.53,122.82 v1(120.92,123.22)
  L3 w0.081: v3(147.99,63.9) 147.77,64.12 147.77,73.26 145.92,76.72 145.92,81.45 129.13,98.23 129.13,112.57 126.33,115.37
  BOTTOM w0.076: U4555.L9 v1(120.92,123.22)
  BOTTOM w0.099: v3(147.99,63.9) 147.76,63.67 147.76,62.8 147.91,62.65 CN4125.242
M_B_PARITY: length 64.1
  L3 w0.076: 106.96,109.3 106.83,109.43 106.83,117.5 106.53,117.8 106.53,121.16 106.27,121.42 v1(106.27,121.89)
  L3 w0.109: 106.96,109.3 108.11,108.15 108.11,106.89 110.16,104.85 110.16,92.04 110.34,91.6 115.81,86.13 115.81,85 117.29,83.52 117.29,76.8 119.69,74.4 119.69,71.13 120.9,69.92 v3(120.9,67.18)
  BOTTOM w0.076: v1(106.27,121.89) U4555.AJ7
  BOTTOM w0.17: CN4125.143 121.16,67.44 v3(120.9,67.18)
M_B_RAS#: length 69.8
  L3 w0.076: v1(107.24,123.87) 107.6,123.51 107.6,123.38 107.61,123.38 107.61,122.34 107.78,122.16 107.78,121.69 107.61,121.51 107.61,118.27 108.04,117.84 108.04,111.54 108.21,111.37
  L3 w0.109: 108.21,111.37 110.25,109.33 110.46,109.01 112.23,106.06 112.23,92.64 117.94,86.93 117.94,85.81 120.31,83.44 120.31,78.74 121.07,77.98 121.07,75.95 122.87,74.15 123.64,72.3 123.64,70.62 124.17,67.95 124.32,67.17 124.34,67.15 124.35,67.1 v3(125.29,64.81)
  BOTTOM w0.076: v1(107.24,123.87) U4555.AH10
  BOTTOM w0.17: v3(125.29,64.81) 125.41,64.7 CN4125.152
M_B_WE#: length 68.4
  L3 w0.076: v1(107.24,124.52) 107.77,123.99 107.77,122.41 108.01,122.18 108.01,121.81 108.01,121.81 108.01,121.63 107.82,121.45 107.82,118.36 108.25,117.93 108.25,111.97 108.52,111.7
  L3 w0.109: v3(125.13,66.79) 124.96,66.96 124.71,67.33 124.61,67.86 124.05,70.66 124.05,72.38 123.22,74.38 121.48,76.12 121.48,78.15 121.34,78.29 121.34,82.04 120.67,83.66 118.35,85.98 118.35,87.1 112.64,92.81 112.64,106.38 110.85,109.37 108.52,111.7
  BOTTOM w0.076: v1(107.24,124.52) U4555.AH11
  BOTTOM w0.17: v3(125.13,66.79) 125.33,66.99 125.55,67.52 125.55,67.92 125.48,68.24 125.23,68.84 CN4125.151
M_CKE0: length 51.8
  L10 w0.109: v3(107.24,81.18) 107.31,81.18 107.53,81.4 107.53,81.63 102.13,87.03 102.13,88.88 98.1,92.91 98.1,95.23 97.99,95.34 97.49,95.34 97.38,95.45 97.38,95.64 97.49,95.76 97.95,95.76 98.1,95.9 98.1,96.14 97.99,96.24 97.42,96.24 97.31,96.35 97.31,96.55 97.42,96.66 97.99,96.66 98.1,96.77 98.1,96.96 97.99,97.07 97.42,97.07 97.31,97.18 97.31,97.38 97.42,97.49 97.99,97.49 98.1,97.6 98.1,97.79 97.99,97.9 97.42,97.9 97.31,98.01 97.31,98.21 97.42,98.31 97.99,98.31 98.1,98.42 98.1,98.62 97.99,98.73 97.42,98.73 97.31,98.84 97.31,99.03 97.42,99.14 97.99,99.14 98.1,99.25 98.1,99.45 97.99,99.56 97.42,99.56 97.31,99.67 97.31,99.86 97.42,99.97 97.99,99.97 98.1,100.08 98.1,100.3 97.97,100.43 97.56,100.43 97.32,100.67 97.32,108.77 97.95,110.29 99.51,114.06 99.51,116.25 v1(100.25,117)
  BOTTOM w0.076: U4555.AT1 100.25,117.65 v1(100.25,117)
  BOTTOM w0.17: v3(107.24,81.18) 107.24,81.48 107.59,81.84 107.59,83.04 CN4100.109
M_CKE1: length 49.9
  L10 w0.109: v3(107.71,76.47) 106.98,78.73 105.83,80.63 105.83,80.63 105.17,81.28 105.17,82.11 100.77,86.51 100.77,88.44 95.92,93.29 95.92,108.73 97.02,111.37 97.52,112.56 98.11,115.57 98.45,116.32 98.84,116.72 100.6,118.02 v1(100.62,118.04)
  BOTTOM w0.076: U4555.AT2 100.61,118.05 100.62,118.04 v1(100.62,118.04)
  BOTTOM w0.17: CN4100.110 v3(107.71,76.47)
M_CKE2: length 69.6
  L3 w0.076: 98.28,113.11 99.03,114.92 99.15,115.54 99.2,116.02 99.66,119.16 99.74,119.93 99.74,120.65 99.8,120.81 100.24,121.61 v1(100.83,122.56)
  L3 w0.109: v3(110.57,66.65) 110.57,66.75 110.38,66.93 110.23,66.93 110.09,66.8 109.93,66.8 109.79,66.93 109.79,67.09 109.93,67.23 109.93,67.38 109.79,67.52 109.64,67.52 109.5,67.38 109.35,67.38 109.21,67.52 109.21,67.67 109.35,67.81 109.35,67.97 109.21,68.11 109.05,68.11 108.92,67.97 108.76,67.97 108.62,68.11 108.62,68.26 108.76,68.4 108.76,68.55 105.41,71.91 105.29,72.06 104.77,72.78 104.62,72.98 104.3,73.55 102.86,76.14 102.85,76.15 102.75,76.32 102.75,76.33 101.56,79.38 100.94,81.39 100.94,81.4 100.75,82.17 100.45,83.15 100.4,83.36 100.17,84.32 99.86,85.63 99.69,86.33 99.69,86.4 99.69,86.42 99.59,87.06 99.54,87.41 97.77,97.98 96.94,109.2 96.94,110.41 97.32,111.28 97.98,112.6 98.28,113.11
  BOTTOM w0.076: U4555.AT8 100.82,122.56 v1(100.83,122.56)
  BOTTOM w0.17: CN4125.109 112.58,69.88 112.58,68.78 111.53,67.73 111.53,65.47 111.43,65.37 111.21,65.37 111.03,65.54 111.03,65.81 111.03,66.52 110.91,66.64 110.57,66.64 v3(110.57,66.65)
M_CKE3: length 68.1
  L3 w0.076: 97.32,112.46 97.79,113.59 98.49,116.72 99.51,119.93 99.51,120.85 99.73,121.29 100.28,122.48 100.35,122.71 100.43,123.13 100.54,123.58 v1(100.84,123.87) ; 97,111.69 97,111.68
  L3 w0.109: 97,111.68 96.53,110.67 96.53,109.18 97.37,97.79 99.12,87.34 99.27,86.3 99.3,86.18 99.3,86.13 99.33,86.02 99.33,86 100.33,81.79 101.05,79.48 101.82,77.52 102.18,76.48 102.3,76.26 102.32,76.21 102.34,76.19 102.58,75.79 104.27,72.76 105.29,71.22 105.58,70.85 v3(110.69,65.15) ; 97.32,112.46 97,111.69
  BOTTOM w0.076: v1(100.84,123.87) U4555.AT10
  BOTTOM w0.17: CN4125.110 112.86,61.98 112.83,62.19 112.83,62.49 112.78,62.61 112.48,63.07 112.16,63.5 110.93,64.85 v3(110.69,65.15)
M_CLK_DDR0_DN: length 57.2
  L10 w0.081: v1(103.79,111.59) 103.79,111.73 103.66,111.87 103.63,111.87 103.57,111.93 103.4,111.93 103.27,111.81 103.27,110.51 103.35,110.43 104.21,110.43 104.42,110.22 104.42,109.71 104.21,109.5 103.35,109.5 103.27,109.42 103.27,109.09 103.35,109.01 104.21,109.01 104.42,108.8 104.42,108.29 104.21,108.08 103.35,108.08 103.27,107.99 103.27,107.67 103.35,107.59 104.19,107.59 104.4,107.38 104.4,106.87 104.19,106.65 103.35,106.65 103.27,106.57 103.27,95.12 110.82,87.58 110.82,86.49 114.94,82.37 114.94,80.28 115.06,80.15 115.28,80.15 v1(115.49,80.37)
  BOTTOM w0.076: U4555.AG2 107.77,118.16 107.86,118.06 108.05,118.06 108.27,117.84 108.27,117.29 108.05,117.07 108.05,114.95 107.91,114.23 107.5,113.26 106.33,112.09 104.24,112.09 103.79,111.63 v1(103.79,111.59)
  BOTTOM w0.099: v1(115.49,80.37) 115.28,80.16 115.11,80.16 115.01,80.25 115.01,81.81 115.16,81.96 CN4100.139
M_CLK_DDR0_DP: length 57.3
  L10 w0.081: v3(115.49,79.71) 115.28,79.93 114.97,79.93 114.72,80.18 114.72,82.28 110.6,86.4 110.6,87.48 103.05,95.03 103.05,106.67 103.26,106.88 104.09,106.88 104.18,106.96 104.18,107.28 104.09,107.37 103.26,107.37 103.05,107.58 103.05,108.09 103.26,108.3 104.11,108.3 104.19,108.38 104.19,108.71 104.11,108.79 103.26,108.79 103.05,109 103.05,109.51 103.26,109.72 104.11,109.72 104.19,109.8 104.19,110.13 104.11,110.21 103.26,110.21 103.05,110.42 103.05,111.9 103.3,112.15 103.7,112.15 v1(103.79,112.25)
  BOTTOM w0.076: v1(103.79,112.25) 106.26,112.25 107.36,113.35 107.75,114.28 107.88,114.97 107.88,117.14 108.1,117.36 108.1,117.77 107.98,117.9 107.86,117.9 107.77,117.8 U4555.AG1
  BOTTOM w0.099: v3(115.49,79.71) 115.25,79.95 115.03,79.95 114.81,80.17 114.81,81.81 114.66,81.96 CN4100.137
M_CLK_DDR1_DN: length 54.5
  L10 w0.081: v3(115.49,77.64) 115.71,77.86 115.98,77.86 116.24,78.12 116.24,83.2 104.03,95.41 104.03,105.63 104.32,105.93 104.78,105.93 105.27,106.42 105.27,115.89 104.95,116.21 104.16,116.21 104.05,116.11 v1(103.72,116.11)
  BOTTOM w0.076: U4555.AK1 105.25,117.95 105.33,118.03 105.46,118.03 105.64,117.85 105.64,117.46 104.91,116.73 104.91,116.33 104.39,115.81 104.18,115.81 104.11,115.87 104.11,116.03 104.04,116.11 v1(103.72,116.11)
  BOTTOM w0.099: v3(115.49,77.64) 115.28,77.85 115.04,77.85 114.9,77.72 114.9,76.87 115.26,76.51 115.26,75.96 115.41,75.81 CN4100.140
M_CLK_DDR1_DP: length 54.5
  L10 w0.081: v1(103.72,115.46) 104.25,115.99 104.85,115.99 105.05,115.8 105.05,106.51 104.68,106.15 104.23,106.15 103.8,105.72 103.8,95.32 116.02,83.1 116.02,78.21 115.89,78.08 115.69,78.08 115.49,78.28 v1(115.49,78.32)
  BOTTOM w0.076: U4555.AK2 105.39,118.19 105.53,118.19 105.81,117.92 105.81,117.39 105.08,116.67 105.08,116.26 104.46,115.65 103.91,115.65 v1(103.72,115.46)
  BOTTOM w0.099: v1(115.49,78.32) 115.23,78.06 114.95,78.06 114.7,77.8 114.7,76.79 115.06,76.43 115.06,75.96 114.91,75.81 CN4100.138
M_CLK_DDR2_DN: length 65.2
  L3 w0.076: v1(103.62,123.21) 103.62,123.24 103.69,123.32 103.92,123.32 104.02,123.21 104.02,123.04 103.97,122.98 103.97,121.48 104.49,120.96 104.49,119 104.46,118.97 104.46,118.96
  L3 w0.081: 104.46,118.96 104.46,110.63 104.64,110.46 104.64,108.13 106.69,103.19 106.69,90.43 112.04,85.08 112.04,84.34 114.06,82.31 114.06,76.5 115.54,75.03 115.54,74.49 115.29,74.24 115.29,73.86 115.58,73.56 115.93,73.56 116.08,73.71 116.77,73.71 117.11,73.38 117.11,72.71 117,72.6 v3(116.65,72.6)
  BOTTOM w0.076: v1(103.62,123.21) 103.58,123.22 U4555.AN9
  BOTTOM w0.099: CN4125.139 120.16,71.16 120.03,71.28 120.03,72.09 119.77,72.35 119.09,72.35 118.97,72.47 118.97,72.87 118.54,73.3 117.9,73.3 117.61,73.01 117.61,72.63 117.44,72.46 116.79,72.46 v3(116.65,72.6)
M_CLK_DDR2_DP: length 65.2
  L3 w0.076: 104.69,118.96 104.69,118.97 104.65,119.01 104.65,121.03 104.13,121.54 104.13,122.88 104.48,123.22 v3(104.49,123.22)
  L3 w0.081: v1(116.65,71.94) 117.33,72.62 117.33,73.47 116.86,73.94 115.99,73.94 115.84,73.78 115.68,73.78 115.51,73.95 115.51,74.15 115.76,74.4 115.76,75.12 114.29,76.59 114.29,82.41 112.26,84.43 112.26,85.17 106.91,90.53 106.91,103.23 104.86,108.18 104.86,110.55 104.69,110.72 104.69,118.96
  BOTTOM w0.076: v3(104.49,123.22) U4555.AM9
  BOTTOM w0.099: CN4125.137 119.66,71.12 119.83,71.3 119.83,72 119.68,72.15 119,72.15 118.77,72.39 118.77,72.79 118.45,73.1 117.98,73.1 117.81,72.93 117.81,72.54 117.52,72.26 116.89,72.26 116.79,72.16 116.79,72.08 v1(116.65,71.94)
M_CLK_DDR3_DN: length 67.6
  L3 w0.076: 105.33,117.93 105.33,117.95 105.29,117.99 105.29,122.07 105.01,122.35 104.72,122.35 v1(104.51,122.55)
  L3 w0.081: v3(119.44,66.36) 119.3,66.22 119.11,66.22 119.02,66.26 118.95,66.33 118.79,66.56 118.65,66.9 118.65,68.95 118.56,69.45 118.2,70.3 118.06,71.02 118.06,73.61 117.93,73.93 117.91,73.98 115.37,76.51 115.19,76.8 115,77.73 115,82.59 114.21,84.5 113.08,86.18 111.82,87.72 108.88,90.66 107.72,93.48 107.72,103.15 105.61,108.22 105.59,108.27 105.59,111.17 105.33,112.51 105.33,117.93
  BOTTOM w0.076: v1(104.51,122.55) 104.48,122.56 U4555.AM8
  BOTTOM w0.099: v3(119.44,66.36) 119.63,66.18 120.05,66.18 120.27,65.96 120.27,62.87 120.41,62.73 CN4125.140
M_CLK_DDR3_DP: length 67.5
  L3 w0.076: 105.1,117.93 105.1,118.03 105.13,118.05 105.13,122 104.94,122.18 104.78,122.18 104.51,121.92 v3(104.51,121.89)
  L3 w0.081: 105.1,117.93 105.1,112.49 105.37,111.15 105.37,108.23 105.37,108.22 107.49,103.1 107.49,93.43 108.69,90.53 111.65,87.57 112.9,86.05 114.01,84.39 114.78,82.55 114.78,77.71 114.97,76.71 115.2,76.37 117.71,73.86 117.71,73.86 117.84,73.56 117.84,71 117.99,70.24 118.34,69.38 118.43,68.93 118.43,66.85 118.6,66.45 118.78,66.18 118.89,66.07 119.07,66 119.15,66 v1(119.44,65.7)
  BOTTOM w0.076: U4555.AM7 v3(104.51,121.89)
  BOTTOM w0.099: v1(119.44,65.7) 119.44,65.73 119.69,65.98 119.97,65.98 120.07,65.88 120.07,62.82 119.91,62.66 CN4125.138
M_CS#0: length 52.1
  L10 w0.076: v1(110.67,119.98) 108.48,117.6 108.31,117.35 108.25,117.12 108.25,112.32 108.3,111.81 108.44,111.1
  L10 w0.109: 108.44,111.1 108.64,110.29 109.13,108.69 109.13,96.4 121.38,84.14 121.38,80.53 121.18,79.49 121.05,79.19 v3(120.87,79.01)
  BOTTOM w0.076: U4555.AD5 v1(110.67,119.98)
  BOTTOM w0.17: CN4100.149 119.66,81.52 120.33,79.51 120.33,79.48 120.59,79.23 v3(120.87,79.01)
M_CS#1: length 53.8
  L10 w0.109: v1(108.66,112.16) 108.66,111.61 109.63,109.8 109.63,107.66 109.74,107.55 110.15,107.55 110.26,107.44 110.26,107.24 110.15,107.13 109.74,107.13 109.63,107.02 109.63,106.83 109.74,106.72 110.15,106.72 110.26,106.61 110.26,106.42 110.15,106.31 109.74,106.31 109.63,106.2 109.63,106 109.74,105.89 110.15,105.89 110.26,105.78 110.26,105.59 110.15,105.48 109.74,105.48 109.63,105.37 109.63,105.17 109.74,105.06 110.15,105.06 110.26,104.95 110.26,104.76 110.15,104.65 109.74,104.65 109.63,104.54 109.63,104.34 109.74,104.24 110.15,104.24 110.26,104.13 110.26,103.93 110.15,103.82 109.74,103.82 109.63,103.71 109.63,103.52 109.74,103.41 110.15,103.41 110.26,103.3 110.26,103.1 110.15,102.99 109.74,102.99 109.63,102.88 109.63,102.69 109.74,102.58 110.15,102.58 110.26,102.47 110.26,102.27 110.15,102.17 109.74,102.17 109.63,102.06 109.63,101.86 109.74,101.75 110.07,101.75 110.18,101.64 110.18,101.45 110.07,101.34 109.74,101.34 109.63,101.23 109.63,96.48 121.78,84.32 121.78,84.32 121.89,84.22 121.89,81.28 v3(122.2,80.97)
  BOTTOM w0.076: v1(108.66,112.16) 108.23,112.59 108.23,114.04 108.33,114.14 108.33,115.62 109.25,116.54 109.25,117.81 109.54,118.1 U4555.AE2
  BOTTOM w0.17: v3(122.2,80.97) 122.13,80.97 121.83,81.26 121.73,82.32 121.66,82.38 CN4100.157
M_CS#2: length 71.6
  L3 w0.076: 108.67,121.32 108.38,121.62 108.38,122.25 108.62,122.49 108.62,124.07 v1(109.07,124.52)
  L3 w0.109: v3(124.95,68.28) 125.21,68.28 125.32,68.39 125.32,70.13 125.2,70.24 124.91,70.24 124.7,70.45 124.7,70.88 124.9,71.08 125.73,71.08 125.88,71.24 125.88,71.53 125.77,71.65 125.13,71.65 125.01,71.76 125.01,72.12 125.16,72.27 125.75,72.27 125.88,72.4 125.88,72.77 125.75,72.91 125.15,72.91 125,73.06 125,73.52 124.65,73.87 124.46,73.87 122.7,75.63 122.7,77.52 121.76,78.46 121.76,81.32 121.87,81.43 122.26,81.43 122.37,81.55 122.37,81.73 122.25,81.85 121.87,81.85 121.76,81.96 121.76,82.16 121.87,82.27 122.23,82.27 122.34,82.37 122.34,82.57 122.23,82.68 121.88,82.68 121.76,82.79 121.76,83.15 118.77,86.15 118.77,87.27 113.06,92.98 113.06,107.81 109.22,111.65 109.22,117.62 108.67,118.17 108.67,121.32
  BOTTOM w0.076: v1(109.07,124.52) U4555.AF11
  BOTTOM w0.17: v3(124.95,68.28) 124.66,68.57 CN4125.149
M_CS#3: length 68.8
  L3 w0.109: v1(109.98,121.94) 109.93,121.89 109.93,118.94 110.39,118.47 110.39,114.01 110.94,113.47 110.94,112.49 114.71,108.72 114.71,93.67 123.07,85.31 123.07,84.3 124.83,82.53 124.83,82.12 124.94,82.01 125.11,82.01 125.22,81.9 125.22,81.7 125.11,81.6 124.94,81.6 124.83,81.49 124.83,75.84 125.15,75.53 125.57,75.53 128.08,73.01 128.08,71.27 127.59,70.78 127.59,70.43 127.19,70.02 127.19,66.91 127.3,66.8 v3(127.37,66.8)
  BOTTOM w0.076: v1(109.98,121.94) U4555.AE7
  BOTTOM w0.17: CN4125.157 126.73,69.88 126.73,68.81 127.06,68.47 127.06,67.46 126.72,67.12 126.72,66.73 126.89,66.56 127.13,66.56 v3(127.37,66.8)
M_ODT0: length 52.8
  L10 w0.109: v3(122.42,79.31) 122.86,79.31 123.05,79.51 123.05,85.03 110.9,97.18 110.9,99.23 111.01,99.34 111.41,99.34 111.52,99.45 111.52,99.64 111.41,99.75 111.01,99.75 110.9,99.86 110.9,100.06 111.01,100.16 111.41,100.16 111.52,100.27 111.52,100.47 111.41,100.58 111.01,100.58 110.9,100.69 110.9,101 111.16,101.26 111.16,108.64 111.29,108.77 111.29,109.48 109.74,111.02 109.39,111.88 109.39,112.93 109,113.86 v1(108.77,114.09)
  BOTTOM w0.076: U4555.AD3 110.18,118.88 109.99,118.43 109.99,117.48 110.03,117.28 110.03,116.67 109.88,116.17 109.21,114.76 v1(108.77,114.09)
  BOTTOM w0.17: v3(122.42,79.31) 121.81,80.06 121.36,81.15 121.26,82.09 CN4100.155
M_ODT1: length 52.7
  L10 w0.109: v1(108.65,116.54) 110.08,115.11 110.08,112.21 110.4,111.43 112.38,109.45 112.38,106.11 112.49,106 112.96,106 113.07,105.89 113.07,105.69 112.96,105.58 112.49,105.58 112.38,105.48 112.38,105.28 112.49,105.17 112.96,105.17 113.07,105.06 113.07,104.87 112.96,104.76 112.49,104.76 112.38,104.65 112.38,104.45 112.49,104.34 112.96,104.34 113.07,104.23 113.07,104.04 112.96,103.93 112.49,103.93 112.38,103.82 112.38,96.87 123.92,85.34 v3(123.92,80.18)
  BOTTOM w0.076: v1(108.65,116.54) 109.06,116.94 109.06,117.93 109.25,118.12 109.25,119.34 U4555.AE4
  BOTTOM w0.17: v3(123.92,80.18) 122.93,81.66 122.75,82.1 122.75,83.03 CN4100.161
M_ODT2: length 66.8
  L3 w0.109: v1(109.07,121.95) 109.27,121.74 109.27,118.56 109.77,118.06 109.77,113.49 110.08,113.18 110.08,112.13 113.88,108.33 113.88,93.33 119.6,87.61 119.6,86.93 119.6,86.49 123.38,82.7 123.38,82 123.49,81.89 123.64,81.89 123.75,81.78 123.75,81.45 123.64,81.35 123.49,81.35 123.38,81.24 123.38,78.95 123.52,78.82 123.85,78.82 123.99,78.67 123.99,78.39 123.88,78.28 123.64,78.28 123.53,78.17 123.53,77.82 123.64,77.71 123.88,77.71 123.99,77.6 123.99,75.51 124.81,74.7 125.2,74.7 126.76,73.13 126.76,70.77 126.14,70.15 126.14,67.76 v3(126.29,67.62)
  BOTTOM w0.076: v1(109.07,121.95) U4555.AF7
  BOTTOM w0.17: CN4125.155 126.08,69.87 126.08,68.78 126.58,68.28 126.58,67.88 126.32,67.62 v3(126.29,67.62)
M_ODT3: length 70.3
  L3 w0.109: v3(127.66,68.24) 128.01,67.88 128.01,66.62 128.13,66.5 128.45,66.5 128.58,66.63 128.58,68.38 128.34,68.63 127.93,68.63 127.78,68.77 127.78,68.98 127.94,69.14 128.49,69.14 128.58,69.24 128.58,69.45 128.45,69.59 128.13,69.59 128,69.72 128,69.98 128.24,70.56 128.58,70.91 128.58,73.1 125.81,75.87 125.81,77.31 125.81,77.31 125.81,82.85 123.84,84.82 123.84,85.13 115.13,93.84 115.13,108.92 111.43,112.62 111.43,113.61 110.72,114.32 110.72,118.71 110.25,119.18 110.25,121.47 110.4,121.61 110.4,122.15 v1(109.98,122.57)
  BOTTOM w0.076: v1(109.98,122.57) U4555.AE8
  BOTTOM w0.17: v3(127.66,68.24) CN4125.161
MB_SHUTDOWN#: length 9.4
  BOTTOM w0.102: U1.69 201.89,40.02 201.7,39.83 198.93,39.83 198.68,40.08 v2(198.68,40.11) 198.65,40.11 198.65,40.11 198.09,40.11 197.74,39.75 196.85,39.75 196.41,39.32 R323.1
ME_FLASH_EN: length 78
  L5 w0.076: v1(265.35,59.36) 264.97,59.36 262.72,57.12 262.72,45.1 262.24,44.62 262.24,43.67 260.64,42.08 260.13,42.08 259.57,41.52 258.17,41.52 257.66,42.03 246.78,42.03 244.94,40.2 238.72,40.2 237.98,39.46 217.59,39.46 217.15,39.89 207.34,39.89 v1(206.79,39.35)
  BOTTOM w0.109: R4861.1 264.29,59.3 265.29,59.3 v1(265.35,59.36) ; U1.81 206.69,39.45 v1(206.79,39.35)
MIC2_REF: length 27
  TOP w0.254: U500.29 18.81,52.68 18.47,52.34 v1(18.47,52.16)
  BOTTOM w0.254: v1(18.47,52.16) 17.75,51.44 17.75,49.71 18.92,48.54 19.66,48.54 20.98,47.22 20.98,43.89 26.41,38.46 32.13,38.46 32.52,38.85 CN603.7
MODEM_CLKREQ_R: length 37
  TOP w0.102: v1(268.4,59.04) 269.44,58 269.44,55.15 270.41,54.18 271.68,54.18 272.51,53.34 272.51,38.52 274.37,36.66 274.37,29.55 274.14,29.32 274.14,29.04 v1(274.34,28.83) R1334.2
  BOTTOM w0.102: v1(268.4,59.04) 268.37,59.01 R4772.2 ; CN1300.14 275.2,28.71 275.08,28.83 v1(274.34,28.83)
NV3V3_DPP_DIS: length 9.3
  BOTTOM w0.254: R56250.1 295.96,38.58 v2(295.5,39.04) 293.93,39.04 293.16,38.28 293.16,35.06 293.85,34.37 U56250.4
NVHS_DVDD: length 3.7
  TOP w0.254: v4(162.38,119.38) 162.53,119.54 R51900.2
  BOTTOM w0.2: U50000.AT9 162.45,118.13 v4(162.33,118.13) ; v4(162.38,119.38) 162.4,119.38 U50000.AT10
  BOTTOM w0.25: U50000.AT10 v4(162.39,118.76) U50000.AT9 ; U50000.AV10 v4(161.67,119.44) U50000.AV11
  vias: v2(162.94,118.39)
NVHS_HVDD: length 3.8
  TOP w0.254: v4(164.95,120.55) 164.57,120.93 R51902.2
  BOTTOM w0.15: U50000.AN11 164.95,119.93 v4(164.95,120.55)
  BOTTOM w0.2: U50000.AN10 v4(164.56,119.43) 164.21,119.78 U50000.AR11 ; v4(165.11,119.42) U50000.AM10
  vias: v2(165.78,119.54) v4(165.4,120.24) v4(166.06,120.19)
NVHS_PLL_HVDD: length 1.4
  TOP w0.254: v6(164.35,118.11) 164.37,118.13 R51903.2
  BOTTOM w0.3: v6(164.35,118.11) U50000.AN9
NVVDD_CURRENT_MONITOR_N: length 28.3
  L10 w0.254: v1(145.08,44.61) 144.98,44.51 144.98,44.09 146.09,42.98 166.44,42.98 168.63,45.16 v1(168.63,45.72)
  BOTTOM w0.254: v1(145.08,44.61) 145.06,44.63 145.06,45.27 R52021.1 ; v1(168.63,45.72) 168.63,45.75 169.03,46.16 R67199.4
NVVDD_CURRENT_MONITOR_P: length 31.7
  L10 w0.254: v1(169.29,45.72) 169.29,45.67 168.98,45.37 168.98,45.02 166.59,42.62 145.95,42.62 144.58,43.99 144.58,44.43 v1(144.4,44.61)
  BOTTOM w0.254: v1(144.4,44.61) 144.52,44.73 144.52,45.17 R52022.1 143.68,44.79 v2(143.68,44.45) 143.61,44.38 R52024.1 ; R67199.3 169.03,45.22 169.29,45.47 v1(169.29,45.72)
NVVDD_GND_SENSE: length 8.3
  BOTTOM w0.102: U50000.BL45 151.93,143.58 151.54,143.97 150.24,143.97
  BOTTOM w0.203: 150.24,143.97 146.99,143.97 146.61,144.35 TP52121.1 146.05,144.53 145.55,144.53 145.32,144.76 144.59,144.76 R52111.1
NVVDD_PG: length 31.6
  L3 w0.102: v1(117.42,54.66) 119.07,53.01 v1(119.07,51.51)
  L5 w0.102: v1(126.58,50.09) 125.63,50.09 124.61,51.11 119.48,51.11 v1(119.07,51.51)
  BOTTOM w0.102: v1(119.07,51.51) 119.07,49.58 118.66,49.17 U53540.2 ; U53585.2 110.6,56.92 112.43,55.1 114.2,55.1 114.55,54.74 117.34,54.74 v1(117.42,54.66) ; R53531.2 133.52,48.49 v2(133.12,48.9) 132.29,49.73 126.94,49.73 v1(126.58,50.09)
NVVDD_PSI: length 82
  TOP w0.102: R67008.1 v1(135.68,47.68)
  L8 w0.102: v3(149.55,97.59) 149.25,97.29 148.15,97.29 147.65,96.78 147.65,82.57 149.44,80.78 149.44,73.18 149.25,72.98 149.25,60.92 149.07,60.74 147.24,58.92 147.24,56.79 141.87,51.41 139.42,51.41 v1(135.68,47.68)
  BOTTOM w0.102: v3(149.55,97.59) 149.78,97.59 153.34,101.15 153.34,103.68 156.29,106.63 160.17,106.63 162.4,104.4 163.19,104.4 R51584.2 R51583.1 164.5,104.94 R51585.2
NVVDD_PWMID: length 65.5
  TOP w0.102: v3(151.62,93.78) 151.52,93.88 R51579.2 ; v1(136.6,47.69) R67010.1
  L5 w0.102: v1(136.6,47.69) 137.01,47.27 144.52,47.27 144.6,47.35 148.99,47.35 v1(149.42,46.92)
  L8 w0.102: v1(149.42,46.92) 149.42,48.47 152.68,51.72 152.68,59.2 152.68,59.2 152.68,59.46 155.27,62.05 155.27,74.32 154.17,75.42 154.17,88.38 151.81,90.74 151.81,93.58 v3(151.62,93.78)
NVVDD_TALERT#: length 1.9
  TOP w0.102: U67000.1 v2(137.39,52.66) 138.15,52.66 R67014.2
NVVDD_VCC_SENSE: length 9.4
  BOTTOM w0.102: U50000.BK45 152.61,143.87 152.34,143.87 152.33,143.88 151.95,143.88 151.63,144.2 150.42,144.2 150.24,144.38
  BOTTOM w0.203: R52110.1 144.72,145.19 145.26,145.19 TP52120.1 145.72,144.94 146.61,144.94 147.16,144.38 150.24,144.38
OVERT_RST#: length 1.3
  BOTTOM w0.102: Q51510.G 147.01,125.9 R51512.2
OVRM_EN: length 25
  BOTTOM w0.102: U52000.28 147.66,50.78 147.98,51.1 152.94,51.1 154.2,49.84 154.2,44.61 153.34,43.74 153.34,41.23 153.69,40.87 R52002.1 154.51,40.85 153.73,40.07 Q52070.D 153.73,39.23 152.7,38.21 151.03,38.21 v2(150.47,38.76) 150.47,39.58 R52072.1
OVRM_EN_EC: length 50
  L3 w0.102: v1(156.18,40.87) 156.56,40.49 157.73,40.49 158.21,40.97 166.24,40.97 167.2,40.01 v1(192.22,40.01)
  BOTTOM w0.102: v1(192.22,40.01) 192.22,39.17 192.66,38.74 194.13,38.74 194.41,39.02 196.59,39.02 196.95,39.37 197.82,39.37 198.03,39.58 202.01,39.58 202.29,39.86 U1.70 ; v1(156.18,40.87) R52002.2
PCH2CPU_TRIGGER: length 186.6
  TOP w0.102: 251.47,69.96 v2(251.08,69.96) ; v1(137.16,119.84) 137.16,119.08 136.95,118.88
  TOP w0.109: v2(251.08,69.96) 250.87,69.96 250.63,69.71 235.6,69.71 231.19,65.3 221.62,65.3 214.58,72.34 164.37,72.34 162.63,70.59 156.16,70.59 151.54,75.2 151.54,78.86 148.52,81.88 147.38,81.88 136.56,92.7 136.56,118.48 136.95,118.88 ; R4792.2 251.47,69.96
  L3 w0.076: 123.04,133.82 125.9,133.82 126.54,133.18 126.54,123.63 127.48,122.69 132.43,122.69 133.12,122 133.12,121.36 133.55,120.93 134.83,120.93
  L3 w0.102: 134.83,120.93 135.58,120.93 136.24,120.27 136.72,120.27 v1(137.16,119.84) ; 123.04,133.82 122.65,134.21 v1(122.59,134.21)
  BOTTOM w0.076: U4555.H23 v1(122.59,134.21)
PCH_3A_SMCLK: length 9
  BOTTOM w0.102: v2(262.48,52.86) 261.9,52.86 261.49,52.45 259.65,52.45 259.59,52.4 259.01,52.4 U4710.BE26
  BOTTOM w0.109: v2(262.48,52.86) 262.76,52.58 R4828.2 264.14,53.39 265.58,53.39 266.12,53.94 Q4702.6
PCH_3A_SMDATA: length 7.1
  BOTTOM w0.102: U4710.BF26 259.62,52.65 259.63,52.65 261.2,52.65 261.97,53.42 262.1,53.42 262.51,53.83
  BOTTOM w0.109: 262.51,53.83 v2(262.79,54.11) 263.11,53.78 R4913.2 263.65,53.81 263.65,53.83 264.08,54.26 264.08,54.44 264.88,55.24 Q4702.3
PCH_3S_SMCLK: length 153
  TOP w0.109: v1(152.52,67.34) 152.88,67.34 153.13,67.08 154.15,67.08 v2(154.45,67.39) 156.47,69.4 163.12,69.4 164.87,71.15 214.05,71.15 215.41,69.78 215.41,67.49 219.35,63.55 227.55,63.55 231.13,63.55 236.04,68.46 250.06,68.46 252.54,65.98 v1(252.87,65.98) ; R4705.2 264.66,54.04 v1(264.49,54.21)
  L3 w0.076: v1(252.87,65.98) 252.7,65.81 252.7,65.05 252.82,64.94 252.82,61.33 253.24,60.91 253.24,57.73 253.93,57.04 253.93,56.89 254.16,56.66 254.49,56.66 254.52,56.69 258.3,56.69 259.69,55.29 260.7,55.29 260.89,55.48 261.83,55.48 263.1,54.21 v1(264.49,54.21)
  BOTTOM w0.109: Q4702.1 264.76,53.94 v1(264.49,54.21) ; v1(152.52,67.34) 152.45,67.26 150.9,67.26 150.66,67.5 CN4125.253 150.66,71.01 150.39,71.28 149.22,71.28 148.46,72.04 148.46,76.2 145.66,79 CN4100.253
PCH_3S_SMDATA: length 150.3
  TOP w0.109: v1(153.54,67.69) v2(154.73,68.89) 155.74,69.89 162.92,69.89 164.66,71.64 214.29,71.64 220.86,65.07 221.89,64.04 227.75,64.04 227.75,64.04 230.15,64.04 230.93,64.04 235.85,68.96 249.93,68.96 252.29,66.6 252.88,66.6 v1(252.9,66.58)
  L3 w0.076: v1(252.9,66.58) 253.93,65.55 253.93,60.48 256.37,58.04 257.6,58.04 259.48,56.16 261.89,56.16 263.11,54.94 263.93,54.94 266.07,54.94 v1(266.37,55.24)
  L5 w0.076: v1(153.54,67.69) 153.51,67.67 152.93,67.67 152.1,68.49 152.1,69.15 149.88,71.38 v1(148.17,71.38)
  BOTTOM w0.109: R4775.2 267.04,55.92 Q4702.4 v1(266.37,55.24) ; CN4100.254 145.91,72.79 146.42,72.28 147.22,72.28 148.13,71.38 v1(148.17,71.38) ; CN4125.254 150.91,66.18 151.15,66.42 152.4,66.42 153.51,67.54 153.51,67.67 v1(153.54,67.69)
PCH_BATLOW#: length 5.1
  BOTTOM w0.102: U4710.BF44 259.78,43.79 260.04,43.53 260.3,43.53 260.34,43.56 260.8,43.56 261.52,42.85 261.52,42.78 262.07,42.22 v2(263.19,42.22) 264.02,42.22 R4804.2
PCH_CIO_PLUG_EVENT: length 5.9
  BOTTOM w0.089: 262.51,50.19 262.36,50.05 258.92,50.05 258.26,49.39 U4710.BC33
  BOTTOM w0.102: 262.51,50.19 v2(262.61,50.3) 263.09,50.3 263.23,50.29 263.36,50.42 R4711.1
PCH_CNVI_PWR_EN#: length 4.7
  BOTTOM w0.089: 262.51,51.57 v2(262.48,51.57) 262.33,51.57 261.64,50.88 259.9,50.88 259.72,51.06 259.4,51.06 U4710.BE29
  BOTTOM w0.102: R4733.1 262.63,51.69 262.51,51.57
PCH_DGPU_PWR_EN#: length 10.6
  TOP w0.089: v1(258.03,51.14) 258.41,51.14 258.51,51.24 R4815.2
  TOP w0.102: R4859.2 v2(263.29,54.51) 263.29,54 263.54,53.76 Q4.1 263.54,52.93 262.81,52.2 v1(262.02,52.2)
  L5 w0.102: v1(258.03,51.14) 258.75,51.14 260.04,52.43 261.79,52.43 v1(262.02,52.2)
  BOTTOM w0.089: U4710.BD30 258.25,50.91 v1(258.03,51.14)
PCH_HOLD_RST#: length 14.6
  TOP w0.102: v3(265.73,50.37) 265.46,50.1 R4823.2 ; R4803.2 255.35,52.56 v1(255.35,52.1)
  L3 w0.102: v3(265.73,50.37) 265.53,50.57 262.28,50.57 261.57,49.86 259.99,49.86 258.11,51.74 258.11,52.23 257.86,52.48 255.73,52.48 v1(255.35,52.1)
  BOTTOM w0.089: U4710.AU26 255.45,52.3 255.37,52.23 255.37,52.13 255.35,52.11 v1(255.35,52.1)
PCH_I2C1_CLK: length 188.2
  TOP w0.109: R4810.2 v1(260.14,55.69)
  L10 w0.076: v1(260.14,55.69) 261.02,55.69 262.29,54.42 262.42,54.42 263.27,53.57 263.27,50.78 262.66,50.17 262.66,49.7 264.47,47.88 265.51,47.88 268.68,44.71 268.68,41.58 269.5,40.76 269.5,34.44 264.3,29.24 261.07,29.24 260.18,28.35 255.98,28.35 255.33,27.71 248.35,27.71 247.71,27.07 243.35,27.07 242.24,25.95 238.04,25.95 237.12,25.02 232.64,25.02 230.97,23.36 225.16,23.36 223.15,25.37 211.29,25.37 210.18,26.47 203.4,26.47 203.04,26.83 196.62,26.83 196.08,27.36 186.34,27.36 185.62,26.65 174.75,26.65 171.66,29.73 168.31,29.73 166.72,31.32 143.83,31.32 142.86,32.29 135.15,32.29 133.14,34.3 122.81,34.3 v3(122.53,34.01)
  BOTTOM w0.102: v1(260.14,55.69) 259.77,55.69 U4710.BE21
  BOTTOM w0.109: R290.1 122.58,32.36 Q281.3 122.06,33.55 v3(122.53,34.01)
PCH_I2C1_DATA: length 191.9
  TOP w0.109: R4812.2 v1(261.07,55.09)
  L10 w0.076: v1(261.07,55.09) 261.07,54.07 262.43,52.71 262.43,50.63 262.18,50.37 262.18,49.53 264.28,47.43 265.32,47.43 268.22,44.52 268.22,41.39 269.04,40.57 269.04,34.63 264.11,29.7 260.88,29.7 260.07,28.88 254.08,28.88 253.38,28.18 248.12,28.18 247.46,27.52 243.16,27.52 242.05,26.41 237.85,26.41 236.93,25.48 232.45,25.48 232.22,25.25 232.2,25.25 230.77,23.81 225.35,23.81 222.54,26.62 210.68,26.62 210.37,26.93 203.59,26.93 202.45,28.07 198.62,28.07 197.9,27.35 196.74,27.35 196.27,27.82 186.13,27.82 185.42,27.11 175.05,27.11 171.97,30.19 168.56,30.19 166.98,31.78 144.02,31.78 143.05,32.74 137.08,32.74 136.09,33.73 135.18,33.73 134.15,34.76 119.56,34.76 v3(118.84,34.04)
  BOTTOM w0.109: U4710.BF21 259.82,55.2 260.96,55.2 v1(261.07,55.09) ; Q281.6 120.21,31.53 120.21,33.39 R289.2 119.04,33.84 v3(118.84,34.04)
PCH_I2C_CLK: length 260.8
  TOP w0.109: R4825.2 258.7,55.53 v2(258.44,55.27) 258.06,55.27 v1(257.79,55.01)
  L8 w0.076: v1(33.96,64.3) 34.58,63.68 49.67,63.68 50.56,62.79 52.12,62.79 63.47,51.44 99.75,51.44 106.88,44.31 110.88,44.31 114.64,40.55 121.47,40.55 128.01,34.02 132.82,34.02 133.65,33.19 134.39,33.19 134.95,32.63 150.91,32.63 152.19,33.91 174.62,33.91 185.44,44.73 211.36,44.73 211.67,45.04 212,45.04 212.21,44.83 219.35,44.83 220.17,45.65 232.58,45.65 233.11,46.17 233.48,46.17 233.48,46.17 236.89,46.17 237.82,47.1 237.82,50.74 238.34,51.26 238.34,52.74 239.52,53.91 239.62,53.91 243.1,57.39 245.26,57.39 247.06,59.19 247.56,59.19 247.56,59.2 248.14,59.2 248.42,59.48 248.42,59.81 248.65,60.04 248.98,60.04 249.21,59.81 249.21,59.16 249.33,59.04 249.33,59.02 250.3,58.06 252.9,58.06 253.5,57.46 254.4,57.46 255,58.06 257.18,58.06 258.48,56.76 258.48,55.69 v1(257.79,55.01)
  BOTTOM w0.109: CN5.25 33.44,66.04 33.44,64.82 v1(33.96,64.3) ; v1(257.8,55.01) 257.99,55.01 U4710.BC22
PCH_I2C_DATA: length 261
  TOP w0.109: R4827.2 259.58,55.18 v2(259.71,55.05) 258.95,54.28 v1(258.21,54.28)
  L8 w0.076: v1(33.27,64.32) 33.98,63.61 33.98,63.26 34.73,62.51 36.17,62.51 36.88,63.22 49.48,63.22 50.37,62.33 50.75,62.33 51.93,62.33 63.9,50.36 100.19,50.36 106.69,43.86 110.69,43.86 114.45,40.1 121.28,40.1 127.82,33.56 132.63,33.56 133.46,32.73 134.2,32.73 134.76,32.17 151.1,32.17 151.72,32.8 164.11,32.8 164.76,33.45 174.81,33.45 182.89,41.53 199.52,41.53 202.23,44.25 207.96,44.25 207.96,44.25 208.48,44.25 212.16,44.25 212.25,44.34 220.1,44.34 220.95,45.19 232.77,45.19 233.29,45.71 237.08,45.71 238.27,46.91 238.27,50.55 238.79,51.07 238.79,52.04 242.11,55.35 242.11,55.51 243.54,56.94 245.6,56.94 246.64,57.97 248.35,57.97 248.6,57.73 249.22,57.73 249.35,57.6 251.95,57.6 252.92,56.63 256.52,56.63 257.4,55.75 257.4,54.84 257.96,54.28 v1(258.21,54.28)
  BOTTOM w0.089: U4710.BF23 259.3,54.13 258.37,54.13 v1(258.21,54.28)
  BOTTOM w0.109: CN5.26 32.95,64.46 33.09,64.32 v1(33.27,64.32)
PCH_JTAGX: length 8.9
  BOTTOM w0.089: U4710.AH4 250.64,63.5 250.48,63.66 250.48,64.65 250.19,64.94 250.19,65.46 249.96,65.69 249.96,66.86 250.16,67.06 250.16,67.36 250.36,67.56 250.36,67.92
  BOTTOM w0.109: R4890.1 251.64,70.52 251.49,70.37 R4532.1 251.18,69.86 250.11,68.79 250.11,68.16 250.36,67.92
PCH_PECI: length 374.4
  TOP w0.109: R4514.1 85.79,141.76 85.64,141.61 v1(85.64,141.15)
  L5 w0.076: v1(220.9,43.51) 220.9,44.33 222.12,45.55 236.27,45.55 238.02,47.3 238.02,50.91 240.89,53.78 240.89,54.41 246.36,59.88 246.49,59.88 247.58,60.97 247.58,62.23 248.18,62.82 248.18,63.22 249.53,64.57 249.53,65.71 250.55,66.74 250.55,71.85 v1(250.54,71.86)
  L8 w0.076: v1(250.54,71.86) 250.06,72.34 249.48,72.34 249.32,72.19 249.32,70.82 247.55,69.05 236.89,69.05 231.88,64.05 231.61,64.05 223.34,64.05 220.28,60.99 220.28,58.56 218.37,56.66 218.37,50.69 218.11,50.42 218.11,50.42 216.73,49.05 187.19,49.05 181.77,49.05 176.6,43.88 170.8,43.88 168.69,41.77 160.13,41.77 157.67,39.31 156.73,39.31 153.22,39.31 152.82,39.72 135.45,39.72 134.79,39.06 134.02,39.06 129.15,39.06 128.88,39.32 123.58,44.62 117.52,44.62 109.99,52.15 104.76,52.15 100.19,56.72 89.66,56.72 88.13,58.25 78.22,58.25 73.02,63.44 73.02,63.82 73.02,65.28 68.68,69.62 67.71,69.62 66.23,71.11 66.23,80.12 67.77,81.66 67.79,81.66 68.07,81.95 68.07,82.4 69.5,83.84 69.5,87.66 70.2,88.36 71.71,89.87 71.71,93.92 75.7,97.91 78.2,97.91 80.13,99.84 80.13,109.66 78.5,111.29 75.48,111.29 74.3,112.47 74.3,115.44 79.22,120.36 79.22,125.39 79.22,125.77 81.24,127.79 81.24,135.92 83.18,137.86 85.48,137.86 86.03,138.41 86.03,140.77 v1(85.64,141.15)
  BOTTOM w0.109: v1(220.9,43.51) 220.9,42.68 223.03,40.55 223.03,32.74 221.21,30.92 R300.2 ; R79.2 250.29,71.61 v1(250.54,71.86)
PCH_PLTRST#_BUF: length 141.6
  TOP w0.102: R4776.2 272.59,55.41 v1(272.31,55.13)
  L5 w0.102: v1(148.94,41.89) 149.69,42.64 166.25,42.64 166.98,41.91 167.6,41.91 167.83,42.14 171.58,42.14 172.93,40.8 174.36,40.8 174.78,41.21 187.66,41.21 187.98,41.53 189.44,41.53 190.33,40.64 197.32,40.64 199.45,38.51 202.82,38.51 202.98,38.36 207.26,38.36 208.2,37.42 222.25,37.42 223.35,36.32 231.06,36.32 232.49,37.75 236.88,37.75 238.94,39.81 257.24,39.81 258.16,40.73 258.16,40.96 258.4,41.2 259.56,41.2 260.22,41.86 260.97,41.86 263.14,44.03 263.14,49.11 268.24,54.21 271.38,54.21 v1(272.31,55.13)
  BOTTOM w0.102: R50022.2 148.35,42.92 148.36,42.93 TP50022.1 ; R50022.2 148.35,41.33 U50020.1 ; R50022.2 v1(148.94,41.89)
PCH_PRDY#: length 10.6
  BOTTOM w0.089: U4710.AM5 252.66,63.3 252.5,63.45 252.5,64.55 252.19,64.85 252.19,65.76 252.27,65.84 252.27,67.16 253.13,68.02
  BOTTOM w0.102: 253.13,68.02 254,68.89 255.07,68.89 v2(256.36,70.18) 256.59,70.41 R4799.1
PCH_PREQ#: length 8.6
  BOTTOM w0.089: U4710.AL2 252.25,64.54 251.98,64.81 251.98,67.2 252.81,68.02
  BOTTOM w0.102: 252.81,68.02 254.16,69.37 v2(254.76,69.37) 255.1,69.72 255.1,69.72 255.7,70.31 R4798.1
PCH_PWROK: length 19.6
  TOP w0.102: C140.1 270,47.7 v1(269.84,47.55) ; v2(270.68,46.64) R7009.2 269.91,47.47 v1(269.84,47.55) ; R7010.2 269.83,47.55 v1(269.84,47.55)
  L8 w0.102: v1(269.84,47.55) 269.84,46.94 267.94,45.04 259.36,45.04 258.52,44.2 257.09,44.2 256.63,44.66 v1(256.15,44.66)
  BOTTOM w0.089: U4710.AY42 256.16,44.65 v1(256.15,44.66)
PCH_R_PECI: length 6.6
  BOTTOM w0.089: 249.45,67.87 249.45,65.69 249.7,65.44 249.7,64.84 249.83,64.71 249.83,64.59 U4710.AF2
  BOTTOM w0.109: R79.1 250.29,69.68 249.5,68.89 v2(249.5,68.28) 249.5,67.92 249.45,67.87
PCH_SPI_CLK: length 57.9
  TOP w0.109: U300.6 XU300.6 225.93,23.19 226.64,23.9 v1(226.64,24.64)
  L3 w0.076: v1(226.64,24.64) 227.55,25.55 227.55,26.24 228.98,27.66 230.35,27.66 233.19,30.51 235.52,30.51 236.41,31.4 241.36,31.4 241.55,31.59 244.28,34.32 249.51,34.32 249.88,34.68 254.21,34.68 254.65,34.24 v1(255.39,34.24)
  L8 w0.076: v1(226.64,24.64) 225.77,24.64 224.37,26.04 224.1,26.31 224.1,30.35 220.32,34.13 220.32,36.27 v1(219.91,36.68)
  BOTTOM w0.109: R136.1 255.03,36.25 255.39,35.9 v1(255.39,34.24) ; R3503.1 227.25,23.4 226.64,24.01 v1(226.64,24.64) ; R311.2 219.93,37.23 219.91,37.21 v1(219.91,36.68)
PCH_SPI_CS0#: length 67.7
  TOP w0.109: v1(228.32,25.76) 228.32,24.64 229.28,23.68 230.18,23.68 230.35,23.5 230.35,21.29 230.98,20.65 XU300.1 U300.1 233.31,20.65 234.49,21.84 235.53,21.84 R7.2
  L3 w0.076: v1(256.23,32.36) 255.84,31.97 255.4,31.97 253.35,34.02 251.2,34.02 251.03,34.02 248.56,31.55 244.46,31.55 243.05,30.14 239.07,30.14 236.03,27.11 230.23,27.11 228.88,25.76 v1(228.32,25.76)
  L8 w0.076: v1(221.92,36.66) 221.92,34.04 227.55,28.41 227.55,26.22 228.01,25.76 v1(228.32,25.76)
  BOTTOM w0.109: R13.2 219.91,39.78 221.05,38.64 v2(221.48,38.64) 221.92,38.21 v1(221.92,36.66) ; R135.1 255.88,36.33 255.88,34.55 256.46,33.97 256.46,32.59 v1(256.23,32.36)
PCH_SPI_CS2#: length 31.8
  L10 w0.076: v1(231.9,30.51) 232.05,30.66 237.44,30.66 238.82,32.05 241.17,32.05 243.59,34.47 243.94,34.47 244.85,35.39 244.85,36.72 247.9,39.77 248.24,39.77 254.05,45.58 254.09,45.58 v1(254.15,45.65)
  BOTTOM w0.109: v1(254.15,45.65) 254.51,46 U4710.AT40 ; R3504.1 231.04,29.21 231.9,30.08 v1(231.9,30.51)
PCH_SPI_SI: length 41.3
  TOP w0.109: U300.5 224.8,25.27 223.39,26.68 R12.2 ; v1(228.29,26.42) 228.15,26.42 226.99,25.26 226.55,25.26 225.75,24.46 XU300.5 ; R133.1 v1(255.6,32.36)
  L3 w0.076: v1(233.07,29.57) 233.07,29.58 233.54,30.05 235.71,30.05 235.98,30.32 236.6,30.94 241.55,30.94 242.37,31.75 247.6,31.75 250.07,34.22 250.94,34.22 250.94,34.23 251.28,34.23 253.74,34.22 v1(255.6,32.36)
  L8 w0.076: v1(233.07,29.57) 232.31,28.81 230.68,28.81 v1(228.29,26.42)
  BOTTOM w0.109: R3506.1 232.81,29.32 v1(233.07,29.57) 233.07,29.82 233.47,30.22 R56.1
PCH_SPI_SO: length 58.4
  TOP w0.109: v1(255.47,30.79) 255.85,31.17 257.01,31.17 R134.1 ; v1(236.17,26.17) 236.12,26.11 236.12,24.16 v2(235.56,23.6) 235.06,23.11 234.51,23.11 233.33,21.92 U300.2 XU300.2 231.37,21.92 230.76,22.53 230.76,23.43 230.27,23.91 229.83,23.91 v1(228.85,24.9)
  L3 w0.076: v1(236.17,26.17) 239.73,29.73 243.38,29.73 243.83,30.18 244,30.18 248.72,30.18 249.13,29.77 254.45,29.77 v1(255.47,30.79)
  L8 w0.076: v1(220.57,36.68) 220.57,36.67 220.77,36.46 220.77,34.32 224.56,30.53 224.56,30.16 224.56,26.5 225.91,25.15 228.34,25.15 228.6,24.9 v1(228.85,24.9)
  BOTTOM w0.109: v1(220.57,36.68) 220.57,38.41 220.21,38.76 R11.2 ; R3505.1 237.89,24.65 237.13,25.4 236.5,25.4 236.17,25.74 v1(236.17,26.17)
