# Allegro board PH317-53 COVINI-6050A3087701-MB-AX2 (BDV)(.BRD).brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
PVCORE_PG: length 342.6
  TOP w0.102: U66000.45 82.78,161.06 82.93,160.91 82.93,158.95 R66602.1 83.44,158.39 83.03,157.98 83.03,156.75 v1(83.46,156.32) ; v3(268.17,46.61) 269.04,46.61 R7009.1
  L3 w0.102: v3(268.17,46.61) 267.81,46.26 264.61,46.26 264.03,45.67 259.04,45.67 258.43,46.28 256.75,46.28 256.52,46.05 251.91,46.05 250.08,44.22 248.61,44.22 246.58,42.19 244.45,42.19 244.17,41.91 242.85,41.91 241.74,40.81 237.96,40.81 236.47,39.32 222.5,39.32 221.46,38.28 214.02,38.28 213.89,38.41 208.99,38.41 208.89,38.31 206.88,38.31 206.65,38.54 188.69,38.54 186.48,36.33 176.25,36.33 174.19,34.27 170.68,34.27 169.97,34.98 167.47,34.98 167.16,34.67 160.75,34.67 159.22,36.2 147.53,36.2 147,35.67 134.58,35.67 133.34,36.91 101.98,36.91 100.58,38.31 87.14,38.31 85.65,39.81 70.84,39.81 69.65,41 69.65,46.87 71.7,48.92 v1(71.7,50.91)
  L5 w0.102: v1(71.7,50.91) 68.68,53.93 68.68,57.92 67.18,59.42 67.18,72.77 67.46,73.05 67.46,79.03 68.46,80.04 69.36,80.04 71.37,82.05 71.37,88.37 72.16,89.16 72.16,94.12 70.91,95.36 70.91,110.54 71.45,111.08 71.45,112.5 77.59,118.65 77.59,119.47 77.59,119.47 77.59,127.03 79.76,129.19 79.76,138 83.33,141.58 83.33,154.51 83.97,155.15 83.97,155.81 v1(83.46,156.32)
PVPACK: length 13
  TOP w0.254: v1(38.07,39.39) 38.89,38.56 38.89,34 38.1,33.2 v1(38.1,31.45)
  TOP w0.381: C7699.1 17.56,33 ; C68.1 17.56,33.89 ; C7689.1 17.56,32.11
  BOTTOM w0.254: D60002.2 D60002.1 v1(38.07,39.39)
  vias: v2(18.46,32.46) v5(18.34,33.79)
PWR_DP:
  vias: v2(298.9,38.18)
PWR_LED: length 182
  L3 w0.102: v1(35.53,41.85) 37.09,40.29 49.96,40.29 60.07,30.18 87.42,30.18 87.65,29.95 123.52,29.95 126.84,26.62 174.93,26.62 175.29,26.98 176.2,26.98 176.2,26.98 190.34,26.98 192.12,28.76 199.47,28.76 199.61,28.9 201.47,28.9 v3(202.6,30.02)
  BOTTOM w0.102: v3(202.6,30.02) 202.6,29.15 202.43,28.98 202.43,26.9 203.49,25.85 U1.24 ; CN603.13 v1(35.53,41.85)
Q4001: length 15.1
  TOP w0.102: C426.2 v1(274.05,95.41) ; Q400.1 v1(281.65,88.22)
  L3 w0.102: v1(274.88,89.35) 274.29,89.94 274.29,95.16 v1(274.05,95.41)
  BOTTOM w0.102: v1(274.88,89.35) R408.2 275.56,89.35 R409.1 276.95,88.86 281.01,88.86 v1(281.65,88.22)
Q4021: length 2.9
  TOP w0.102: Q401.G 275.9,97.12 276.06,96.96 C421.1 276.52,96.9 R403.2 277.11,95.55 v2(277.17,95.55)
Q4023: length 11.4
  TOP w0.102: Q401.D 273.54,98.36 v1(273.64,98.46)
  L3 w0.102: v1(273.64,98.46) 273.64,98.34 275,96.98 275,92.21 v3(277.19,90.02)
  BOTTOM w0.102: R409.2 277.01,90.21 v3(277.19,90.02)
R_GPP_A11: length 5
  BOTTOM w0.089: U4710.BE36 259.4,47.96 260.42,47.96 260.67,48.21 261.74,48.21 262.51,48.97
  BOTTOM w0.102: 262.51,48.97 v2(262.56,49.03) 263.2,49.03 R4911.2
REAR1_A_EQ0: length 4.6
  BOTTOM w0.102: R1702.2 99.29,45.3 v2(99.29,44.61) 99.18,44.5 R1710.2 98.73,43.36 98.73,41.63 98.75,41.61 U1700.21
REAR1_A_EQ1: length 5.4
  BOTTOM w0.102: U1700.26 100.8,41.09 101.49,41.78 102.58,41.78 R1711.2 103.6,41.33 v2(104.06,41.79) 104.52,41.33 R1703.2
REAR1_B_EQ0: length 4.7
  BOTTOM w0.102: R1704.2 98,45.32 v2(98,44.61) R1712.2 98.53,43.28 98.53,41.93 98.35,41.75 U1700.20
REAR1_B_EQ1: length 4.2
  BOTTOM w0.102: R1705.2 R1713.2 93.83,41.4 94.16,41.07 95.09,41.07 v2(95.48,41.46) 95.48,41.25 96.12,40.61 U1700.15
REAR1_FGA: length 4.7
  BOTTOM w0.102: U1700.27 101.29,40.21 101.88,40.8 102.61,40.8 103.06,40.34 R1715.2 103.27,40.49 v2(103.88,40.49) 104.63,40.49 R1706.2
REAR1_FGB: length 4.8
  BOTTOM w0.102: R1707.2 92.81,40.34 v2(93.06,40.59) 93.32,40.34 R1714.2 93.83,40.5 94.2,40.87 95.23,40.87 95.89,40.21 U1700.14
REAR1_SWA: length 4.5
  BOTTOM w0.102: R1708.2 104.14,39.3 v2(104.06,39.22) 103.98,39.3 R1716.2 102.81,38.84 101.7,38.84 101.13,39.41 U1700.29
REAR1_SWB: length 4.6
  BOTTOM w0.102: R1709.2 92.91,39.45 v2(93.06,39.3) 93.21,39.45 R1717.2 94.39,38.89 95.25,38.89 95.76,39.41 U1700.12
REP_LAN_C_RX13N: length 67.7
  L10 w0.084: v1(34.74,46.8) 34.97,47.02 35.79,47.02 36.94,48.18 59.22,48.18 61.68,45.71 65.73,45.71 67.74,43.71 93.18,43.71 94.1,44.63 96.32,44.63 96.58,44.89 96.58,45.37 v3(96.78,45.56)
  BOTTOM w0.107: C1704.2 96.6,45.05 96.6,45.38 v3(96.78,45.56) ; CN603.23 34.17,46.85 34.29,46.97 34.57,46.97 v1(34.74,46.8)
REP_LAN_C_RX13P: length 67.7
  L10 w0.084: v1(96.12,45.56) 96.37,45.31 96.37,44.98 96.24,44.84 94.02,44.84 93.09,43.92 67.82,43.92 65.82,45.92 61.77,45.92 59.31,48.39 36.86,48.39 35.7,47.23 34.89,47.23 34.74,47.38 v3(34.74,47.46)
  BOTTOM w0.107: C1705.2 96.1,44.73 96.39,45.01 96.39,45.39 96.22,45.56 v1(96.12,45.56) ; CN603.24 34.18,47.35 34.36,47.18 34.46,47.18 v3(34.74,47.46)
REP_LAN_RX13N: length 4
  BOTTOM w0.107: U1700.18 97.55,41.56 97.45,41.65 97.45,41.87 97.25,42.08 96.78,42.08 96.65,42.21 96.65,42.38 v2(97.12,42.85) 96.58,43.39 96.58,43.53 C1704.1
REP_LAN_RX13P: length 4.1
  BOTTOM w0.107: C1705.1 96.37,43.53 96.37,43.38 v2(95.85,42.85) 96.44,42.26 96.44,42.12 96.69,41.87 97.16,41.87 97.24,41.78 97.24,41.65 97.15,41.56 U1700.17
REP_LAN_TX13N: length 77.1
  L10 w0.084: v1(99.83,42.36) 100.05,42.58 100.05,42.84 99.96,42.92 90.81,42.92 90.11,42.22 75.26,42.22 74.8,42.68 67.92,42.68 65.48,45.11 61.44,45.11 58.97,47.58 38.15,47.58 36.85,46.28 36.26,46.28 35.45,45.47 34.34,45.47 33.39,46.42 33.39,46.6 33.39,47.71 33.3,47.81 32.84,47.81 32.75,47.71 32.75,47.49 v1(32.84,47.4)
  BOTTOM w0.107: U1700.23 99.55,41.43 99.67,41.55 99.67,41.55 100.05,41.93 100.05,42.25 99.94,42.36 v1(99.83,42.36) ; CN603.26 33.31,48.35 33.17,48.5 32.87,48.5 32.79,48.42 32.79,47.55 32.84,47.5 v1(32.84,47.4)
REP_LAN_TX13P: length 77.2
  L10 w0.084: v3(32.3,48.01) 32.75,48.01 32.75,48.02 33.38,48.02 33.6,47.8 33.6,47.63 33.6,46.51 34.43,45.68 35.36,45.68 36.18,46.49 36.76,46.49 38.06,47.79 59.06,47.79 61.52,45.32 65.57,45.32 68.01,42.89 74.89,42.89 75.34,42.43 90.02,42.43 90.73,43.13 100.05,43.13 100.26,42.93 100.26,42.59 v1(100.49,42.36)
  BOTTOM w0.107: v3(32.3,48.01) 32.58,48.29 32.58,48.5 32.78,48.7 32.92,48.7 33.07,48.85 CN603.27 ; v1(100.49,42.36) 100.26,42.12 100.26,41.84 99.95,41.53 U1700.24
REPEATER_DP_LANE0N: length 3.8
  TOP w0.091: U55800.34 294.25,56.62 294.37,56.74 294.37,56.74 294.81,56.74 295.39,56.15 295.88,56.15 v1(296.1,55.92)
  BOTTOM w0.091: C55801.1 296.6,56.19 296.37,56.19 v1(296.1,55.92)
REPEATER_DP_LANE0P: length 3.8
  TOP w0.091: v3(296.1,56.58) 295.86,56.34 295.47,56.34 294.89,56.93 294.45,56.93 294.27,57.11 U55800.35
  BOTTOM w0.091: v3(296.1,56.58) 296.3,56.38 296.61,56.38 C55800.1
REPEATER_DP_LANE1N: length 4
  TOP w0.091: U55800.31 294.27,55.11 294.37,55.21 294.88,55.21 295.12,54.97 295.12,54.74 295.44,54.42 295.81,54.42 296.09,54.14 v1(296.1,54.14)
  BOTTOM w0.091: v1(296.1,54.14) 296.35,54.4 296.61,54.4 C55803.1
REPEATER_DP_LANE1P: length 4.1
  TOP w0.091: U55800.32 294.19,55.61 294.41,55.4 294.96,55.4 295.31,55.05 295.31,54.82 295.52,54.61 295.91,54.61 v3(296.1,54.8)
  BOTTOM w0.091: C55802.1 296.6,54.59 296.32,54.59 v3(296.1,54.8)
REPEATER_DP_LANE2N: length 4.3
  TOP w0.091: v1(296.1,52.37) 296.09,52.37 295.82,52.63 295.45,52.63 295.14,52.94 295.14,53.32 294.71,53.76 294.29,53.76 294.14,53.61 U55800.28
  BOTTOM w0.091: v1(296.1,52.37) 296.35,52.62 296.61,52.62 C55805.1
REPEATER_DP_LANE2P: length 4.3
  TOP w0.091: U55800.29 294.2,54.11 294.36,53.95 294.79,53.95 295.34,53.4 295.34,53.02 295.53,52.83 295.9,52.83 v3(296.1,53.03)
  BOTTOM w0.091: v3(296.1,53.03) 296.3,52.83 296.61,52.83 C55804.1
REPEATER_DP_LANE3N: length 17.6
  TOP w0.091: U55800.25 294.27,52.11 294.39,52.24 294.56,52.24 294.95,51.84 294.95,51.39 294.36,50.8 294.36,47.4 294.57,47.2 296.23,47.2 296.43,47.4 296.43,47.85 296.23,48.06 295.48,48.06 295.39,48.15 295.39,48.44 295.48,48.53 296.99,48.53 297.19,48.73 297.19,49.13 296.94,49.39 295.48,49.39 295.3,49.57 295.3,50.37 295.73,50.8 295.89,50.8 v1(296.1,50.59)
  BOTTOM w0.091: C55807.1 296.61,50.84 296.35,50.84 v1(296.1,50.59)
REPEATER_DP_LANE3P: length 17.6
  TOP w0.091: U55800.26 294.15,52.61 294.33,52.43 294.64,52.43 295.14,51.92 295.14,51.31 294.56,50.72 294.56,47.48 294.65,47.39 296.15,47.39 296.24,47.48 296.24,47.77 296.15,47.86 295.4,47.86 295.2,48.07 295.2,48.52 295.4,48.72 296.91,48.72 297,48.81 297,49.05 296.86,49.19 295.4,49.19 295.1,49.49 295.1,50.45 295.65,51 295.85,51 v3(296.1,51.25)
  BOTTOM w0.091: C55806.1 296.6,51.03 296.32,51.03 v3(296.1,51.25)
REPEATER_DP_LANE_0N: length 2.2
  BOTTOM w0.091: L56220.1 299.43,56.02 299.14,56.31 298.72,56.31 298.62,56.21 298.19,56.21 C55801.2
REPEATER_DP_LANE_0P: length 2.2
  BOTTOM w0.091: C55800.2 298.12,56.41 298.54,56.41 298.64,56.51 299.09,56.51 299.41,56.82 L56220.2
REPEATER_DP_LANE_1N: length 2.3
  BOTTOM w0.091: L56221.1 299.46,54.29 299.16,54.59 298.78,54.59 298.61,54.42 298.18,54.42 297.82,54.05 C55803.2
REPEATER_DP_LANE_1P: length 2.3
  BOTTOM w0.091: C55802.2 298.13,54.61 298.53,54.61 298.7,54.78 299.17,54.78 299.48,55.09 L56221.2
REPEATER_DP_LANE_2N: length 2.3
  BOTTOM w0.091: C55805.2 297.81,52.28 298.19,52.66 298.52,52.66 298.72,52.86 299.14,52.86 299.43,52.56 L56225.1
REPEATER_DP_LANE_2P: length 2.3
  BOTTOM w0.091: L56225.2 299.46,53.36 299.15,53.05 298.64,53.05 298.44,52.85 298.12,52.85 C55804.2
REPEATER_DP_LANE_3N: length 2.3
  BOTTOM w0.091: L56226.1 299.46,50.83 299.22,51.07 298.6,51.07 298.43,50.89 298.2,50.89 C55807.2
REPEATER_DP_LANE_3P: length 2.3
  BOTTOM w0.091: L56226.2 299.41,51.64 299.03,51.26 298.52,51.26 298.35,51.09 298.1,51.09 C55806.2
REPEATER_HDMI_CLKN: length 10.7
  TOP w0.076: R56688.1 300.82,69.37 299.28,69.37 295.37,73.28 293.53,73.28 293.26,73.55 292.88,73.55 292.8,73.48 U56400.16
REPEATER_HDMI_CLKP: length 10.7
  TOP w0.076: U56400.17 292.82,73.88 292.91,73.79 293.36,73.79 293.63,73.52 295.46,73.52 299.38,69.6 300.82,69.6 R56687.1
REPEATER_HDMI_D0N: length 8.8
  TOP w0.076: U56400.18 292.94,74.28 292.96,74.26 292.98,74.26 293.04,74.2 295.6,74.2 298.95,70.84 299.29,70.84 299.54,70.59 R56686.1
REPEATER_HDMI_D0P: length 8.8
  TOP w0.076: U56400.19 292.88,74.68 293.06,74.49 293.08,74.49 293.14,74.43 295.7,74.43 299.05,71.08 299.22,71.08 R56685.1
REPEATER_HDMI_D1N: length 8.7
  TOP w0.076: U56400.21 292.47,75.57 292.97,75.57 293.1,75.7 295.83,75.7 298.83,72.7 299.16,72.7 R56684.1
REPEATER_HDMI_D1P: length 8.6
  TOP w0.076: U56400.22 292.45,75.8 292.87,75.8 293,75.93 295.93,75.93 298.93,72.93 299.27,72.93 R56683.1
REPEATER_HDMI_D2N: length 10
  TOP w0.076: R56682.1 300.81,74.15 299.94,74.15 299.51,74.58 297.99,74.58 295.98,76.59 293.3,76.59 293.12,76.41 292.96,76.41 292.83,76.28 U56400.23
REPEATER_HDMI_D2P: length 10
  TOP w0.076: R56681.1 300.82,74.38 300.04,74.38 299.61,74.81 298.09,74.81 296.08,76.83 293.2,76.83 293.02,76.64 292.86,76.64 292.83,76.68 U56400.24
RESUME_PWEN: length 196.2
  TOP w0.102: R7030.1 227.23,47.5 v1(227.38,47.35)
  L5 w0.102: v1(107.34,39.17) 108.4,38.1 137.26,38.1 138.07,37.29 160.68,37.29 162.51,35.46 166.26,35.46 167.86,37.07 168.37,37.07 168.37,37.07 181.4,37.07 181.4,37.06 186.84,37.06 187.47,37.7 196.46,37.7 198.29,35.87 201.44,35.87 205.08,32.24 209.14,32.24 211.02,30.36 212.43,30.36 213.18,29.61 v1(213.18,28.73) 214.15,28.73 215.16,29.75 v1(223.19,29.75)
  BOTTOM w0.102: v1(107.34,39.17) 107.34,41.86 98.36,50.84 v2(98.36,53.95) D7001.1 ; D7001.1 95.37,53.78 94.26,53.78 94.05,53.98 94.05,55.1 93.77,55.38 89.09,55.38 87.88,54.16 87.88,51.86 87.05,51.03 82.7,51.03 80.77,52.96 79.35,52.96 78.99,53.32 78.99,55.3 78.36,55.93 77.87,55.93 R7041.1 ; D7001.1 96.96,56.35 R7040.1 ; U1.123 v1(213.18,28.73) ; v1(227.38,47.35) 228.34,46.38 228.34,41.2 227.1,39.96 223.84,39.96 223.52,39.64 223.52,30.08 v1(223.19,29.75)
RET_ADDR: length 3.4
  TOP w0.102: U56400.6 289.25,71.55 289.25,70.26 v2(289.05,70.05) 289.08,70.02 R56436.1 289.08,68.28 R56435.2
RET_GPIO1: length 4.5
  TOP w0.102: v2(287.8,67.44) 288.23,67.86 R56433.2 288.23,68.28 R56432.1 288.23,70.43 288.51,70.71 U56400.4
RET_GPIO2: length 6.2
  TOP w0.102: U56400.9 290.51,71.41 290.42,71.33 290.42,70.57 290.76,70.23 291.16,70.23 v2(291.49,69.9) 291.91,69.48 291.91,67.61 R56430.1 291.63,66.79 291.63,66.78 R56431.2
RET_RAVCC10: length 3.8
  TOP w0.292: C564001.1 284.41,75.01 v2(284.73,75.34) 285,75.34 285.26,75.08 U56400.41
  TOP w0.381: C564001.1 283.19,75.01 L56401.2
RET_RAVCC33: length 7
  TOP w0.254: C56400.1 L56400.2
  TOP w0.292: C56400.1 281.99,70.19 282.31,70.51 282.39,70.51 282.83,70.95 284.17,70.95 285.24,72.01 v2(285.24,72.16) 285.24,72.46 285.86,73.08 U56400.46
RET_RVCC10: length 8.6
  TOP w0.292: U56400.47 286.14,72.68 285.85,72.39 285.85,71.89 283.34,69.38 283.34,68.83 282.89,68.38 v2(282.17,68.38) 281.99,68.55 C56402.1 L56402.2
RET_TAVCC10: length 9.3
  TOP w0.292: U56400.20 v1(293.34,75.08)
  TOP w0.381: C56406.1 293.35,75.09 v1(293.34,75.08)
  BOTTOM w0.432: L56405.1 299.67,72.29 299.01,72.95 C56405.1 v2(297.81,73.13) 296.19,73.13 294.24,75.08 v1(293.34,75.08)
RET_TVCC10: length 6.8
  TOP w0.254: U56400.15 292.96,73.08 293.42,72.62 293.42,72.19 293.77,71.84 C56407.1
  TOP w0.432: C56407.1 294.59,71.84 v1(294.76,72.01)
  BOTTOM w0.432: v1(294.76,72.01) 295.75,72.01 296.26,71.5 v2(296.8,71.5) L56407.1
RET_TVCC33: length 6.7
  TOP w0.254: 293.01,71.73 293.01,72.5 292.83,72.68 U56400.14
  TOP w0.381: C56409.1 293.75,71 293.01,71.73
  TOP w0.432: L56408.1 C56408.1 293.26,68.63 293.34,68.63 294.1,69.4 294.1,69.88 v2(294.34,70.12) 294.06,70.41 C56409.1
RING2: length 35.8
  TOP w0.254: U500.17 14.27,57.12 14.22,57.08 v3(14.17,57.08)
  L3 w0.508: v3(14.17,57.08) 13.94,56.85 13.94,55.5 14.7,54.74 14.7,48.06 25.65,37.11 v1(32.05,37.11)
  BOTTOM w0.254: v1(32.05,37.11) 32.05,37.38 32.52,37.85 CN603.5
RING2_CONN: length 13.9
  L10 w0.254: v1(301.88,165.79) 302.59,166.5 310.38,166.5 311.42,165.46 JACK600.3
  BOTTOM w0.254: v1(301.88,165.79) 301.04,164.95 D7523.2 C24.1 L601.1
RSMRST#: length 71.2
  L10 w0.102: v1(257.79,42.98) 249.28,34.47 245.23,34.47 241.93,31.17 241.6,31.17 240.1,29.67 235.5,29.67 234.79,28.96 233.55,28.96 232.33,27.74 223.72,27.74 v1(223.54,27.92)
  BOTTOM w0.102: C7011.1 222.4,27.28 v2(222.88,26.8) 225.04,24.64 225.04,22.86 226.44,21.47 226.44,20.07 225.96,19.59 209.05,19.59 R346.2 ; C7011.1 223.17,27.54 v1(223.54,27.92) ; C7011.1 222.4,27.54 R7019.2 ; v1(257.79,42.98) 257.8,42.97 257.8,42.87 257.8,42.87 257.8,42.72 U4710.BA47
RSMRST_EC: length 2.9
  BOTTOM w0.102: R315.2 207.03,21.09 207.03,20.76 R346.1
RSVD1: length 6
  BOTTOM w0.089: 262.51,66.3 262.12,65.92 259.23,65.92 U4710.BC1
  BOTTOM w0.102: TP4600.1 263.12,66.91 262.51,66.3
RTC_RST#: length 24.9
  L10 w0.102: v3(245.23,30.81) 246.02,31.6 247.76,31.6 254.72,38.56 256.93,38.56 259.25,40.88 259.25,41.74 258.85,42.14 v1(258.62,42.14)
  BOTTOM w0.089: U4710.BE47 258.8,42.32 v1(258.62,42.14)
  BOTTOM w0.102: R4764.2 243.13,32.25 243.35,32.02 C4714.1 244.21,31.67 R4795.1 244.62,31.26 244.79,31.26 v3(245.23,30.81) 245.23,30.59 245.55,30.27 Q300.3
RTC_X1: length 10.9
  BOTTOM w0.109: U4710.BA49 257.18,40.44 257.87,39.74 260.17,39.74 260.46,40.03 261.45,40.03 262.15,39.33 262.19,39.33 263,38.52 C4767.2 263,37.29 R4862.1 263.06,36.61 262.34,35.89 X4750.1
RTC_X2: length 12.4
  BOTTOM w0.109: U4710.BA48 257.29,41.87 256.92,41.5 256.92,40.41 257.79,39.54 261.25,39.54 262.22,38.56 C4788.2 262.22,37.24 R4862.2 261.4,36.41 261.4,35.11 261.52,34.99 X4750.4
RUNSCI#: length 3.8
  TOP w0.102: v3(256.49,57.48) 256.49,57.56 257.01,58.09 R4882.2
  BOTTOM w0.089: v3(256.49,57.48) 256.49,57.38 255.93,56.82 255.93,55.59 U4710.AV21
SA0_DIM0: length 4.3
  TOP w0.102: v1(146.73,76.17) 146.68,76.13 R60.1 145.94,76.72 145.46,77.19 R4210.2
  BOTTOM w0.102: CN4100.256 146.41,75.86 v1(146.73,76.17)
SA0_DIM1: length 6.3
  TOP w0.102: R4217.1 150.92,65.25 R4216.2 151.65,64.53 v1(151.79,64.53)
  BOTTOM w0.102: v1(151.79,64.53) 151.41,64.15 CN4125.256
SA1_DIM0: length 6.1
  TOP w0.102: R4213.1 147.98,76.38 147.29,77.06 v1(146.41,77.06) 146.35,77.12 R4212.2
  BOTTOM w0.102: v1(146.41,77.06) 146.62,77.06 147.41,76.27 CN4100.260
SA1_DIM1: length 5.4
  TOP w0.102: R4119.1 151.72,63.88 v1(151.96,63.88) 152.24,64.16 152.24,64.85 R4218.2
  BOTTOM w0.102: v1(151.96,63.88) 152.01,63.84 152.26,63.84 152.52,63.58 152.52,61.62 CN4125.260
SA2_DIM0: length 5.4
  TOP w0.102: R4214.2 124.89,75.38 R4211.1 124.04,76.23 124.04,76.41 v1(123.56,76.9)
  BOTTOM w0.102: CN4100.166 124.02,74.77 124.02,76.43 v1(123.56,76.9)
SA2_DIM1: length 6.8
  TOP w0.102: R4220.2 128.73,67.63 128.27,67.16 128.27,66.21 128.48,66 R4219.1 128.89,65.85 v1(128.89,65.14)
  BOTTOM w0.102: v1(128.89,65.14) 128.91,65.13 CN4125.166
SATA_LED#: length 6.7
  BOTTOM w0.102: U4710.AK48 251.41,41.9 251.41,40.21 251.15,39.96 251.15,38.76 250.92,38.54 250.92,37.65 v2(251.02,37.54) 250.87,37.39 250.87,36.41 R4749.2
SATA_PCIE_SEL: length 2.2
  BOTTOM w0.102: U1700.30 100.95,39.01 101.65,38.31 v2(101.65,38.08) R1718.2
SB_PWRBTN#: length 56.3
  L5 w0.102: v1(208.23,45.23) 209.97,43.49 212.82,43.49 213.97,42.35 218.4,42.35 219.05,41.7 228.98,41.7 230.66,43.39 237.36,43.39 239.04,41.7 240.3,41.7 241.07,42.47 257.96,42.47 258.07,42.57 258.97,42.57 v1(259.61,43.21)
  BOTTOM w0.102: v1(259.61,43.21) 259.61,43.21 259.5,43.21 259.34,43.05 U4710.BE46 ; v1(208.23,45.23) 208.48,44.97 R350.2
SB_PWRBTN#_EC: length 3.3
  BOTTOM w0.102: U1.83 207.49,41.69 v2(208.48,42.67) 208.48,42.68 R350.1
SBPWR_EN_EC: length 3.2
  BOTTOM w0.102: U1.82 207.09,41.92 207.26,42.09 v2(207.26,42.22) 207.26,42.7 207.44,42.88 R352.1
SCAN_IN<0>: length 101
  L5 w0.102: v1(103.4,33.58) 103.76,33.94 105.37,33.94 107.59,36.16 129.2,36.16 130.53,34.83 160.85,34.83 161.84,33.84 168.7,33.84 168.88,34.01 171.44,34.01 172.78,35.36 194.46,35.36 v1(196.29,37.19)
  BOTTOM w0.102: U1.58 198.59,36.83 196.64,36.83 196.34,37.14 ; 196.34,37.14 D250.1 ; 196.34,37.14 v1(196.29,37.19) ; v1(103.4,33.58) 103.25,33.43 CN250.26
SCAN_IN<1>: length 102.1
  L5 w0.102: v3(102.25,33.23) 103.16,34.14 105.28,34.14 107.51,36.37 129.28,36.37 130.61,35.03 160.93,35.03 161.92,34.04 166.85,34.04 167.84,35.03 172.17,35.03 172.7,35.56 193.8,35.56 v1(195.43,37.19)
  BOTTOM w0.102: U1.59 197.13,37.14 196.64,37.62 195.86,37.62 v1(195.43,37.19) 195.43,36.89 195.45,36.87 D251.1 ; CN250.25 v3(102.25,33.23)
SCAN_IN<2>: length 103.3
  L5 w0.102: v1(194.54,37.19) 193.11,35.77 172.62,35.77 172.09,35.24 167.93,35.24 167.76,35.24 166.76,34.24 162.01,34.24 161.01,35.24 160.84,35.24 130.7,35.24 129.37,36.57 107.42,36.57 105.2,34.34 102.01,34.34 v1(101.25,33.58)
  BOTTOM w0.102: D252.1 194.56,36.87 194.54,36.89 v1(194.54,37.19) 195.17,37.82 197,37.82 197.29,37.53 U1.60 ; CN250.24 v1(101.25,33.58)
SCAN_IN<3>: length 104.4
  L5 w0.102: v3(100.25,33.23) 100.25,33.66 101.14,34.55 105.12,34.55 107.34,36.77 129.45,36.77 130.78,35.44 160.76,35.44 161.1,35.44 162.09,34.45 166.68,34.45 167.67,35.44 168.01,35.44 172,35.44 172.53,35.97 192.43,35.97 v1(193.65,37.19)
  BOTTOM w0.102: U1.61 197.32,37.94 197.2,38.05 194.81,38.05 193.96,37.19 v1(193.65,37.19) 193.65,36.89 193.67,36.87 D253.1 ; CN250.23 v3(100.25,33.23)
SCAN_IN<4>: length 105.4
  L5 w0.102: v1(99.25,33.58) 100.42,34.75 105.03,34.75 107.26,36.98 129.54,36.98 130.87,35.64 160.68,35.64 160.68,35.64 161.18,35.64 162.18,34.65 166.6,34.65 167.59,35.64 168.1,35.64 171.92,35.64 172.45,36.17 191.72,36.17 v1(192.76,37.22)
  BOTTOM w0.102: CN250.22 v1(99.25,33.58) ; D254.1 192.78,36.89 192.76,36.91 v1(192.76,37.22) 193.44,37.9 194.37,37.9 194.73,38.26 197.18,38.26 197.25,38.33 U1.62
SCAN_IN<5>: length 106.6
  L5 w0.102: v1(191.87,37.22) 191.11,36.45 176.09,36.45 176.09,36.46 168.11,36.46 166.51,34.85 162.26,34.85 161.24,35.87 130.93,35.87 129.62,37.18 107.17,37.18 104.95,34.95 99.72,34.95 98.25,33.49 v3(98.25,33.23)
  BOTTOM w0.102: CN250.21 v3(98.25,33.23) ; U1.63 197.23,38.73 197.01,38.51 194.7,38.51 194.37,38.18 192.83,38.18 v1(191.87,37.22) 191.87,36.91 191.89,36.89 D255.1
SCAN_IN<6>: length 107.8
  L5 w0.102: v1(190.98,37.22) 190.42,36.66 181.23,36.66 181.23,36.66 168.2,36.66 168.03,36.66 166.43,35.06 162.34,35.06 160.69,36.71 137.83,36.71 137.71,36.82 130.26,36.82 129.7,37.38 107.09,37.38 106.18,36.48 100.87,36.48 97.62,33.23 v1(97.25,33.23)
  BOTTOM w0.102: CN250.20 v1(97.25,33.23) ; D256.1 191,36.89 190.98,36.91 v1(190.98,37.22) 190.98,37.5 191.33,37.85 TP306.1 191.94,38.48 194.23,38.48 194.48,38.74 196.95,38.74 197.34,39.13 U1.64
SCAN_IN<7>: length 111.9
  L5 w0.102: v1(96.25,33.23) 96.66,33.63 97.74,33.63 100.78,36.68 106.1,36.68 107.22,37.8 137.02,37.8 137.77,37.05 160.64,37.05 162.43,35.26 166.34,35.26 167.95,36.86 168.28,36.86 181.32,36.86 181.32,36.86 189.84,36.86 v1(190.22,37.24)
  BOTTOM w0.102: U1.65 198.84,40.73 198.7,40.59 197.77,40.59 TP307.1 D257.1 196.38,40.11 195.91,39.63 194.66,39.63 193.72,40.57 191.97,40.57 190.24,38.84 190.24,37.27 v1(190.22,37.24) ; CN250.19 v1(96.25,33.23)
SCAN_OUT<0>: length 125.3
  L5 w0.102: v3(80.25,29.26) 80.83,28.68 106.7,28.68 108.68,30.66 123.28,30.66 126.95,26.98 187.87,26.98 187.87,26.98 188.71,26.98 188.71,26.98 191.3,26.98 192.06,27.74 195.33,27.74 196.32,28.73 197.13,28.73 197.27,28.58 v1(197.27,28.32)
  BOTTOM w0.102: v1(197.27,28.32) 197.32,28.27 197.65,28.27 197.8,28.13 197.8,28.12 197.99,27.93 U1.36 ; CN250.3 v3(80.25,29.26)
SCAN_OUT<1>: length 125.6
  L5 w0.102: v3(195.46,29.75) 194.19,28.48 191.54,28.48 190.65,27.59 188.46,27.59 157.26,27.59 155.84,29.01 125.79,29.01 122.8,32 109.16,32 106.45,29.29 84.35,29.29 83.77,29.87 81.76,29.87 v1(81.15,29.26)
  BOTTOM w0.102: v1(81.15,29.26) 81.25,29.36 CN250.4 ; U1.37 197.88,28.33 197.15,29.06 196.15,29.06 v3(195.46,29.75)
SCAN_OUT<2>: length 124
  L5 w0.102: v1(196.16,29.7) 194.61,28.15 191.89,28.15 191.13,27.38 188.54,27.38 188.54,27.38 188.03,27.38 127.12,27.38 123.44,31.06 108.51,31.06 106.53,29.09 84.27,29.09 83.68,29.67 82.35,29.67 v3(81.95,29.26)
  BOTTOM w0.102: U1.38 197.77,28.73 197.23,29.26 196.59,29.26 v1(196.16,29.7) ; CN250.5 82.25,29.57 v3(81.95,29.26)
SCAN_OUT<3>: length 122.3
  L5 w0.102: v1(196.8,29.7) 195.04,27.94 191.98,27.94 191.22,27.18 188.62,27.18 187.95,27.18 187.95,27.18 127.04,27.18 123.36,30.86 108.6,30.86 106.62,28.88 83.61,28.88 v3(83.23,29.26)
  BOTTOM w0.102: v3(83.23,29.26) 83.25,29.28 CN250.6 ; U1.39 197.65,29.13 197.32,29.47 197.02,29.47 v1(196.8,29.7)
SCAN_OUT<4>: length 122.1
  L5 w0.102: v3(84.25,31.12) 87.3,31.12 88.31,30.1 104.7,30.1 107.4,32.81 125.8,32.81 128.71,29.91 157.69,29.91 157.86,30.08 160.6,30.08 160.88,29.8 175.15,29.8 175.69,30.33 175.86,30.33 191.34,30.33 191.77,30.76 195.2,30.76 195.6,31.17 198.24,31.17 v1(199.84,29.57)
  BOTTOM w0.102: CN250.7 v3(84.25,31.12) ; v1(199.84,29.57) 199.81,29.53 U1.40
SCAN_OUT<5>: length 120.3
  L5 w0.102: v3(85.25,29.77) 85.86,30.38 87.75,30.38 88.23,29.9 106.2,29.9 108.9,32.61 125.72,32.61 128.62,29.71 157.77,29.71 157.94,29.87 158.28,29.87 158.56,29.59 175.24,29.59 175.77,30.13 191.42,30.13 191.85,30.56 195.35,30.56 195.75,30.97 197.18,30.97 197.56,30.59 v1(197.56,29.92)
  BOTTOM w0.102: U1.41 198.68,29.92 v1(197.56,29.92) ; CN250.8 v3(85.25,29.77)
SCAN_OUT<6>: length 119.7
  L5 w0.102: v1(86.23,29.77) 86.64,30.18 87.66,30.18 88.14,29.7 106.28,29.7 108.99,32.4 125.64,32.4 128.55,29.49 156.94,29.49 158.44,27.99 188.29,27.99 189.58,29.29 190.87,29.29 191.94,30.36 195.43,30.36 195.84,30.76 196.55,30.76 v3(196.97,30.34)
  BOTTOM w0.102: U1.42 196.98,30.33 v3(196.97,30.34) ; CN250.9 86.25,31.37 86.23,31.35 v1(86.23,29.77)
SCAN_OUT<7>: length 118.3
  L5 w0.102: v3(87.25,29.77) 87.53,29.49 106.37,29.49 109.07,32.2 125.33,32.2 128.24,29.29 156.85,29.29 158.35,27.79 188.37,27.79 189.67,29.09 190.95,29.09 192.02,30.15 195.93,30.15 v1(196.14,30.36)
  BOTTOM w0.102: v3(87.25,29.77) CN250.10 ; U1.43 197.71,30.73 197.7,30.74 196.52,30.74 v1(196.14,30.36)
SCAN_OUT<8>: length 115.3
  L5 w0.102: v1(88.25,31.12) 89.04,30.31 104.61,30.31 107.32,33.01 125.89,33.01 127.53,31.37 156.44,31.37 157.17,30.64 170.52,30.64 171.15,30 175.07,30 175.6,30.53 175.94,30.53 191.25,30.53 191.78,31.07 194.86,31.07 195.19,31.4 196.62,31.4 v3(196.91,31.69)
  BOTTOM w0.102: U1.44 197.47,31.13 v3(196.91,31.69) ; CN250.11 v1(88.25,31.12)
SCAN_OUT<9>: length 114.5
  L5 w0.102: v1(196.24,31.83) 196.01,31.6 195.1,31.6 195.01,31.5 192.85,31.5 192.62,31.73 188.98,31.73 187.99,30.74 176.02,30.74 175.52,30.74 174.99,30.2 171.24,30.2 170.6,30.84 157.26,30.84 156.47,31.63 128.06,31.63 126.47,33.22 107.23,33.22 104.53,30.51 89.84,30.51 v3(89.25,31.12)
  BOTTOM w0.102: CN250.12 v3(89.25,31.12) ; U1.45 197.78,31.53 197.19,32.12 196.52,32.12 v1(196.24,31.83)
SCAN_OUT<10>: length 113.2
  L5 w0.102: v3(90.55,31.12) 90.94,30.71 104.44,30.71 107.15,33.42 126.63,33.42 128.22,31.83 156.55,31.83 157.34,31.04 170.68,31.04 171.32,30.41 174.9,30.41 175.43,30.94 176.11,30.94 187.62,30.94 188.61,31.93 192.71,31.93 192.93,31.71 194.92,31.71 195.22,32.01 v1(195.65,32.01)
  BOTTOM w0.102: CN250.13 90.25,31.42 v3(90.55,31.12) ; U1.46 197.67,31.93 197.18,32.41 196.06,32.41 v1(195.65,32.01)
SCAN_OUT<11>: length 115.3
  L5 w0.102: v1(91.54,31.12) 92.56,32.13 104.43,32.13 107.85,35.55 128.95,35.55 130.38,34.12 149.32,34.12 149.88,33.56 151.92,33.56 152.12,33.75 159.65,33.75 161.34,32.06 167.79,32.06 169.14,33.4 192.78,33.4 193.29,33.91 195,33.91 195.26,34.17 199.41,34.17 v3(199.82,33.76)
  BOTTOM w0.102: v1(91.54,31.12) 91.25,31.41 CN250.14 ; v3(199.82,33.76) 199.64,33.93 U1.51
SCAN_OUT<12>: length 115.9
  L5 w0.102: v1(200.57,33.79) 200.13,33.35 194.07,33.35 193.71,33.71 193.38,33.71 192.87,33.2 169.26,33.2 167.91,31.86 161.25,31.86 160.32,32.79 160.16,32.79 150.37,32.78 149.24,33.91 130.3,33.91 128.86,35.35 107.93,35.35 104.51,31.93 93.06,31.93 v3(92.25,31.12)
  BOTTOM w0.102: U1.52 199.91,34.33 200.45,33.79 v1(200.57,33.79) ; CN250.15 v3(92.25,31.12)
SCAN_OUT<13>: length 116
  L5 w0.102: v3(93.57,31.12) 94.18,31.73 104.6,31.73 108.02,35.15 128.2,35.15 129.64,33.71 149.02,33.71 150.15,32.58 160.24,32.58 161.17,31.65 168,31.65 169.24,32.9 194.17,32.9 194.2,32.93 200.46,32.93 201.24,33.71 v1(201.24,33.79)
  BOTTOM w0.102: U1.53 199.88,34.74 200.22,34.39 200.71,34.39 201.24,33.86 v1(201.24,33.79) ; v3(93.57,31.12) 93.25,31.44 CN250.16
SCAN_OUT<14>: length 116.7
  L5 w0.102: v1(94.3,31.12) 94.71,31.52 104.68,31.52 108.1,34.94 125.68,34.94 128.33,32.29 160.08,32.29 160.08,32.29 160.25,32.29 161.08,31.45 168.08,31.45 169.33,32.69 194.26,32.69 194.29,32.72 200.89,32.72 v3(201.95,33.79)
  BOTTOM w0.102: U1.54 199.77,35.13 200.28,34.62 201.11,34.62 v3(201.95,33.79) ; CN250.17 94.25,31.17 v1(94.3,31.12)
SCAN_OUT<15>: length 117.7
  L5 w0.102: v3(95.3,31.12) 104.56,31.12 108.18,34.74 125.59,34.74 128.25,32.08 160.16,32.08 161,31.25 168.17,31.25 168.96,32.03 176.49,32.03 177.12,31.4 187.79,31.4 188.88,32.49 194.34,32.49 194.37,32.52 201.35,32.52 v1(202.61,33.79)
  BOTTOM w0.102: CN250.18 95.25,31.17 v3(95.3,31.12) ; v1(202.61,33.79) 201.55,34.85 200.34,34.85 199.65,35.54 U1.55
SCAN_OUT<16>: length 128.9
  L5 w0.102: v3(78.2,31.12) 79.78,32.77 104.49,32.77 107.68,35.96 129.11,35.96 130.45,34.62 159.81,34.62 160.8,33.63 168.79,33.63 168.97,33.81 192.62,33.81 193.12,34.32 194.83,34.32 195.34,34.83 199.69,34.83 v1(200.31,35.45)
  BOTTOM w0.102: v1(200.31,35.45) 199.83,35.93 U1.56 ; CN250.1 78.25,31.24 v3(78.2,31.12)
SCAN_OUT<17>: length 130.3
  L5 w0.102: v3(79.47,31.14) 80.9,32.57 104.57,32.57 107.76,35.76 129.03,35.76 130.37,34.42 159.61,34.42 161.77,32.26 167.7,32.26 169.05,33.61 192.7,33.61 193.21,34.12 194.92,34.12 195.17,34.37 199.99,34.37 v1(201.06,35.44)
  BOTTOM w0.102: v1(201.06,35.44) 200.17,36.34 U1.57 ; CN250.2 79.25,31.37 v3(79.47,31.14)
SD3_1P8_RCOMP: length 2
  TOP w0.089: R4605.1 259.23,62.56
  TOP w0.102: 259.23,62.56 259.13,62.56 v2(259.01,62.68) v1(258.54,63.15)
  BOTTOM w0.089: U4710.BE5 258.54,63.15 v1(258.54,63.15)
SD3_3P3_RCOMP: length 7
  BOTTOM w0.089: U4710.BE4 259.34,63.56 260.05,62.86 260.31,62.86 261.03,63.58 261.87,63.58 262.51,64.21
  BOTTOM w0.102: R4606.1 v2(264.54,64.11) 264.31,64.34 262.63,64.34 262.51,64.21
SERIRQ: length 80.9
  TOP w0.102: v1(256.94,48.7) 256.94,48.16 257.25,47.86 257.81,47.86 258.42,47.25 259.36,47.25 261.29,45.32 264.87,45.32 265.99,46.43 v2(266.72,46.43) 266.85,46.43 v1(267.38,46.97) 267.31,47.04 R4873.2
  L10 w0.102: v1(211.32,31.52) 212.47,30.38 216.01,30.38 216.26,30.13 216.6,30.13 216.62,30.15 219.13,30.15 219.28,30 219.7,30 219.85,30.15 224.59,30.15 225.04,29.7 230.51,29.7 231.76,30.94 237.29,30.94 239.81,33.46 241.99,33.46 242.16,33.46 243.79,35.08 243.79,35.96 247.7,39.87 247.7,43.31 248.84,44.45 249.83,44.45 250.9,45.52 252.73,45.52 253.33,46.13 256.31,46.13 257.32,47.15 257.32,47.22 257.43,47.32 257.43,47.7 256.94,48.19 v1(256.94,48.7)
  BOTTOM w0.089: v1(256.94,48.7) 256.71,48.7 U4710.AW35
  BOTTOM w0.102: v1(267.38,46.97) 267.78,47.37 R4904.1 ; v1(211.32,31.52) 212.06,30.79 212.06,29.29 211.6,28.83 211.6,26.72 211.09,26.21 U1.5
SERIRQ_ESPI_RST#: length 2.1
  BOTTOM w0.102: R4902.2 266.27,48.82 TP4806.1 267.05,47.9 R4904.2
SET_R: length 2.1
  TOP w0.102: U2501.4 282.45,30.93 282.44,30.92 v2(282.37,30.92) 281.65,30.92 R2559.2
SH_IN_N3: length 2.3
  BOTTOM w0.102: U52000.13 142.47,50.78 v2(141.93,51.31) 141.91,51.34 R52038.1
SH_IN_N4: length 3.1
  BOTTOM w0.102: R52036.1 142.24,54.46 v2(143.13,53.57) 143.19,53.5 U52000.16
SH_IN_P3: length 2.3
  BOTTOM w0.102: R52039.1 141.88,50.17 v2(142.01,50.04) 142.34,50.37 U52000.12
SH_IN_P4: length 4.1
  BOTTOM w0.102: U52000.15 142.76,51.58 142.62,51.72 142.62,53.09 v2(141.86,53.85) 141.35,54.36 R52037.1
SLEEVE: length 32.4
  TOP w0.254: v1(15.23,56.64) 15.32,56.72 U500.18
  L3 w0.508: v1(15.23,56.64) 15.49,56.38 15.49,48.35 25.97,37.87 v1(31.72,37.87)
  BOTTOM w0.254: v1(31.72,37.87) 32.05,37.87 32.52,38.35 CN603.6
SLP_A: length 6.7
  BOTTOM w0.089: U4710.BE40 259.32,46.31 259.66,46.31 259.77,46.21
  BOTTOM w0.102: 259.77,46.21 260.01,45.96 260.56,45.96 260.88,45.65 261.84,45.65 263.21,47.02 TP4700.1
SLP_LAN#: length 4.6
  BOTTOM w0.089: 262.51,45.77 262.2,45.47 260.8,45.47 260.49,45.78 259.93,45.78 259.81,45.9 259.62,45.9 U4710.BF40
  BOTTOM w0.102: TP4703.1 263.14,46.41 262.51,45.77
SLP_S0#: length 4.5
  TOP w0.089: v1(260.97,51.97) 261.29,51.66 261.29,50.98 TP4701.1
  BOTTOM w0.089: v1(260.97,51.97) 260.19,51.97 259.83,51.61 258.24,51.61 U4710.BC28
SLP_S3#: length 77.3
  L10 w0.102: v1(266.7,43.41) 264.69,43.41 260.27,38.99 258.97,38.99 256.54,36.56 256.54,33.99 255.09,32.54 255.09,31.2 253.04,29.16 253.04,29.16 252.49,28.6 252.32,28.6 247.94,28.6 247.28,27.94 234.3,27.94 230.59,24.23 225.52,24.23 222.72,27.04 214.1,27.04 v1(212.43,28.71)
  BOTTOM w0.089: 261.44,44.43 259.97,44.43 U4710.BF42
  BOTTOM w0.102: v1(212.43,28.71) 213.03,29.3 213.03,30 213.36,30.33 U1.119 ; v1(266.7,43.41) 266.18,42.9 R4718.1 265.55,43.31 262.56,43.31 261.44,44.43
SLP_S4#: length 76.3
  L10 w0.102: v3(203.73,30.89) 204.29,30.33 204.77,30.33 205.99,29.11 212.93,29.11 212.96,29.14 214.09,29.14 214.54,28.69 220.46,28.69 221.42,27.73 223.12,27.73 223.34,27.51 232.39,27.51 233.63,28.76 234.87,28.76 235.58,29.47 240.7,29.47 241.37,30.13 246.86,30.13 255.09,38.36 257.02,38.36 260.07,41.41 260.07,41.42 261.38,42.73 v1(261.38,43.91)
  BOTTOM w0.089: v1(261.38,43.91) 261.03,44.25 259.73,44.25 259.29,44.69 U4710.BE42
  BOTTOM w0.102: v3(203.73,30.89) 203.27,30.43 203.27,29.14 202.89,28.76 202.89,27.11 203.6,26.39 204.3,26.39 204.69,26.01 U1.21
SLP_S5#_3R: length 5.5
  BOTTOM w0.089: 262.51,45 261.89,45 261.83,45.06 260.7,45.06 260.45,45.32 259.97,45.32 259.8,45.15 258.67,45.15 258.51,44.99 U4710.BC42
  BOTTOM w0.102: 262.51,45 263.31,45 TP4705.1
SLP_SUS#: length 59.5
  L10 w0.102: v3(256.96,47.39) 256.89,47.32 253.51,47.32 253.03,46.84 253.03,46.6 252.26,45.83 250.85,45.83 249.68,44.66 248.76,44.66 247.49,43.39 247.49,39.96 243.58,36.04 243.58,35.17 242.07,33.66 239.72,33.66 237.67,31.61 232.35,31.61 232.18,31.78 225.36,31.78 224.65,31.07 212.37,31.07 v1(211.91,31.52)
  BOTTOM w0.089: v3(256.96,47.39) 256.96,47.23 257.53,46.66 257.81,46.66 257.95,46.52 U4710.BD39
  BOTTOM w0.102: v1(211.91,31.52) 212.7,30.73 U1.118
SLP_WLAN#: length 34.3
  TOP w0.102: Q1300.1 271.61,23.62 272,24 R1301.2 272.64,24.04 v2(272.64,25.07) 272.64,25.7 272.97,26.04 272.97,28.83 273.96,29.82 273.96,36.25 268.6,41.61 268.6,42.38 267.09,43.89 263.04,43.89 v1(262.73,44.2)
  BOTTOM w0.089: U4710.BD42 258.87,44.97 259.88,44.97 260.04,45.14 260.3,45.14 260.55,44.89 261.76,44.89 262.44,44.2 262.51,44.2
  BOTTOM w0.102: 262.51,44.2 v1(262.73,44.2)
SMB0_CLK: length 178
  TOP w0.109: R359.2 218.23,33.96 218.41,33.79 v1(218.49,33.79)
  L5 w0.076: v1(282.75,59.69) 282.75,59.11 272.4,48.76 272.4,42.79 267.75,38.14 262.04,38.14 261.52,38.66 258.2,38.66 256.47,36.94 252.02,36.94 250.25,35.17 245.41,35.17 244.14,33.9 238.06,33.9 237.64,34.32 232.33,34.32 231.49,33.48 223.8,33.48 223.26,32.94 218.85,32.94 218.49,33.3 v1(218.49,33.79) 214.55,33.79 214.17,34.17 204.71,34.17 202.16,36.72 198.64,36.72 196.81,38.55 190.07,38.55 189.33,39.29 175.52,39.29 175.17,38.93 172.15,38.93 171.64,39.44 167.83,39.44 164.91,36.52 162.96,36.52 159.91,39.56 153.56,39.56 153.43,39.69 134.93,39.69 v1(134.24,40.39)
  BOTTOM w0.109: U1.110 217.47,33.93 217.8,33.61 v2(217.85,33.61) 218.31,33.61 v1(218.49,33.79) ; Q700.6 134.61,40.76 134.44,40.59 134.43,40.59 v1(134.24,40.39) ; v1(282.75,59.69) 283.16,59.69 283.37,59.91 Q303.6
SMB0_CLK_D: length 268.8
  TOP w0.109: v1(258.49,77.58) v2(257.3,77.58) 255.93,77.58 253.35,80.15 241.49,80.15 240.59,81.05 237.09,81.05 236.37,81.77 235.18,81.77 233.73,83.22 233.32,83.22 216.46,83.22 214.75,81.52 214.75,77.88 213.83,76.96 213.83,75.73 214.12,75.44 v1(214.35,75.44) ; R56463.2 v1(286.13,81.36) ; U55800.19 291.92,49.99 291.19,49.25 290.65,49.25 v1(290.61,49.22) 290.34,48.95 R55832.1
  L5 w0.076: v1(286.13,81.36) 286.13,81.14 284.15,79.16 284.15,69.09 281.4,66.35 281.4,65.28 282.04,64.65 282.04,63.33 v1(284.68,60.68)
  L8 w0.076: v1(160.7,86.24) 160.7,84.86 162.1,83.47 162.1,78.72 167.33,73.49 212.39,73.49 v1(214.35,75.44) ; v1(284.68,60.68) 282.95,62.41 282.95,63.4 280.87,65.48 269.21,65.48 268.03,66.67 265.31,66.67 258.49,73.49 v1(258.49,77.58)
  L10 w0.076: v1(284.68,60.68) 284.68,59.97 284.4,59.69 284.4,56.21 290.61,50 v1(290.61,49.22)
  BOTTOM w0.109: v1(160.7,86.24) 160.55,86.08 160.55,85.65 157.84,82.94 154.03,82.94 151.32,85.65 151.32,92.58 148.99,94.91 145.84,94.91 145.28,94.35 140.74,94.35 138.36,96.72 138.36,108.83 137.01,110.19 137.01,117.13 139.38,119.5 143.85,119.5 146.06,121.71 147.16,121.71 147.86,121.01 U4450.8 ; R325.2 283.55,58.15 283.37,58.34 Q303.1 284.06,58.74 284.68,59.36 v1(284.68,60.68)
SMB0_DATA: length 175.4
  TOP w0.109: v3(219.01,33.34) 218.75,33.07 R360.2
  L5 w0.076: v1(279.47,56.72) 279.42,56.72 278.79,56.09 278.79,55.92 269.92,47.06 269.92,40.96 267.56,38.6 262.23,38.6 261.68,39.14 258.03,39.14 257.56,38.68 246.9,38.68 243.02,34.8 231.95,34.8 231.09,33.94 219.61,33.94 v3(219.01,33.34) 219.01,33.91 218.68,34.24 216.94,34.24 216.56,34.62 204.9,34.62 202.35,37.18 198.83,37.18 197,39.01 190.44,39.01 190.44,39.01 190.26,39.01 189.52,39.74 175.33,39.74 174.98,39.39 172.34,39.39 171.81,39.92 166.83,39.92 165.63,41.12 161.56,41.12 160.46,40.02 153.75,40.02 153.62,40.15 135.16,40.15 v1(134.24,41.08)
  BOTTOM w0.109: U1.111 214.36,33.47 214.82,33.47 214.84,33.44 216.97,33.44 217.34,33.07 218.75,33.07 v3(219.01,33.34) ; Q303.3 282.07,58.35 280.61,56.9 279.6,56.9 279.47,56.77 v1(279.47,56.72) ; v1(134.24,41.08) 134.24,41.66 133.84,42.06 Q700.3
SMB0_DATA_D: length 261.5
  TOP w0.109: R56462.2 v1(287.02,81.39) ; U55800.18 291.04,49.89 290.5,49.89 v1(289.81,49.2) 289.43,48.82 R55831.1 ; v1(214.32,76.08) 214.32,76.74 215.34,77.75 215.34,81.41 216.66,82.73 233.52,82.73 234.97,81.28 236.17,81.28 236.88,80.56 240.38,80.56 241.29,79.66 252.85,79.66 255.67,76.84 v1(259.03,76.84)
  L5 w0.076: v1(281.96,65.33) 281.96,66.22 284.6,68.86 284.6,78.97 v1(287.02,81.39)
  L8 w0.076: v1(259.03,76.84) 259.03,73.64 265.55,67.12 268.22,67.12 269.4,65.94 281.35,65.94 v1(281.96,65.33) ; v1(214.32,76.08) 214.17,76.08 212.04,73.94 167.81,73.94 162.81,78.95 162.81,83.72 161.19,85.35 v1(161.19,85.75)
  L10 w0.076: v1(281.78,60) 281.78,59.64 283.59,57.84 283.59,55.71 286.66,52.64 286.66,52.36 v1(289.81,49.2)
  BOTTOM w0.109: v1(161.19,85.75) 161.19,85.55 158.09,82.45 153.82,82.45 150.14,86.14 150.14,93.07 148.79,94.42 146.05,94.42 145.49,93.86 140.53,93.86 137.87,96.52 137.87,108.53 136.52,109.89 136.52,117.33 139.4,120.22 TP4450.1 143.88,120.22 145.86,122.2 147.6,122.2 148.51,121.29 148.51,118.47 148.23,118.19 147.55,118.19 147.21,118.53 U4450.7 ; v1(281.78,60) 281.78,60.07 282.07,60.36 Q303.4 282.07,61.67 R327.2 282.16,65.19 282.01,65.33 v1(281.96,65.33)
SMBALERT#: length 5.1
  BOTTOM w0.109: R4717.1 262.63,55.48 v2(262.51,55.35) 260.93,53.78 260.27,53.78 259.94,53.44 259.53,53.44 259.27,53.18 U4710.BE25
SPI0_CS1#: length 5.2
  BOTTOM w0.109: U4710.AW48 255.98,42.08 255.98,39.55 255.5,39.07 255.5,37.27 TP4714.1
SPI_EC_CLK: length 5.8
  BOTTOM w0.109: U1.105 215,35.93 215.72,36.66 216.36,36.66 v2(216.43,36.74) 216.69,36.99 216.69,37.27 217.25,37.83 219.03,37.83 R311.1
SPI_EC_CS0#: length 5.1
  BOTTOM w0.109: R13.1 218.21,39.78 217.47,39.04 217.4,39.04 217.15,38.79 216.85,38.79 215.68,37.62 215.32,37.62 215.24,37.53 U1.101
SPI_EC_SI: length 23.9
  TOP w0.109: R12.1 223.37,27.53 224.33,26.57 v1(225.04,26.57)
  L8 w0.076: v1(221.23,36.68) 221.23,34.36 225.04,30.55 v1(225.04,26.57)
  BOTTOM w0.109: v1(221.23,36.68) v2(221.23,37.34) 221.23,38.13 220.96,38.4 220.95,38.4 220.13,39.22 218.08,39.22 217.66,38.8 217.5,38.8 217.25,38.55 216.94,38.55 215.78,37.39 215.42,37.39 215.17,37.14 U1.102
SPI_EC_SO: length 5.5
  BOTTOM w0.109: U1.103 215.1,36.73 215.52,37.15 215.91,37.15 216.2,37.44 216.2,37.47 217.04,38.32 v2(218.11,38.32) 218.55,38.76 R11.1
SPK_OUT_L_N: length 3.7
  TOP w0.254: U500.43 23.59,56.72 24.45,57.59 R508.2
SPK_OUT_L_P: length 3.4
  TOP w0.254: U500.42 24.46,56.32 v2(24.6,56.46) 24.61,56.44 R509.2
SPK_OUT_R_L_N: length 22.2
  TOP w0.508: R508.1 27.56,57.59 v5(27.81,57.84)
  BOTTOM w0.356: 31.99,41.11 32.25,40.85 CN603.11
  BOTTOM w0.635: v3(28.53,57.99) 28.08,57.99 27.92,57.84 v5(27.81,57.84) 27.63,57.66 27.63,55.86 29.49,54 29.49,43.63 31.99,41.13 31.99,41.11
SPK_OUT_R_L_P: length 20.6
  TOP w0.508: R509.1 28.06,56.44 v5(28.52,56.9)
  BOTTOM w0.356: 32.58,41.91 33.15,41.35 CN603.12
  BOTTOM w0.635: v1(29.13,57.2) 29,57.08 28.7,57.08 v5(28.52,56.9) 28.52,56.23 30.38,54.37 30.38,44.14 32.58,41.93 32.58,41.91
SPK_OUT_R_N: length 3.1
  TOP w0.254: v2(24.58,58.7) 24.58,58.45 23.26,57.12 U500.44
SPK_OUT_R_P: length 3.9
  TOP w0.254: v2(24.63,59.97) 24.58,59.97 23.81,59.2 23.81,58.68 23.77,58.64 23.77,58.62 23.69,58.54 23.69,58.14 23.08,57.52 U500.45
SPK_OUT_R_R_N: length 25
  TOP w0.508: R510.1 27.43,58.73 27.53,58.83 27.63,58.83 v5(27.71,58.91)
  BOTTOM w0.356: CN603.10 31.65,40.35 31.28,40.72 31.06,40.72
  BOTTOM w0.635: v1(28.42,58.98) 27.81,58.98 27.73,58.91 v5(27.71,58.91) 27.63,58.83 27.4,58.83 26.62,58.04 26.62,55.62 28.6,53.64 28.6,43.18 31.06,40.72
SPK_OUT_R_R_P: length 28.1
  TOP w0.508: R511.1 v5(27.73,59.87)
  BOTTOM w0.356: CN603.9 30.66,39.85 30.32,40.19
  BOTTOM w0.635: v1(28.45,60.04) 27.9,60.04 v5(27.73,59.87) 27,59.87 25.73,58.6 25.73,55.25 27.64,53.33 27.64,42.74 30.2,40.19 30.32,40.19
SRTC_RST#: length 18.7
  L10 w0.102: v1(258.42,43.03) 257.86,42.47 257.76,42.47 249.56,34.27 247.5,34.27 v3(247.02,33.79)
  BOTTOM w0.089: v1(258.42,43.03) 258.74,42.71 U4710.BD46
  BOTTOM w0.102: 246.25,33.05 C4713.1 ; C4713.1 247.02,32.31 246.85,32.14 Q300.6 ; C4713.1 v3(247.02,33.79)
SSD1_DEVSLP: length 13.5
  BOTTOM w0.102: CN1901.38 69.37,44.3 69.8,44.73 69.8,46.82 72.06,49.08 74.06,49.08 74.77,49.79 v2(77.75,49.79) 78.29,49.79 R1900.2
SSD1_SATA_LED#: length 1.8
  BOTTOM w0.102: CN1901.10 67.44,37.3 TP1901.1
SSD1_TX9N: length 16
  TOP w0.107: C1916.2 74.69,48.9 74.43,48.9 73.88,48.35 73.88,47.76 v1(73.67,47.55)
  BOTTOM w0.107: v1(73.67,47.55) 73.67,47.56 73.66,47.56 71.77,45.67 71.77,40.18 74.4,37.55 CN1901.11
SSD1_TX9P: length 16
  TOP w0.107: v3(74.37,47.55) 74.09,47.83 74.09,48.26 74.52,48.7 74.77,48.7 74.99,48.48 C1919.2
  BOTTOM w0.107: CN1901.13 75.21,38.05 74.92,37.76 74.49,37.76 71.98,40.27 71.98,45.58 73.54,47.14 73.84,47.14 74.25,47.55 v3(74.37,47.55)
SSD1_TX10N: length 12.8
  BOTTOM w0.107: CN1901.23 78.29,40.55 79.83,42.09 85.77,42.09 v2(86.38,41.48) 86.38,41.71 86.69,42.02 87.1,42.02 C1917.2
SSD1_TX10P: length 12.9
  BOTTOM w0.107: C1918.2 87.33,42.22 86.55,42.22 86.38,42.4 v2(86.38,42.75) 85.93,42.3 79.74,42.3 78.2,40.76 77.5,40.76 77.21,41.05 CN1901.25
SSD1_TX11N: length 13.3
  BOTTOM w0.107: CN1901.35 77.12,43.55 77.27,43.7 79.43,43.7 79.73,44 86.93,44 v2(87.45,43.48) 87.45,43.9 87.56,44.01 88.16,44.01 C1920.2
SSD1_TX11P: length 13.3
  BOTTOM w0.107: C1921.2 88.11,44.21 87.56,44.21 87.45,44.32 v2(87.45,44.75) 86.91,44.2 79.64,44.2 79.34,43.9 77.36,43.9 77.21,44.05 CN1901.37
SSD1_TX12N: length 13.2
  BOTTOM w0.107: C1922.2 88.09,46.66 87.53,46.66 87.42,46.56 v2(87.42,46.13) 87.05,46.51 77.69,46.51 77.48,46.71 77.29,46.71 77.12,46.55 CN1901.47
SSD1_TX12P: length 13.3
  BOTTOM w0.107: CN1901.49 77.13,47.05 77.26,46.92 77.56,46.92 77.77,46.71 86.74,46.71 v2(87.42,47.4) 87.42,47.04 87.6,46.87 88.12,46.87 C1923.2
SSD1_WAKE#: length 2.6
  TOP w0.102: v1(69.86,48.61) 69.69,48.44 TP1900.1
  BOTTOM w0.102: CN1901.54 69.55,48.3 v1(69.86,48.61)
SSD2_SATA_LED#: length 1.6
  BOTTOM w0.102: TP1902.1 177.6,38.8 CN1900.10
SSD2_WAKE#: length 1.8
  BOTTOM w0.102: TP1903.1 177.15,27.8 CN1900.54
SSD_CLKREQ2#: length 11.5
  BOTTOM w0.102: R1901.1 v2(77.79,51.28) 76.5,49.99 72.62,49.99 70.42,47.8 CN1901.52
SSD_CLKREQ3#: length 2.9
  TOP w0.102: R1902.1 176.58,29.21 v3(177.26,29.21)
  BOTTOM w0.102: v3(177.26,29.21) 177.26,28.71 176.86,28.3 CN1900.52
SSD_TX1N: length 17.7
  BOTTOM w0.107: C1930.2 182.44,27.16 182.72,26.88 182.72,26.61 181.12,25.01 173.92,25.01 169.39,29.55 CN1900.47
SSD_TX1P: length 17.7
  BOTTOM w0.107: C1929.2 182.93,26.94 182.93,26.53 181.21,24.8 173.84,24.8 169.59,29.05 CN1900.49
SSD_TX2N: length 19.1
  BOTTOM w0.107: CN1900.35 169.39,32.55 169.68,32.26 171.81,32.26 172.21,31.85 172.21,28.01 174.6,25.63 180.3,25.63 180.92,26.26 180.92,26.95 180.71,27.16 C1928.2
SSD_TX2P: length 19.1
  BOTTOM w0.107: CN1900.37 171.72,32.05 172.01,31.76 172.01,27.93 174.51,25.42 180.38,25.42 181.13,26.17 181.13,26.91 C1909.2
SSD_TX3N: length 18.3
  BOTTOM w0.107: CN1900.23 169.39,35.55 169.68,35.26 171.12,35.26 174.01,32.36 174.01,27.33 174.9,26.44 178.94,26.44 179.09,26.59 179.09,26.98 178.91,27.16 C1927.2
SSD_TX3P: length 18.4
  BOTTOM w0.107: C1926.2 179.3,26.86 179.3,26.5 179.03,26.23 174.82,26.23 173.8,27.25 173.8,32.28 171.03,35.05 CN1900.25
SSD_TX4N: length 17.6
  BOTTOM w0.107: C1925.2 182.98,41.37 182.98,41.8 181.91,42.87 176.27,42.87 171.94,38.55 CN1900.11
SSD_TX4P: length 17.5
  BOTTOM w0.107: C1924.2 182.49,41.12 182.78,41.41 182.78,41.71 181.82,42.67 176.35,42.67 172.03,38.34 169.68,38.34 169.39,38.05 CN1900.13
SUSACK#: length 71.2
  L10 w0.102: v1(261.26,49.2) 264.41,46.05 264.41,43.74 260.07,39.4 258.8,39.4 256,36.6 256,34.02 254.68,32.71 254.68,31.37 252.88,29.56 252.32,29.01 247.77,29.01 247.11,28.35 234.13,28.35 231.15,25.37 230.16,25.37 228.3,27.22 223.11,27.22 222.88,27.45 221.42,27.45 220.41,28.45 216.32,28.45 v3(215.9,28.03)
  BOTTOM w0.089: U4710.BE35 259.26,48.44 259.27,48.44 259.33,48.51 259.6,48.51 259.79,48.31 260.27,48.31 260.8,48.84 260.9,48.84 v1(261.26,49.2)
  BOTTOM w0.102: v3(215.9,28.03) 215.8,27.93 U1.125
SUSCLK: length 4.8
  BOTTOM w0.109: R4753.2 v2(265.02,39.73) 265.02,39.71 265.36,39.37 266.34,39.37 266.54,39.16 R4750.1 R4710.1 R4706.1
SUSCLK32_PCH: length 8.1
  BOTTOM w0.089: U4710.BE45 259.37,43.83 259.51,44.03 259.55,44.07 260.55,44.07 261.82,42.8
  BOTTOM w0.109: 261.82,42.8 264.46,42.8 v2(265.02,42.24) R4753.1
SUSWARN#: length 65.2
  TOP w0.102: v1(261.87,47.68) 262.12,47.93 v2(262.12,48.37) 262.56,48.8 R4912.1
  L3 w0.102: v1(208.72,38.71) 208.77,38.66 213.92,38.66 214.1,38.48 221.37,38.48 222.42,39.53 236.39,39.53 237.87,41.01 240.02,41.01 241.25,42.24 244.21,42.24 244.36,42.4 246.5,42.4 248.52,44.42 249.95,44.42 251.79,46.26 256.44,46.26 256.66,46.49 260.78,46.49 261.87,47.58 v1(261.87,47.68)
  BOTTOM w0.089: v1(261.87,47.68) 261.59,47.96 260.67,47.96 260.49,47.78 260.12,47.78 259.69,47.35 259,47.35 258.88,47.22 258.25,47.22 U4710.BC37
  BOTTOM w0.102: v1(208.72,38.71) 208.72,39.52 209.09,39.88 U1.87
SYS_PWROK: length 65.8
  L5 w0.102: v1(256.54,66.83) 256.54,66.03 253.91,63.4 250.84,63.4 250.02,62.59 248.61,62.59 248.05,62.03 248.05,59.67 246.35,57.97 245.9,57.97 238.49,50.55 238.49,47.11 236.46,45.08 229.35,45.08 227.1,42.83 219.86,42.83 218.67,44.02 215,44.02 214.7,43.72 v1(214.07,43.72)
  BOTTOM w0.089: U4710.AU3 255.38,64.22 255.38,64.59 255.93,65.14 255.93,65.44 256.06,65.58 256.06,66.15
  BOTTOM w0.102: 256.06,66.15 256.07,66.16 256.07,66.36 v1(256.54,66.83) ; R301.1 214.7,43.74 214.17,43.74 214.14,43.72 v1(214.07,43.72) 214.06,43.71 214.06,43.38 213.31,42.63 212.06,42.63 v2(211.73,42.3) 211.38,41.95 211.38,41.54 211.39,41.53 211.39,41.28 211.49,41.18 U1.93
SYS_RESET#: length 3.8
  TOP w0.089: v1(255.67,65.74) 255.29,66.12 254.67,66.12 v2(254.47,65.92) 254.48,65.91 254.48,65.21 R4713.1
  BOTTOM w0.089: v1(255.67,65.74) 255.5,65.56 255.5,64.98 255.12,64.6 U4710.AU2
TB_STAT#: length 2.4
  BOTTOM w0.254: TP60002.1 59.25,48.11 59.25,46.77 59,46.51 U60000.16
THERM_SCI#: length 247.6
  TOP w0.102: v1(145.31,118.98) 145.69,118.6 145.69,113.06 142.74,110.11 142.74,106.28 v2(142.21,105.75) 139.62,103.15 139.62,94.92 142.74,91.8 142.74,89.14 148.79,83.1 149.02,83.1 152.76,79.36 152.76,75.71 156.66,71.81 162.12,71.81 163.87,73.55 215.09,73.55 222.13,66.51 230.69,66.51 235.22,71.04 236.36,71.04 237.54,72.22 242.4,72.22 243.42,73.23 243.42,74.28 243.58,74.45 269.47,74.45 277.39,66.53 279.83,66.53 281.43,64.93 281.43,60.48 278.74,57.79 278.74,51.18 279.63,50.3 v1(279.63,42.04)
  L8 w0.102: v1(252.34,42.98) 253.2,42.12 258.04,42.12 258.52,41.63 259.6,41.63 260.03,42.07 263.17,42.07 263.65,42.55 279.12,42.55 v1(279.63,42.04)
  BOTTOM w0.089: v1(252.34,42.98) 252.34,42.98 252.25,42.88 U4710.AL47
  BOTTOM w0.102: v1(145.31,118.98) 144.85,118.52 144.61,118.52 R4454.2
THERMTRIP#: length 134
  L5 w0.076: v1(186,42.47) 184.45,44.02 166.93,44.02 166.8,43.89 154.96,43.89 v1(153.69,45.16)
  L8 w0.076: v1(158.94,85.12) 156.14,82.32 156.14,76.39 157.34,75.2 157.34,60.8 156.47,59.94 156.47,47.95 v1(153.69,45.16)
  BOTTOM w0.109: v1(186,42.47) 186.99,41.48 186.99,36.83 188.73,35.09 Q7003.S ; R4455.1 144.44,110.6 R4453.2 142.8,110.6 140,107.8 140,101.59 138.85,100.44 138.85,96.92 140.94,94.84 145.08,94.84 145.64,95.4 145.66,95.4 149.2,95.4 151.81,92.78 151.81,85.85 154.23,83.43 157.54,83.43 158.94,84.83 v1(158.94,85.12)
THERMTRIP_BASE: length 2.1
  BOTTOM w0.102: v2(248.62,76.74) R4743.2 248.62,75.33 249.03,74.92 Q4758.1
TOUCH_INT#: length 244.8
  TOP w0.102: v1(253.77,55.81) 254,55.58 254.58,55.58 255.15,56.15 R4819.2
  L8 w0.102: v1(60.55,52.3) 62.91,49.94 98.88,49.94 105.38,43.44 110.52,43.44 114.28,39.68 120.99,39.68 128.37,32.3 134.04,32.3 134.59,31.75 151.27,31.75 151.7,32.19 167.53,32.19 168.38,33.03 174.98,33.03 183.06,41.11 199.69,41.11 202.41,43.83 208.14,43.83 208.14,43.83 208.31,43.83 209.77,42.37 216.18,42.37 216.43,42.62 217.67,42.62 218.18,42.12 228.88,42.12 230.76,44 232.63,44 233.92,45.29 236.9,45.29 237.3,45.29 238.69,46.68 238.69,46.73 238.69,50.38 239.21,50.9 239.21,51.56 242.82,55.17 243.19,55.17 244.54,56.52 247.73,56.52 248.52,57.31 248.86,57.31 249.09,57.07 250.56,57.07 251.83,55.81 v1(253.77,55.81)
  BOTTOM w0.089: U4710.AP21 253.92,55.65 v1(253.77,55.81)
  BOTTOM w0.102: v1(60.55,52.3) 50.19,52.3 46.9,55.59 v2(39.42,55.59) Q3000.3
TOUCH_INT#_L: length 12.9
  L8 w0.102: v3(32.46,64.87) 32.46,62.94 34.41,60.99 35.3,60.99 36.19,60.1 36.19,59.67 v1(35.58,59.06)
  BOTTOM w0.102: CN5.27 32.45,64.88 32.46,64.87 v3(32.46,64.87) ; R3002.2 37.7,57.49 Q3000.2 37.25,57.6 35.79,59.06 v1(35.58,59.06)
TOUCH_PAD_DISABLE: length 88.9
  L3 w0.102: v1(200.91,31.22) 192.28,31.22 191.95,30.89 178.97,30.89 178.03,29.95 177.11,29.95 174.6,27.44 161.85,27.44 160.76,27.44 158.32,29.87 154.39,29.87 154.3,29.79 137.75,29.79 136.98,29.01 126.59,29.01 v1(125.27,30.33)
  BOTTOM w0.102: U1.31 200.69,26.8 200.96,27.08 200.96,28.27 200.66,28.58 200.66,29.8 201.09,30.23 201.09,31.04 v1(200.91,31.22) ; D281.2 124.52,31.08 v1(125.27,30.33) 125.85,30.33 126.2,29.98 CN280.8
TOUCH_PWR_EN: length 256.6
  TOP w0.089: R149.2 255.07,54.71 255.42,54.36 v1(255.45,54.36)
  L8 w0.102: v1(255.45,54.36) 255.01,54.8 252.55,54.8 251.04,56.3 244.61,56.3 243.28,54.97 242.91,54.97 239.42,51.48 239.42,50.81 238.9,50.29 238.9,46.65 238.9,46.6 237.39,45.09 236.82,45.09 234.01,45.09 232.71,43.79 230.86,43.79 228.98,41.91 218.1,41.91 217.59,42.42 216.56,42.42 216.3,42.17 209.68,42.17 208.22,43.63 202.49,43.63 199.77,40.91 191.88,40.91 191.11,40.14 182.37,40.14 175.06,32.83 168.92,32.83 168.07,31.98 151.79,31.98 151.35,31.55 134.5,31.55 133.95,32.1 128.28,32.1 120.91,39.48 114.19,39.48 110.44,43.23 105.27,43.23 98.77,49.74 62.38,49.74 58.67,53.45 48.99,53.45 46.39,56.05 44.17,56.05 38.93,61.29 34.64,61.29 32.76,63.17 32.76,64.59 33.13,64.96 v3(33.95,64.96)
  BOTTOM w0.089: U4710.AU24 v1(255.45,54.36)
  BOTTOM w0.102: v3(33.95,64.96) CN5.24
TOUCH_RST#: length 271.6
  L8 w0.102: v1(33.3,63.73) 33.3,63.28 34.28,62.3 36.26,62.3 36.84,62.88 49.52,62.88 50.28,62.12 50.84,62.12 51.84,62.12 63.81,50.14 99.27,50.14 105.77,43.64 110.6,43.64 114.36,39.88 121.08,39.88 128.45,32.51 134.12,32.51 134.67,31.96 151.19,31.96 151.81,32.58 164.2,32.58 164.85,33.24 174.9,33.24 182.98,41.32 199.61,41.32 202.32,44.03 208.05,44.03 212.45,44.03 213.2,43.29 218,43.29 218.92,42.37 228.85,42.37 230.68,44.2 232.54,44.2 233.84,45.5 236.99,45.5 237.17,45.49 238.49,46.82 238.49,50.46 239.01,50.98 239.01,51.65 242.74,55.38 243.11,55.38 244.45,56.72 247.64,56.72 248.43,57.51 249.13,57.51 249.27,57.37 250.55,57.37 251.53,56.39 254.52,56.39 255.85,55.06 255.85,53.9 254.02,52.07 254.02,50.54 254.85,49.71 256.58,49.71 257.31,48.98 258.17,48.98 259.62,47.54 v3(261.16,47.54)
  BOTTOM w0.089: v3(261.16,47.54) 261.12,47.58 260.26,47.58 259.85,47.17 259.08,47.17 258.88,46.97 U4710.BD38
  BOTTOM w0.102: v1(33.3,63.73) 32.74,63.73 31.95,64.52 CN5.28
