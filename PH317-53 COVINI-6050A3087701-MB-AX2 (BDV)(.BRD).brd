# Allegro board PH317-53 COVINI-6050A3087701-MB-AX2 (BDV)(.BRD).brd (continued)
## Placement (name value [footprint] x y rotation side) (continued)
C67210  10UF_25V_5  [CSC_200X125X140_2]  218.63 67.12 0 bottom
C67211  10UF_25V_5  [CSC_200X125X140_2]  218.64 65.41 0 bottom
C67212  0.1uF_25V_3  [RANGER11-6010A0057701-003]  220.75 65.25 90 bottom
C67215  0.1uF_16V_2  [CSC_100X050X040_2]  236.09 79.43 0 bottom
C67216  CSC0402  [CSC_100X050X040_2]  215.21 78.95 0 bottom
C67218  1uF_25V_3  [CSC_160X080X080_2]  245.79 76.43 270 bottom
C67219  CSC0402_DY  [CSC_100X050X040_2]  239.93 80.52 90 bottom
C67220  10UF_25V_5  [CSC_200X125X140_2]  230.71 67.11 180 bottom
C67221  10UF_25V_5  [CSC_200X125X140_2]  230.71 65.41 180 bottom
C67222  0.1uF_25V_3  [CSC_160X080X080_2]  228.64 65.23 90 bottom
C67225  0.1uF_16V_2  [CSC_100X050X040_2]  235.56 75.49 0 bottom
C67226  CSC0402  [CSC_100X050X040_2]  227.78 74.12 180 top
C67230  CSC0402  [CSC_100X050X040_2]  239.87 73.56 180 bottom
C67231  CSC0402  [CSC_100X050X040_2]  238.1 71.66 270 bottom
C67232  CSC0402  [CSC_100X050X040_2]  242.52 75.52 180 bottom
C67233  CSC0402  [CSC_100X050X040_2]  237.21 71.66 270 bottom
C67234  0.1uF_16V_2  [CSC_100X050X040_2]  244.73 77.68 90 bottom
C67235  4700pF_50V_2  [CSC_100X050X040_2]  244.65 80.17 270 bottom
C67236  CSC0402  [CSC_100X050X040_2]  243.48 78.03 0 bottom
C67298  15uF_25V  [CS_350X280X200_2]  222.97 65.5 90 bottom
C67299  15uF_25V  [CS_350X280X200_2]  226.42 65.5 90 bottom
C67400  22UF_6.3V_3  [CSC_160X080X090_2]  207.63 179.06 0 top
C67401  22UF_6.3V_3  [CSC_160X080X090_2]  207.63 177.82 0 top
C67402  22UF_6.3V_3  [CSC_160X080X090_2]  207.63 176.6 0 top
C67403  22UF_6.3V_3  [CSC_160X080X090_2]  204.14 174.22 180 top
C67404  CSC0603  [CSC_160X080X080_2]  204.13 173 180 top
C67409  4.7UF_6.3V_2  [CSC_100X050X065_2]  199.55 174.91 90 top
C67410  10UF_25V_5  [CSC_200X125X140_2]  193.18 176.36 270 top
C67411  10UF_25V_5  [CSC_200X125X140_2]  191.51 176.37 270 top
C67412  0.1uF_25V_2  [CSC_100X050X040_2]  194.49 176.59 270 top
C67415  0.1uF_25V_2  [CSC_100X050X040_2]  199.3 179.46 0 top
C67416  CSC0402  [CSC_100X050X040_2]  201.83 173.89 90 top
C67420  220pF_50V_2  [CSC_100X050X040_2]  197.49 171.37 90 top
C67430  1uF_10V_2  [CSC_100X050X040_2]  199.16 172.14 270 top
C67600  22UF_6.3V_3  [CSC_160X080X090_2]  145.76 164.77 180 bottom
C67601  CSC0402_DY  [CSC_100X050X040_2]  153.8 172.49 270 bottom
C67609  0.1uF_16V_2  [CSC_100X050X040_2]  154.7 170.45 90 bottom
C67610  10uF_6.3V_3  [CSC_160X080X095_2]  153.51 167.7 180 bottom
C564001  0.1uF_16V_2  [CSC_100X050X040_2]  283.92 75.44 90 top
CN1  ACES_50505_00401_001_4P  [FPC_ACES_4_100_R_160]  265.84 94.78 90 top
CN2  ACES_50505_00401_001_4P  [FPC_ACES_4_100_R_160]  290.95 152.16 90 top
CN5  ACES_51398_0407T_001_40P  [WTB_ACES_40_050_SMD_V_F_140_2]  35.7 68 180 bottom
CN8  ACES_50290_00801_001_8P  [WTB_ACES_8_150_SMD_R_M_445]  5.6 75.3 90 bottom
CN250  ENTERY_6905K_E28N_00R_28P  [FPC_ENTRY_28_100_R_200]  91.75 31 180 bottom
CN251  ACES_50505_00401_001_4P  [FPC_ACES_4_100_R_160]  153.11 27.25 180 bottom
CN252  ACES_51619_01401_001_14P  [FPC_ACES_14_050_R_200_4]  147.61 28.3 180 bottom
CN253  ACES_50505_00401_001_4P  [FPC_ACES_4_100_R_160]  72.2 161.5 90 bottom
CN254  ACES_50505_00401_001_4P  [FPC_ACES_4_100_R_160]  57.1 25.4 180 bottom
CN280  ENTERY_6916K_Q08N_08L_8P  [FPC_ENTRY_8_100_R_205]  129.7 26.9 180 bottom
CN301  ACES_50696_0100M_001_10P  [FPC_ACES_10_050_R_105]  211.07 33.07 180 top
CN600  ACES_50224_00401_001_4P  [WTB_ACES_4_100_SMD_R_M_295]  295.55 127.96 0 bottom
CN601  ACES_51540_05001_001_50P  [FPC_ACES_50_050_R_180]  274.85 105.46 90 bottom
CN602  ACES_50224_00401_001_4P  [WTB_ACES_4_100_SMD_R_M_295]  283.85 93.71 180 bottom
CN603  ACES_51540_05001_001_50P  [FPC_ACES_50_050_R_180]  30.5 48.1 90 bottom
CN604  ACES_50224_00401_001_4P  [WTB_ACES_4_100_SMD_R_M_295]  16.7 70.1 180 bottom
CN1300  LOTES_APCI0062_P001A_NGFF_E_KEY_75P  [COVINI-6026B0276201-002]  281.2 25.36 180 bottom
CN1700  ACES_51540_01041_Q01_10P  [FPC_ACES_10_050_R_180_1]  260.1 26.6 180 bottom
CN1900  LOTUS_APCI0107_P001H_75P  [COVINI-6026B0436901-001]  173.7 31.8 270 bottom
CN1901  LOTUS_APCI0107_P001H_75P  [COVINI-6026B0436901-001]  70.9 44.3 90 bottom
CN2400  TCONN_18_35690_1A63_0_9P  [USB3_TCONN_9_DIP_RS_S_040_326_1]  304.4 126.86 270 bottom
CN2401  TCONN_18_35690_1A63_0_9P  [USB3_TCONN_9_DIP_RS_S_040_326_1]  304.4 145.86 270 bottom
CN2500  SINGATRON_2UB3C02_101211F_24P  [USB31_SIGAT_24_DIP_S_060_193_1]  311.41 14.6 270 bottom
CN2501  TCONN_18_35690_1A63_0_9P  [USB3_TCONN_9_DIP_RS_S_040_326_1]  307.95 32.7 270 bottom
CN4100  ARGOSY_D4AR0_26010_1P52_260P  [COVINI-6026B0375701-001]  114.04 78.89 180 bottom
CN4125  ARGOSY_D4AS0_26001_1P52_260P  [COVINI-6026B0363901-001]  119.03 65.73 0 bottom
CN4300  ACES_50279_00401_Q01_4P  [WTB_ACES_4_125_SMD_R_M_215]  56.7 63.3 0 bottom
CN4301  ACES_50279_00401_Q01_4P  [WTB_ACES_4_125_SMD_R_M_215]  275 76.2 90 bottom
CN4700  ACES_50224_0020N_001_2P  [WTB_ACES_2_100_SMD_R_M_295_4]  162.7 30.3 180 bottom
CN6050  ACES_50458_00801_Q01_8P  [WTB_ACES_8_200_SMD_R_M_226_2]  25.35 27.4 180 bottom
CN56200  TCONN_22_M0081_1003_0_20P  [COVINI-6012B0760101-001]  308.96 52.05 270 bottom
CN56600  TCONN_116B_2D023_20N_19P  [HDMI_TCONN_19_RS_051_328]  316.2 72.2 270 bottom
D1  SFI_SFI0402ML120C_LF_SMD_2P_DY  [DS_100X050X060_2_S2]  285.47 152.07 270 top
D101  EVL_12_22UYOSUBC_S530_A4_TR8_3P  [LED_EVERLI_R_D_300X200X100]  313.35 88.36 90 top
D102  12_215_BHC_ZLMRY_3C  [PUMBAA-6011A0029102-004]  313.85 93.86 270 top
D250  SFI_SFI0402ML120C_LF_SMD_2P_DY  [DS_100X050X060_2_S2]  196.34 35.94 270 bottom
D251  SFI_SFI0402ML120C_LF_SMD_2P_DY  [DS_100X050X060_2_S2]  195.45 35.94 270 bottom
D252  SFI_SFI0402ML120C_LF_SMD_2P_DY  [DS_100X050X060_2_S2]  194.56 35.94 270 bottom
D253  SFI_SFI0402ML120C_LF_SMD_2P_DY  [DS_100X050X060_2_S2]  193.67 35.94 270 bottom
D254  SFI_SFI0402ML120C_LF_SMD_2P_DY  [DS_100X050X060_2_S2]  192.78 35.94 270 bottom
D255  SFI_SFI0402ML120C_LF_SMD_2P_DY  [DS_100X050X060_2_S2]  191.89 35.94 270 bottom
D256  SFI_SFI0402ML120C_LF_SMD_2P_DY  [DS_100X050X060_2_S2]  191 35.94 270 bottom
D257  SFI_SFI0402ML120C_LF_SMD_2P_DY  [DS_100X050X060_2_S2]  195.96 40.24 180 bottom
D258  SFI_SFI0402ML120C_LF_SMD_2P_DY  [DS_100X050X060_2_S2]  105.25 35.54 90 bottom
D281  LITEON_L30ESDXVC3_2_DSOT23_3P_DY  [DSOT23_290X130X150_3_095]  125.47 32.82 180 bottom
D282  LITEON_L30ESDXVC3_2_DSOT23_3P_DY  [DSOT23_290X130X150_3_095]  128.77 32.82 180 bottom
D283  LITEON_L30ESDXVC3_2_DSOT23_3P_DY  [DSOT23_290X130X150_3_095]  132.08 32.82 180 bottom
D300  DIODE-BAT54-TAP-PHP  [DSOT23_290X130X110_3_095_P3]  194.05 25.48 0 bottom
D402  AMAZING_AZ1045_04F_R7G_10P  [DS_250X100X065_10_050]  289.67 98.89 90 top
D403  AMAZING_AZ1045_04F_R7G_10P  [DS_250X100X065_10_050]  288.62 105.49 180 top
D501  AMC_AZ2015_01H_SOD523_2P_DY  [DSSOD523_120X080X070_2_150]  29.56 54.92 90 top
D608  AMC_AZ5125_01H_SOD523_2P  [DSOD523_120X080X070_2_150_P2]  299.08 123.02 0 bottom
D609  AMC_AZ5125_01H_SOD523_2P  [DSOD523_120X080X070_2_150_P2]  296.21 121.87 180 bottom
D610  AMC_AZ5125_01H_SOD523_2P  [DSOD523_120X080X070_2_150_P2]  293.6 122.34 180 bottom
D611  AMC_AZ5125_01H_SOD523_2P  [DSOD523_120X080X070_2_150_P2]  290.93 123.12 180 bottom
D2400  AMC_AZC099_04S_R7G_SOT23_6P  [DSSOT23_290X160X145_6_095]  297.56 130.33 0 top
D2401  AMAZING_AZ1045_04F_R7G_10P  [DS_250X100X065_10_050]  289.68 127.18 270 bottom
D2402  AMC_AZC099_04S_R7G_SOT23_6P  [DSSOT23_290X160X145_6_095]  292.99 130.2 180 top
D2403  AMAZING_AZ1045_04F_R7G_10P  [DS_250X100X065_10_050]  300.96 135.49 180 top
D3000  1N4148WS_DY  [DSOD323_185X125X095_2_231]  39.9 60.48 90 bottom
D4700  BAT54C_30V_0_6A  [DS_292X130X110_3_190]  241.25 30.84 180 bottom
D4711  DIODE-BAT54-TAP-PHP  [DSOT23_290X130X110_3_095_P3]  156.26 38.48 180 bottom
D4801  DIODE-BAT54-TAP-PHP  [DSOT23_290X130X110_3_095_P3]  267.33 45.7 90 bottom
D6035  SEM_SM24_SOT23_3P_DY  [DSSOT23_290X130X112_3_095]  12.7 75.54 90 bottom
D6098  BAV99  [DSSOT23_290X130X110_3_095-2]  48.53 48.41 180 bottom
D7000  BAT54_30V_0.2A_DY  [TSOT23_290X130X110_3_096_P1]  66.03 72.06 270 bottom
D7001  DIODE-BAT54-TAP-PHP  [DSOT23_290X130X110_3_095_P3]  95.96 54.41 270 bottom
D7002  DIODE-BAT54-TAP-PHP  [DSOT23_290X130X110_3_095_P3]  58.29 35.23 90 bottom
D7004  DIODE-BAT54-TAP-PHP  [DSOT23_290X130X110_3_095_P3]  68.96 97.46 270 bottom
D7005  DIODE-BAT54-TAP-PHP  [DSOT23_290X130X110_3_095_P3]  189.38 25.68 90 bottom
D7500  AMAZING_AZ1065_06F_10P  [DESD_410X200X055_10_080_T1]  301.95 32.06 270 top
D7503  AMAZING_AZ1045_04F_R7G_10P  [DS_250X100X065_10_050]  308 14.51 90 bottom
D7504  AMAZING_AZ1045_04F_R7G_10P  [DS_250X100X065_10_050]  305.3 17.2 0 bottom
D7505  AMAZING_AZ1045_04F_R7G_10P  [DS_250X100X065_10_050]  304.59 18.24 0 top
D7521  AMAZING_AZ5525_01F_R7G_DFN1006P2X_2P_DY  [DESD_100X060X050_2_085]  300.3 154.78 90 bottom
D7522  AMAZING_AZ5525_01F_R7G_DFN1006P2X_2P_DY  [DESD_100X060X050_2_085]  299.77 152.76 180 bottom
D7523  AMAZING_AZ5525_01F_R7G_DFN1006P2X_2P_DY  [DESD_100X060X050_2_085]  300.8 165.38 270 bottom
D7533  AMAZING_AZ5525_01F_R7G_DFN1006P2X_2P_DY  [DESD_100X060X050_2_085]  300.3 156.53 270 bottom
D7534  AMAZING_AZ5525_01F_R7G_DFN1006P2X_2P_DY  [DESD_100X060X050_2_085]  300.8 163.6 270 bottom
D7600  AMC_AZ5125_01H_SOD523_2P_DY  [DSOD523_120X080X070_2_150_P2]  23.69 30.1 0 top
D7601  AMC_AZ5125_01H_SOD523_2P  [DSOD523_120X080X070_2_150_P2]  29.74 32.39 180 top
D7602  AMC_AZ5125_01H_SOD523_2P  [DSOD523_120X080X070_2_150_P2]  26.31 30.1 0 top
D51510  DIODE-BAT54-TAP-PHP  [DSOT23_290X130X110_3_095_P3]  142.69 97.44 180 bottom
D53552  DIODE-BAT54-TAP-PHP  [DSOT23_290X130X110_3_095_P3]  113.41 53.04 270 bottom
D53571  DIODE-BAT54-TAP-PHP  [DSOT23_290X130X110_3_095_P3]  125.04 54.49 90 bottom
D53581  DIODE-BAT54-TAP-PHP_DY  [DSOT23_290X130X110_3_095_P3]  115.52 57.71 180 bottom
D56220  AMAZING_AZ1045_04F_R7G_10P  [DS_250X100X065_10_050]  303.3 55.53 270 bottom
D56222  SFI_SFI0402ML120C_LF_SMD_2P  [DS_100X050X060_2_S2]  306.22 46.21 90 bottom
D56225  AMAZING_AZ1045_04F_R7G_10P  [DS_250X100X065_10_050]  303.22 52.07 270 bottom
D56230  AMAZING_AZ1045_04F_R7G_10P  [DS_250X100X065_10_050]  302.51 49.99 270 top
D56610  SFI_SFI0402ML120C_LF_SMD_2P  [DS_100X050X060_2_S2]  304.44 65.05 90 bottom
D56650  AMAZING_AZ1045_04F_R7G_10P  [DS_250X100X065_10_050]  303.88 73.61 270 top
D56651  AMAZING_AZ1045_04F_R7G_10P  [DS_250X100X065_10_050]  303.91 70.26 270 top
D56652  AMAZING_AZ1045_04F_R7G_10P  [DS_250X100X065_10_050]  304.59 66.86 90 top
D60000  BAT54C_30V_0_6A  [DS_292X130X110_3_190]  53.85 38.11 180 bottom
D60001  BAT54C_30V_0_6A_DY  [DS_292X130X110_3_190]  57.21 38.53 270 bottom
D60002  BAT54C_30V_0_6A  [DS_292X130X110_3_190]  37.11 41.73 180 bottom
FIX1  -  [FIX_MASK]  66.98 170.89 0 top
FIX2  -  [FIX_MASK]  3.27 74.1 0 top
FIX3  -  [FIX_MASK]  18.64 28.22 0 top
FIX4  -  [FIX_MASK]  264.89 80.22 0 top
FIX5  -  [FIX_MASK]  67 170.89 180 bottom
FIX6  -  [FIX_MASK]  214.43 171.42 180 bottom
FIX7  -  [FIX_MASK]  13.79 35.06 180 bottom
FIX8  -  [FIX_MASK]  36.14 80.67 180 bottom
FIX9  -  [FIX_MASK]  285.87 148.34 0 top
FIX10  -  [FIX_MASK]  270.13 142.12 0 top
FIX11  -  [FIX_MASK]  257.04 95.5 0 top
FIX12  -  [FIX_MASK]  263.49 114.3 0 top
FIX13  -  [FIX_MASK]  300.35 87.33 0 top
FIX14  -  [FIX_MASK]  300.91 159.97 180 bottom
FIX15  -  [FIX_MASK]  300.96 159.92 0 top
FIX16  -  [FIX_MASK]  275.41 127.59 180 bottom
FUSE3000  1.5A_24V  [ASHMORE-6036B0093201-003]  44.98 82.83 180 bottom
FUSE3001  LITTELFUSE_0805L110ULYR  [FUSE_210X135X075_2_220]  27 63.5 0 bottom
JACK400  SINGATRON_2RJ3104_038211F_8P  [RJ45_SIGAT_8_SS_N_470]  306.65 105.96 270 bottom
JACK600  SINGA_2SJ3095_123111F_7P  [AUDIO_SIGAT_6_R_050_200_1]  303.9 160.61 270 bottom
L1  BLM15AG121SN1D_500mA  [LS_100X050X055_2]  216.68 21.97 90 bottom
L400  4.7uH_20%  [LS_250X200X120_2_170]  279.22 97.23 180 top
L401  HCB1608KF_221T20  [LS_160X080X095_2]  278.03 93.42 0 top
L402  HCB1608KF_221T20  [LS_160X080X095_2]  277.03 105.54 180 top
L600  BLM15AG121SN1D_500mA  [LS_100X050X055_2]  298.45 156.52 90 bottom
L601  BLM15AG121SN1D_500mA  [LS_100X050X055_2]  298.9 165.38 90 bottom
L1300  MCF12102G900-T_DY  [LS_125X100X065_4_055]  268.93 27.03 270 bottom
L2400  MCF12102G900-T  [CAESAR-6014B0247601-001]  295.27 129.44 90 top
L2401  WCM_2012SHS_850T  [LS_200X120X140_4_080]  286.15 123.35 90 bottom
L2402  WCM_2012SHS_850T  [LS_200X120X140_4_080]  284.4 123.32 90 bottom
L2403  MCF12102G900-T  [CAESAR-6014B0247601-001]  289.28 126.67 0 top
L2404  WCM_2012SHS_850T  [LS_200X120X140_4_080]  300.12 133 90 top
L2405  WCM_2012SHS_850T  [LS_200X120X140_4_080]  301.85 133 90 top
L2500  MCF12102G900-T  [LS_125X100X065_4_055]  305.75 13.74 0 bottom
L2501  MCF12102G900-T  [LS_125X100X065_4_055]  299.06 31.03 0 top
L3001  LS_Short_0504  [LS_SHORT_0504]  41.4 60.94 90 bottom
L3002  LS_Short_0504  [LS_SHORT_0504]  35.05 61.83 90 bottom
L4700  MCF12102G900-T  [LS_125X100X065_4_055]  245.96 68.79 90 bottom
L6035  120OHM_25%_6A  [LS_200X125X110_2]  13.2 80.57 180 bottom
L6036  120OHM_25%_6A  [LS_200X125X110_2]  13.2 78.92 180 bottom
L50100  FBMA_11_160808_300A25T  [EMIS_BLM11]  190.89 158.87 90 top
L51300  FBMA_11_160808_300A25T  [EMIS_BLM11]  190.89 156.55 270 top
L52110  FBMA_11_160808_300A25T  [EMIS_BLM11]  163.52 90.83 90 top
L56220  WCM_2012SHS_850T  [LS_200X120X140_4_080]  300.58 56.42 0 bottom
L56221  WCM_2012SHS_850T  [LS_200X120X140_4_080]  300.58 54.69 0 bottom
L56225  WCM_2012SHS_850T  [LS_200X120X140_4_080]  300.58 52.96 0 bottom
L56226  WCM_2012SHS_850T  [LS_200X120X140_4_080]  300.58 51.24 0 bottom
L56400  BLM15PD600SN1D  [LS_100X050X055_2]  280.74 70.11 0 top
L56401  BLM15PD600SN1D  [LS_100X050X055_2]  282.67 75.11 0 top
L56402  BLM15PD600SN1D  [LS_100X050X055_2]  280.74 69.22 0 top
L56405  BLM15PD600SN1D  [LS_100X050X055_2]  299.79 71.86 270 bottom
L56407  BLM15PD600SN1D  [LS_100X050X055_2]  298.52 71.5 0 bottom
L56408  BLM15PD600SN1D  [LS_100X050X055_2]  292.81 67.72 180 top
L60000  PCMC063T_3R3MN  [LS_700X660X300_2_555]  42.37 26.83 180 bottom
L60100  CYNTEC_PCMB062D_1R5MS  [LS_660X660X240_2_555]  199.45 21.88 0 top
L60200  PCMC063T_2R2MN  [LS_700X660X300_2_555]  251.4 21.92 0 top
L60250  CYNTEC_PCMB051H_3R3MS  [LS_540X520X180_4_P2]  56.45 80.84 180 bottom
L60300  CYN_PCMC063T_R68MN_4P  [LS_660X660X300_4_P3]  71.43 76.33 270 bottom
L60400  TAI_TECH_HPC4018B_2R2M  [LS_400X400X180_2_280]  77.82 64.34 90 bottom
L60500  CYN_PCMC063T_R68MN_4P  [LS_660X660X300_4_P3]  74.26 105.78 0 bottom
L60600  TAI_TECH_HPC4018B_2R2M  [LS_400X400X180_2_280]  219.61 23.02 0 top
L60900  CYN_PCMC063T_R68MN_4P  [LS_660X660X300_4_P3]  226.16 57.22 0 bottom
L66010  MAGLAYERS_MMD_10CZ_R15MGX2I  [SNAPE-6014B0296001-003]  99.64 160.48 270 bottom
L66020  MAGLAYERS_MMD_10CZ_R15MGX2I  [SNAPE-6014B0296001-003]  110 160.46 270 bottom
L66030  MAGLAYERS_MMD_10CZ_R15MGX2I  [SNAPE-6014B0296001-003]  120.42 160.46 270 bottom
L66040  MAGLAYERS_MMD_10CZ_R15MGX2I  [SNAPE-6014B0296001-003]  130.81 160.46 270 bottom
L66310  TRIO_EM_15BM66V03  [LS_1120X720X400_4]  70.08 125.91 270 bottom
L66610  PCME064T_R42MS1R557  [LS_660X660X400_4_P2]  139.72 164.21 270 bottom
L67010  TRIO_EM_22BM66V04  [LS_1100X720X390_4]  162.06 64.89 90 bottom
L67020  TRIO_EM_22BM66V04  [LS_1100X720X390_4]  172.04 64.9 90 bottom
L67030  TRIO_EM_22BM66V04  [LS_1100X720X390_4]  182.02 64.91 90 bottom
L67040  TRIO_EM_22BM66V04  [LS_1100X720X390_4]  192.03 64.92 90 bottom
L67050  TRIO_EM_22BM66V04  [LS_1100X720X390_4]  202.03 64.92 90 bottom
L67060  TRIO_EM_22BM66V04  [LS_1100X720X390_4]  212.04 64.93 90 bottom
L67210  PCME063T-R24MS1R195  [LS_660X660X300_4_P4]  219.53 78.01 90 bottom
L67220  PCME063T-R24MS1R195  [LS_660X660X300_4_P4]  231.24 78.03 90 bottom
L67400  CYNTEC_PCMB053T_2R2MS  [LS_485X470X300_2_500]  202.76 177.38 0 top
L67600  NRS5020T1R0N  [LS_500X500X200_2_340_P2]  149.64 165.63 270 bottom
NOREF  -  []  305.85 175.11 90 top
NOREF#2  -  []  8.31 -46.18 90 top
NOREF#3  -  []  263.89 84.28 90 top
NOREF#4  -  []  141.56 20.7 0 top
NOREF#5  -  []  32.53 35.46 0 top
NOREF#6  -  []  277.24 120.73 0 top
NOREF#7  -  []  50.26 -46.18 90 top
NOREF#8  -  [unnamed#2]  -3.65 -144.9 0 top
NOREF#9  -  []  111.7 198.39 0 top
NOREF#10  -  [unnamed#3]  11.55 -144.45 180 top
NOREF#11  -  [unnamed#2]  279.55 127.36 0 top
NOREF#12  -  []  280.69 115.42 0 top
NOREF#13  -  []  276.92 156.66 90 top
NOREF#14  -  []  220.34 10.7 0 top
NOREF#15  -  []  300.1 -15.4 0 top
NOREF#16  -  []  40.37 -67.97 0 top
NOREF#17  -  []  218.22 175.13 180 top
NOREF#18  -  [unnamed#2]  313.81 183 0 top
NOREF#19  -  [unnamed#2]  313.81 -144.9 0 top
NOREF#20  -  []  246.98 -137.03 0 top
NOREF#21  -  []  10.06 49.5 0 top
NOREF#22  -  []  37.23 -118.56 90 top
NOREF#23  -  []  91.94 -89.9 0 top
NOREF#24  -  []  50.17 -75.03 0 top
NOREF#25  -  [unnamed#2]  264.89 104.28 0 top
NOREF#26  -  []  174.1 17.4 0 top
NOREF#27  -  []  305.85 84.28 90 top
NOREF#28  -  []  259.99 109.13 0 top
NOREF#29  -  []  79.68 182 90 top
NOREF#30  -  []  268.56 17.4 0 top
NOREF#31  -  []  218.22 128 180 top
NOREF#32  -  []  25.41 -98.06 90 top
NOREF#33  -  []  7.11 -144.5 180 top
NOREF#34  -  []  19.4 39.42 0 top
NOREF#35  -  []  205.72 182 90 top
NOREF#36  -  []  171.46 -143.9 90 top
NOREF#37  -  []  63.18 171.13 0 top
NOREF#38  -  []  48.06 -115.59 0 top
NOREF#39  -  []  15.41 -109.4 0 top
NOREF#40  -  []  142.7 182 90 top
NOREF#41  -  [unnamed#2]  74.18 177 0 top
NOREF#42  -  []  234.48 -143.9 90 top
NOREF#43  -  []  19.35 84.28 90 top
NOREF#44  -  []  274.72 174.25 90 top
NOREF#45  -  []  79.67 -49.98 60.3 top
NOREF#46  -  []  54.91 38.54 0 top
NOREF#47  -  []  312.45 -1 90 top
NOREF#48  -  []  304.39 182.76 0 top
NOREF#49  -  [unnamed#2]  283.25 142.16 0 top
NOREF#50  -  []  294.81 -46.18 90 top
NOREF#51  -  []  288.75 136.16 90 top
NOREF#52  -  [unnamed#2]  273.6 153.16 0 top
NOREF#53  -  []  108.44 -143.9 90 top
NOREF#54  -  []  91.94 -137.03 0 top
NOREF#55  -  []  1.7 39.1 90 top
NOREF#56  -  []  262.1 149.69 0 top
NOREF#57  -  []  294.75 143.5 0 top
NOREF#58  -  []  8.31 -137.01 90 top
NOREF#59  -  []  230.49 88.08 240.3 top
NOREF#60  -  [unnamed#2]  304.15 89.56 0 top
NOREF#61  -  []  246.98 -89.9 0 top
NOREF#62  -  []  63.18 124 0 top
NOREF#63  -  [unnamed#3]  300.35 182.76 0 top
NOREF#64  -  []  269.79 102.07 0 top
NOREF#65  -  []  47.1 20.7 0 top
NOREF#66  -  [unnamed#2]  306.81 4 0 top
NOREF#67  -  []  265.26 100.31 180 bottom
NOREF#68  -  []  261.27 96.72 180 bottom
NOREF#69  -  []  287.37 151.95 180 bottom
NOREF#70  -  []  280.74 152.86 180 bottom
PAD1  -  [POWERPAD_2_0610]  276.76 60.13 270 bottom
PAD282  POWERPAD1x1m  [POWERPAD1X1M]  132.97 35.74 270 bottom
PAD500  POWERPAD1x1m  [POWERPAD1X1M]  26.29 48.95 180 top
PAD501  POWERPAD1x1m  [POWERPAD1X1M]  24.25 46.74 90 top
PAD502  POWERPAD1x1m  [POWERPAD1X1M]  13.66 46.72 90 top
PAD1700  POWERPAD1x1m  [POWERPAD1X1M]  267.89 31.22 270 bottom
PAD1901  POWERPAD1x1m  [POWERPAD1X1M]  64.39 52.25 180 bottom
PAD1902  POWERPAD1x1m  [POWERPAD1X1M]  183.38 37.16 0 bottom
PAD3000  POWERPAD1x1m  [POWERPAD1X1M]  20.82 77.78 270 bottom
PAD3001  POWERPAD1x1m  [POWERPAD1X1M]  47.49 80.04 90 bottom
PAD3500  POWERPAD1x1m  [POWERPAD1X1M]  236.12 31.25 270 bottom
PAD4300  POWERPAD1x1m  [POWERPAD1X1M]  65.96 58.73 90 bottom
PAD4301  POWERPAD1x1m  [POWERPAD1X1M]  281.23 68.48 180 bottom
PAD7002  -  [POWERPAD_2_0610]  225.96 35.08 90 bottom
PAD7003  -  [POWERPAD_2_0610]  232.15 33.89 0 bottom
PAD55300  -  [POWERPAD_2_0610]  194.71 167.1 180 top
PAD56250  -  [POWERPAD_2_0610]  300.25 36.3 0 bottom
PAD60000  POWERPAD1x1m  [POWERPAD1X1M]  52.4 34.4 90 bottom
PAD60100  POWERPAD_4_0610  [POWERPAD_4_0610_SHORT]  208.83 24.68 90 top
PAD60110  -  [POWERPAD_2_0610]  186.1 28.71 270 top
PAD60191  POWERPAD1x1m  [POWERPAD1X1M]  194.1 31.07 0 bottom
PAD60200  POWERPAD_4_0610  [POWERPAD_4_0610_SHORT]  259.56 21.64 0 top
PAD60210  -  [POWERPAD_2_0610]  237.11 28.6 0 top
PAD60250  POWERPAD_4_0610  [POWERPAD_4_0610_SHORT]  50.46 76.69 270 bottom
PAD60260  -  [POWERPAD_2_0610]  64.79 85.35 270 bottom
PAD60300  POWERPAD_4_0610  [POWERPAD_4_0610_SHORT]  75.69 72.44 0 bottom
PAD60310  -  [POWERPAD_2_0610]  67.75 87.26 0 bottom
PAD60350  POWERPAD1x1m  [POWERPAD1X1M]  75.89 83.11 0 bottom
PAD60400  POWERPAD1x1m  [POWERPAD1X1M]  81.01 65.31 0 bottom
PAD60410  POWERPAD1x1m  [POWERPAD1X1M]  80.16 56.44 90 bottom
PAD60500  -  [POWERPAD_2_0610]  77.03 110.52 90 bottom
PAD60510  POWERPAD1x1m  [POWERPAD1X1M]  65.52 103.26 90 bottom
PAD60600  POWERPAD1x1m  [POWERPAD1X1M]  219.99 27.82 180 top
PAD60610  POWERPAD1x1m  [POWERPAD1X1M]  214.04 26.44 270 top
PAD60900  POWERPAD_4_0610  [POWERPAD_4_0610_SHORT]  230.6 52.96 270 bottom
PAD60910  -  [POWERPAD_2_0610]  225.33 44.7 90 bottom
PAD66010  -  [POWERPAD_2_0610]  97.13 178.18 0 bottom
PAD66310  -  [POWERPAD_2_0610]  73.81 152.23 270 bottom
PAD66610  -  [POWERPAD_2_0610]  138.17 177.85 270 top
PAD67210  -  [POWERPAD_2_0610]  218.69 61.04 90 bottom
PAD67400  POWERPAD_4_0610  [POWERPAD_4_0610_SHORT]  206.75 174.19 0 top
PAD67410  -  [POWERPAD_2_0610]  188.53 178.19 0 top
PAD67600  POWERPAD1x1m  [POWERPAD1X1M]  145.68 163.13 270 bottom
PAD67610  POWERPAD1x1m  [POWERPAD1X1M]  153.97 166.04 90 bottom
Q1  MMBT4401  [TSOT23_290X130X110_3_096]  83.64 111.94 90 bottom
Q2  L2N7002WT1G  [TSSOT323_200X125X100_3_065]  86.28 109.93 0 bottom
Q4  L2N7002WT1G  [TSSOT323_200X125X100_3_065]  262.89 52.1 180 top
Q5  PANJIT_2N7002KW_3P  [SOT323_200X125X110_3_065_P3]  300.38 26.62 180 bottom
Q6  PANJIT_2N7002KW_3P  [SOT323_200X125X110_3_065_P3]  298.04 26.63 180 bottom
Q9  2N7002KDW  [SOT363_205X125X110_6_065_P3]  225.17 48.19 90 top
Q10  2N7002KDW  [SOT363_205X125X110_6_065_P3]  73.96 91.01 0 bottom
Q101  2N7002KDW  [APUS-6015B0153201-001]  281.68 104.42 0 bottom
Q102  PANJIT_2N7002KW_3P  [SOT323_200X125X110_3_065_P3]  275.18 100.08 90 top
Q250  PM513BA  [TSOT23_292X130X120_3_095]  155.17 33.1 0 bottom
Q251  PANJIT_2N7002KW_3P  [SOT323_200X125X110_3_065_P3]  157.25 31.12 90 bottom
Q281  2N7002KDW  [APUS-6015B0153201-001]  121.41 31.93 0 bottom
Q300  2N7002KDW  [APUS-6015B0153201-001]  246.2 30.76 180 bottom
Q303  2N7002KDW  [SOT363_205X125X110_6_065_P3]  282.72 59.69 180 bottom
Q400  PM513BA  [HL10BM-6015B0145801-003]  282.6 90 0 top
Q401  PANJIT_2N7002KW_3P  [SOT323_200X125X110_3_065_P3]  274.47 97.77 90 top
Q402  LMBT3904LT1G  [TSSOT23_292X130X111_3_096]  289.26 94.35 180 bottom
Q700  2N7002KDW  [SOT363_205X125X110_6_065_P3]  134.31 41.41 90 bottom
Q701  PM513BA  [TSOT23_292X130X120_3_095]  135.84 33.05 180 bottom
Q702  PANJIT_2N7002KW_3P  [SOT323_200X125X110_3_065_P3]  138.09 28.2 180 bottom
Q1300  L2N7002WT1G  [TSSOT323_200X125X100_3_065]  270.96 21.92 180 top
Q1312  L2N7002WT1G  [TSSOT323_200X125X100_3_065]  287.75 23.9 180 top
Q1313  L2N7002WT1G  [TSSOT323_200X125X100_3_065]  285.39 23.9 180 top
Q1314  LMBT3904LT1G  [TSSOT23_292X130X111_3_096]  283.21 21.19 0 top
Q1900  L2N7002WT1G  [TSSOT323_200X125X100_3_065]  90.29 54.11 270 bottom
Q3000  L2N7002WT1G  [TSSOT323_200X125X100_3_065]  36.6 56.54 0 bottom
Q4450  LMBT3904LT1G  [TSSOT23_292X130X111_3_096]  205.05 84.41 90 bottom
Q4702  2N7002KDW  [SOT363_205X125X110_6_065_P3]  266.09 54.59 90 bottom
Q4751  2N7002KDW  [SOT363_205X125X110_6_065_P3]  65 68.76 180 bottom
Q4758  LMBT3904LT1G  [TSSOT23_292X130X111_3_096]  249.98 73.84 0 bottom
Q5000  SYNNEX_SM3303PSQG  [MOSFET_300X300X100_8_065]  156.11 46.03 0 top
Q5001  L2N7002WT1G  [TSSOT323_200X125X100_3_065]  158.34 41.56 180 bottom
Q7003  PANJIT_2N7002KW_3P  [SOT323_200X125X110_3_065_P3]  188.08 33.3 0 bottom
Q7006  2N7002KDW  [SOT363_205X125X110_6_065_P3]  68.48 94.11 180 bottom
Q7007  PM514BA  [TSOT23_292X130X120_3_095_P2]  72.21 93.37 0 bottom
Q7010  LMBT3904LT1G  [TSSOT23_292X130X111_3_096]  65.6 91.37 90 bottom
Q50010  PJA138K  [SOT23_292X130X110_3_095]  141.77 122.98 270 bottom
Q51510  PJA138K  [SOT23_292X130X110_3_095]  146.01 124.09 270 bottom
Q51520  EM6K1GT2R  [TSEMT6_160X120X050_6_050_2]  130.1 45.32 0 bottom
Q51530  EM6K1GT2R  [TSEMT6_160X120X050_6_050_2]  135.96 45.14 90 bottom
Q51545  PJA138K  [SOT23_292X130X110_3_095]  151.75 102.68 180 bottom
Q51550  PJA138K  [SOT23_292X130X110_3_095]  160.65 94.62 0 bottom
Q51592  EM6K1GT2R  [TSEMT6_160X120X050_6_050_2]  154.84 88.47 270 top
Q51595  EM6K1GT2R  [TSEMT6_160X120X050_6_050_2]  127.43 43.59 0 bottom
Q51630  L2N7002WT1G  [TSSOT323_200X125X100_3_065]  298.93 54.84 270 top
Q51640  L2N7002WT1G  [TSSOT323_200X125X100_3_065]  299.08 59.64 270 top
Q51641  L2N7002WT1G  [TSSOT323_200X125X100_3_065]  299.01 57.28 90 top
Q51650  L2N7002WT1G  [TSSOT323_200X125X100_3_065]  302.84 54.84 270 top
Q51660  L2N7002WT1G  [TSSOT323_200X125X100_3_065]  302.21 59.64 90 top
Q51661  L2N7002WT1G  [TSSOT323_200X125X100_3_065]  302.54 57.26 270 top
Q51670  EM6K1GT2R  [TSEMT6_160X120X050_6_050_2]  296 64.75 180 top
Q51680  EM6K1GT2R  [TSEMT6_160X120X050_6_050_2]  293.83 64.75 180 top
Q52060  LMBT3904LT1G  [TSSOT23_292X130X111_3_096]  148.36 58.21 270 bottom
Q52070  PJA138K  [SOT23_292X130X110_3_095]  152.73 39.78 90 bottom
Q53510  EM6K1GT2R  [TSEMT6_160X120X050_6_050_2]  146.43 101.96 90 bottom
Q55210  PJA138K  [SOT23_292X130X110_3_095]  201.61 83.26 270 bottom
Q55215  PM514BA  [TSOT23_292X130X120_3_095_P2]  201.54 86.53 270 bottom
Q55220  PJA138K  [SOT23_292X130X110_3_095]  207.03 172.04 90 bottom
Q55225  PM514BA  [TSOT23_292X130X120_3_095_P2]  207.06 175.29 180 bottom
Q55230  PJA138K  [SOT23_292X130X110_3_095]  201.93 170.29 0 top
Q55235  PM514BA  [TSOT23_292X130X120_3_095_P2]  205.15 170.31 270 top
Q56260  LMBT3904LT1G  [TSSOT23_292X130X111_3_096]  270.48 69.37 180 bottom
Q56270  LMBT3904LT1G  [TSSOT23_292X130X111_3_096]  277.06 68.99 180 bottom
Q56280  LMBT3904LT1G  [TSSOT23_292X130X111_3_096]  273.75 68.99 180 bottom
Q56470  EM6K1GT2R  [TSEMT6_160X120X050_6_050_2]  289.99 64.65 180 top
Q56670  EM6K1GT2R  [TSEMT6_160X120X050_6_050_2]  301.63 66.93 0 top
Q56690  EM6K1GT2R  [TSEMT6_160X120X050_6_050_2]  302.97 70.08 270 bottom
Q60000  AOS_AON7506_TRANSISTOR  [MOSFET_300X300X090_8_065]  46.38 32.38 180 bottom
Q60001  AON7752  [MOSFET_300X300X112_8_065]  48.48 28.44 270 bottom
Q60002  2N7002KDW  [APUS-6015B0153201-001]  36.03 47.6 0 bottom
Q60003  2N7002KDW  [APUS-6015B0153201-001]  45.79 45.77 180 bottom
Q60010  AOS_AONS32314  [MOSFET_500X600X100_8_127]  41.74 50.21 180 bottom
Q60011  AOS_AONS32314  [MOSFET_500X600X100_8_127]  41.7 42.56 0 bottom
Q60012  AOS_AON6368  [MOSFET_500X600X100_8_127]  41.71 35.21 180 bottom
Q66310  ALPHA_AON6994_8P  [DFN_500X600X080_8_127_T1]  72.34 135.8 45 bottom
Q66311  ALPHA_AON6994_8P  [DFN_500X600X080_8_127_T1]  76.09 139.56 45 bottom
Q66610  AOS_AON6996  [TSMOS_530X555X100_8_127_T2]  140.26 171.68 90 bottom
Q67210  AOS_AON6992_8P  [TSMOS_530X555X100_8_127_T2]  219.3 70.8 90 bottom
Q67220  AOS_AON6992_8P  [TSMOS_530X555X100_8_127_T2]  230.04 70.8 270 bottom
R7  10K_5%_2  [RSC_100X050X040_2]  235.76 21.64 90 top
R11  33_5%_2  [RSC_100X050X040_2]  219.33 38.76 0 bottom
R12  33_5%_2  [RSC_100X050X040_2]  222.93 27.11 270 top
R13  short_0402_5  [RSC_100X050X040_2_SHORT]  218.89 39.78 0 bottom
R21  100_1%_2  [RSC_100X050X040_2]  108.84 143.03 270 top
R24  short_0402_15  [RSC_100X050X040_2_15_SHORT]  217.9 37.27 180 bottom
R25  18.7K_1%_2  [RSC_100X050X040_2]  196.47 41.51 270 bottom
R26  100K_1%_NTC  [RSC_100X050X055_2]  265.25 69.57 0 bottom
R28  100K_5%_2  [RSC_100X050X040_2]  212.47 44.22 270 bottom
R37  10K_5%_2  [RSC_100X050X040_2]  231.04 48.31 90 top
R38  10K_1%_2  [RSC_100X050X040_2]  279.68 65.94 0 bottom
R40  0_5%_2  [RSC_100X050X040_2]  17.01 75.87 270 bottom
R41  10K_5%_2  [RSC_100X050X040_2]  83.54 109.35 270 bottom
R42  330_5%_2  [RSC_100X050X040_2]  81.3 111.05 270 bottom
R43  100K_5%_2  [RSC_100X050X040_2]  82.75 114.1 180 bottom
R44  10K_5%_2  [RSC_100X050X040_2]  87.96 109.91 270 bottom
R55  1K_5%_2  [RSC_100X050X040_2]  222.45 22.3 270 top
R56  1K_5%_2  [RSC_100X050X040_2]  233.04 30.33 180 bottom
R60  short_0402_15  [RSC_100X050X040_2_15_SHORT]  145.51 76.13 180 top
R79  12.1_1%_2  [RSC_100X050X040_2]  250.29 70.79 90 bottom
R100  120_5%_2  [RSC_100X050X040_2]  284.73 105.06 0 bottom
R103  300_5%_2  [RSC_100X050X040_2]  281.02 101.68 180 bottom
R104  10K_5%_2  [RSC_100X050X040_2]  281.66 106.48 180 bottom
R105  300_5%_2  [RSC_100X050X040_2]  273.94 101.43 90 top
R107  10K_5%_2  [RSC_100X050X040_2]  284.81 103.91 0 bottom
R109  10K_5%_2  [RSC_100X050X040_2]  275.41 101.71 0 top
R133  33_5%_2  [RSC_100X050X040_2]  256.03 33.23 0 top
R134  33_5%_2  [RSC_100X050X040_2]  257.17 31.75 90 top
R135  33_5%_2  [RSC_100X050X040_2]  256.18 37.06 90 bottom
R136  33_5%_2  [RSC_100X050X040_2]  254.48 36.68 90 bottom
R143  1M_5%_2  [RSC_100X050X040_2]  73.5 89.01 180 bottom
R144  2M_5%_2_DY  [RSC_100X050X040_2]  75.1 89.01 180 bottom
R145  1M_5%_2  [RSC_100X050X040_2]  223.29 47.86 270 top
R146  2M_5%_2_DY  [RSC_100X050X040_2]  222.73 49.38 180 top
R148  0_5%_2  [RSC_100X050X040_2]  209.62 19.92 0 top
R149  100K_5%_2  [RSC_100X050X040_2]  255.5 55.27 180 top
R251  100K_5%_2  [RSC_100X050X040_2]  155.9 35.21 180 bottom
R253  100K_5%_2  [RSC_100X050X040_2]  154.25 35.21 180 bottom
R254  0_5%_2  [RSC_100X050X040_2]  107.46 34.24 180 bottom
R255  10K_5%_2  [RSC_100X050X040_2]  107.46 35.13 180 bottom
R280  short_0402_5  [RSC_100X050X040_2_SHORT]  117.8 33 270 bottom
R281  short_0402_5  [RSC_100X050X040_2_SHORT]  116.89 33 270 bottom
R282  10K_5%_2  [RSC_100X050X040_2]  115.97 33 90 bottom
R285  10K_5%_2_DY  [RSC_100X050X040_2]  119.4 30.89 0 bottom
R286  0_5%_2  [RSC_100X050X040_2]  117.8 30.89 0 bottom
R287  2.2K_5%_2  [RSC_100X050X040_2]  122.68 34.65 180 bottom
R288  2.2K_5%_2  [RSC_100X050X040_2]  121.03 34.65 0 bottom
R289  0_5%_2_DY  [RSC_100X050X040_2]  119.76 34.27 270 bottom
R290  0_5%_2_DY  [RSC_100X050X040_2]  123.19 31.93 270 bottom
R300  43_5%_2  [RSC_100X050X040_2]  217.65 30.92 0 bottom
R301  100K_5%_2  [RSC_100X050X040_2]  214.7 44.17 90 bottom
R302  220_5%_2  [RSC_100X050X040_2]  209.37 44.22 90 bottom
R303  0_5%_2  [RSC_100X050X040_2]  218.26 44.02 270 bottom
R304  10K_5%_2  [RSC_100X050X040_2]  210.28 44.22 90 bottom
R305  0_5%_2  [RSC_100X050X040_2]  215.59 44 270 bottom
R306  10K_5%_2  [RSC_100X050X040_2]  211.17 44.22 90 bottom
R307  0_5%_2  [RSC_100X050X040_2]  194.61 41.53 270 bottom
R311  33_5%_2  [RSC_100X050X040_2]  219.5 37.87 0 bottom
R312  0_5%_2  [RSC_100X050X040_2]  216.1 40.69 90 bottom
R314  100K_5%_2  [RSC_100X050X040_2]  201.93 22.36 0 bottom
R315  330_5%_2  [RSC_100X050X040_2]  205.74 22.81 270 bottom
R316  10K_5%_2  [RSC_100X050X040_2]  206.63 22.81 270 bottom
R317  10K_5%_2  [RSC_100X050X040_2]  216.86 26.5 180 bottom
R318  10K_5%_2  [RSC_100X050X040_2]  203.7 23.09 90 bottom
R319  10K_5%_2  [RSC_100X050X040_2]  208.4 22.15 90 bottom
R320  10K_5%_2  [RSC_100X050X040_2]  219.68 32.16 90 bottom
R321  100K_5%_2  [RSC_100X050X040_2]  193.21 27.51 0 bottom
R322  10K_5%_2  [RSC_100X050X040_2]  199.29 43.92 270 bottom
R323  0_5%_2  [RSC_100X050X040_2]  193.29 39.32 180 bottom
R324  10K_5%_2  [RSC_100X050X040_2]  217.37 41.02 180 bottom
R325  2.2K_5%_2  [RSC_100X050X040_2]  283.13 57.64 0 bottom
R326  0_5%_2  [RSC_100X050X040_2]  204.67 44.22 270 bottom
R327  2.2K_5%_2  [RSC_100X050X040_2]  282.58 61.76 180 bottom
R328  2.2K_5%_2  [RSC_100X050X040_2]  214.65 42.62 180 bottom
R329  2.2K_5%_2  [RSC_100X050X040_2]  216.94 42.98 0 bottom
R330  1K_5%_2  [RSC_100X050X040_2]  234.77 24.79 270 top
R331  short_0402_15  [RSC_100X050X040_2_15_SHORT]  210.18 22.23 90 bottom
R333  100_5%_2  [RSC_100X050X040_2]  217.37 35.49 0 bottom
R334  10K_5%_2_DY  [RSC_100X050X040_2]  213.99 22.15 270 bottom
R336  10K_5%_2  [RSC_100X050X040_2]  214.7 41.05 180 bottom
R337  10K_5%_2  [RSC_100X050X040_2]  197.99 43.54 0 bottom
R338  10K_5%_2_DY  [RSC_100X050X040_2]  202.89 44.22 270 bottom
R339  75_5%_2  [RSC_100X050X040_2]  218.21 34.6 0 bottom
R341  10K_5%_2  [RSC_100X050X040_2]  196.72 27.28 90 bottom
R342  10K_5%_2  [RSC_100X050X040_2]  207.51 22.15 270 bottom
R343  10K_5%_2  [RSC_100X050X040_2]  202 44.22 90 bottom
R344  10K_5%_2  [RSC_100X050X040_2]  205.56 44.22 270 bottom
R345  0_5%_2  [RSC_100X050X040_2]  206.45 44.22 270 bottom
R346  short_0402_15  [RSC_100X050X040_2_15_SHORT]  208 20.22 0 bottom
R347  short_0402_15  [RSC_100X050X040_2_15_SHORT]  204.59 23.09 90 bottom
R348  100K_5%_2  [RSC_100X050X040_2]  214.7 40.14 180 bottom
R349  100K_5%_2  [RSC_100X050X040_2]  203.45 29.54 90 top
R350  100_5%_2  [RSC_100X050X040_2]  208.48 44.02 90 bottom
R351  short_0402_15  [RSC_100X050X040_2_15_SHORT]  201.06 43.92 270 bottom
R352  100_5%_2  [RSC_100X050X040_2]  207.44 44.22 90 bottom
R354  short_0603_25  [RSC_160X080X080_2_25_SHORT]  212.98 22 90 bottom
R359  2.2K_5%_2  [RSC_100X050X040_2]  217.47 33.96 0 top
R360  2.2K_5%_2  [RSC_100X050X040_2]  217.47 33.07 0 top
R361  2.2K_5%_2  [RSC_100X050X040_2]  216.2 33.18 270 top
R362  2.2K_5%_2  [RSC_100X050X040_2]  215.29 33.18 270 top
R367  10K_5%_2  [RSC_100X050X040_2]  216.05 29.32 90 bottom
R392  10K_5%_2  [RSC_100X050X040_2]  215.77 21.97 90 bottom
R393  10K_5%_2_DY  [RSC_100X050X040_2]  214.88 22.15 90 bottom
R400  10K_5%_2  [RSC_100X050X040_2]  284.19 92.25 180 top
R402  10K_5%_2  [RSC_100X050X040_2]  289.87 92.27 0 bottom
R403  0_5%_2  [RSC_100X050X040_2]  276.1 96.13 0 top
R404  0_5%_2  [RSC_100X050X040_2]  283.34 94.25 90 top
R405  30.1K_1%_2  [RSC_100X050X040_2]  284.23 94.25 270 top
R406  0_5%_3_DY  [RSC_160X080X055_2]  278.15 91.67 270 top
R407  2.37K_1%_2  [RSC_100X050X040_2]  290.36 94.94 90 top
R408  200K_5%_2  [RSC_100X050X040_2]  275.55 89.77 270 bottom
R409  20K_5%_2  [RSC_100X050X040_2]  276.46 89.78 90 bottom
R410  0_5%_2  [RSC_100X050X040_2]  286.73 94.69 90 top
R411  1M_5%_2_DY  [RSC_100X050X040_2]  287.62 94.92 270 top
R412  75_5%_3  [RSC_160X080X080_2]  298.43 99.67 0 top
R413  75_5%_3  [RSC_160X080X080_2]  298.42 101.96 0 top
R414  75_5%_3  [RSC_160X080X080_2]  298.42 104.5 0 top
R415  75_5%_3  [RSC_160X080X080_2]  298.42 105.64 0 top
R416  4.7K_5%_2  [RSC_100X050X040_2]  291.39 93.63 270 bottom
R417  220_5%_2  [RSC_100X050X040_2]  271.74 94.28 270 top
R418  220_5%_2  [RSC_100X050X040_2]  271.74 95.9 90 top
R419  220_5%_2  [RSC_100X050X040_2]  284.79 105.31 90 top
R500  short_0603_25  [RSC_160X080X080_2_25_SHORT]  28.37 52.89 180 top
R501  20K_1%_2_DY  [RSC_100X050X040_2]  12.85 57.03 180 top
R502  200K_5%_2  [RSC_100X050X040_2]  13.93 58.15 180 top
R503  4.7K_5%_2  [RSC_100X050X040_2]  13.15 61.65 180 top
R504  100K_5%_2  [RSC_100X050X040_2]  13.92 59.04 180 top
R505  22K_5%_2  [RSC_100X050X040_2]  13.15 60.76 180 top
R506  short_0402_5  [RSC_100X050X040_2_SHORT]  19.68 63 180 top
R507  75_5%_2  [RSC_100X050X040_2]  17.17 62.46 90 top
R508  short_0603_25  [RSC_160X080X080_2_25_SHORT]  26.26 57.59 180 top
R509  short_0603_25  [RSC_160X080X080_2_25_SHORT]  26.26 56.44 180 top
R510  short_0603_25  [RSC_160X080X080_2_25_SHORT]  26.26 58.73 180 top
R511  short_0603_25  [RSC_160X080X080_2_25_SHORT]  26.26 59.87 180 top
R512  100_5%_2  [RSC_100X050X040_2]  20.95 62.21 270 top
R513  short_0603_25  [RSC_160X080X080_2_25_SHORT]  26.95 54.72 90 top
R514  short_0603_25  [RSC_160X080X080_2_25_SHORT]  13.15 54.72 180 top
R515  short_0402_5  [RSC_100X050X040_2_SHORT]  26.77 51.13 90 top
R521  22K_5%_2  [RSC_100X050X040_2]  14.78 60.84 0 top
R525  100K_5%_2  [RSC_100X050X040_2]  22.81 60.89 270 top
R531  100K_5%_2  [RSC_100X050X040_2]  15.34 51.95 180 top
R600  2.2K_5%_2  [RSC_100X050X040_2]  298.09 157.79 180 bottom
R601  2.2K_5%_2  [RSC_100X050X040_2]  297.99 165.38 270 bottom
R604  61.9_1%_2  [RSC_100X050X040_2]  18.11 47.5 0 top
R605  61.9_1%_2  [RSC_100X050X040_2]  18.26 48.39 0 top
R606  4.7K_5%_2  [RSC_100X050X040_2]  18.26 49.28 180 top
R607  4.7K_5%_2  [RSC_100X050X040_2]  18.11 46.61 180 top
R610  0_5%_2_DY  [RSC_100X050X040_2]  299.34 154.79 270 bottom
R700  2.2K_5%_2  [RSC_100X050X040_2]  136.32 42.37 270 bottom
R701  2.2K_5%_2  [RSC_100X050X040_2]  132.05 41.2 270 bottom
R702  100K_5%_2  [RSC_100X050X040_2]  135.57 30.66 90 bottom
R703  100K_5%_2  [RSC_100X050X040_2]  136.22 39.09 90 bottom
R704  390_1%_2  [RSC_100X050X040_2]  141.96 41.84 180 bottom
R705  100K_5%_2  [RSC_100X050X040_2]  134.65 30.66 270 bottom
R1300  100K_5%_2  [RSC_100X050X040_2]  263.75 20.76 270 top
R1301  100K_5%_2  [RSC_100X050X040_2]  272.59 23.57 90 top
R1320  0_5%_2  [RSC_100X050X040_2]  277.77 28.88 270 top
R1321  0_5%_2  [RSC_100X050X040_2]  261.08 66.6 0 top
R1324  0_5%_2  [RSC_100X050X040_2]  276.17 23.57 270 top
R1325  0_5%_5_DY  [RSC_200X125X130_2]  264.69 24.74 0 top
R1328  0_5%_2  [RSC_100X050X040_2]  273.48 23.57 270 top
R1329  0_5%_2  [RSC_100X050X040_2]  274.37 23.57 270 top
R1330  0_5%_2  [RSC_100X050X040_2]  291.41 22.84 180 top
R1331  0_5%_2  [RSC_100X050X040_2]  291.41 21.95 180 top
R1334  71.5K_1%_2  [RSC_100X050X040_2]  274.34 27.74 90 top
R1335  75K_1%_2_DY  [RSC_100X050X040_2]  273.45 27.74 90 top
R1337  0_5%_2  [RSC_100X050X040_2]  277.97 23.57 270 top
R1338  0_5%_2  [RSC_100X050X040_2]  277.09 23.57 270 top
R1342  10K_5%_2  [RSC_100X050X040_2]  244.52 62.82 180 top
R1345  0_5%_2  [RSC_100X050X040_2]  280.41 27.64 90 top
R1346  0_5%_2  [RSC_100X050X040_2]  281.3 27.64 90 top
R1347  0_5%_2  [RSC_100X050X040_2]  282.19 27.64 90 top
R1350  100K_5%_2  [RSC_100X050X040_2]  288.39 25.91 180 top
R1351  100K_5%_2  [RSC_100X050X040_2]  285.44 25.91 180 top
R1352  0_5%_2  [RSC_100X050X040_2]  287.96 27.33 180 top
R1353  0_5%_2  [RSC_100X050X040_2]  291.41 21.03 180 top
R1354  0_5%_2  [RSC_100X050X040_2]  291.41 20.15 180 top
R1355  0_5%_2  [RSC_100X050X040_2]  268.47 27.03 270 bottom
R1356  0_5%_2  [RSC_100X050X040_2]  269.36 27.03 270 bottom
R1357  10K_5%_2  [RSC_100X050X040_2]  282.88 23.78 90 top
R1358  0_5%_2  [RSC_100X050X040_2]  283.77 23.78 270 top
R1359  10K_5%_2  [RSC_100X050X040_2]  286.41 21.67 90 top
R1360  4.7K_5%_2  [RSC_100X050X040_2]  281.12 21.39 90 top
R1361  0_5%_2  [RSC_100X050X040_2]  283.08 27.64 270 top
R1362  0_5%_2  [RSC_100X050X040_2]  283.97 27.64 270 top
R1363  0_5%_2  [RSC_100X050X040_2]  284.88 27.94 270 top
R1364  0_5%_2  [RSC_100X050X040_2]  262.63 69.42 0 top
R1365  0_5%_2  [RSC_100X050X040_2]  278.08 30.66 270 top
R1366  0_5%_2  [RSC_100X050X040_2]  275.28 23.57 270 top
R1367  0_5%_2  [RSC_100X050X040_2]  293.04 24.34 180 top
R1368  0_5%_2  [RSC_100X050X040_2]  293.04 23.45 180 top
R1700  4.7K_5%_2  [RSC_100X050X040_2]  94.08 37.8 90 bottom
R1701  4.7K_5%_2_DY  [RSC_100X050X040_2]  94.97 37.8 90 bottom
R1702  1K_5%_2_DY  [RSC_100X050X040_2]  99.18 45.83 270 bottom
R1703  1K_5%_2_DY  [RSC_100X050X040_2]  105.25 41.33 180 bottom
R1704  1K_5%_2_DY  [RSC_100X050X040_2]  98.08 45.82 270 bottom
R1705  1K_5%_2_DY  [RSC_100X050X040_2]  92.66 41.61 0 bottom
R1706  1K_5%_2_DY  [RSC_100X050X040_2]  105.25 40.29 180 bottom
R1707  1K_5%_2_DY  [RSC_100X050X040_2]  91.87 40.34 0 bottom
R1708  1K_5%_2_DY  [RSC_100X050X040_2]  105.25 39.3 180 bottom
R1709  1K_5%_2_DY  [RSC_100X050X040_2]  91.87 39.45 0 bottom
R1710  1K_5%_2_DY  [RSC_100X050X040_2]  99.18 43.39 90 bottom
R1711  1K_5%_2_DY  [RSC_100X050X040_2]  102.61 41.33 0 bottom
R1712  1K_5%_2_DY  [RSC_100X050X040_2]  98 43.38 90 bottom
R1713  1K_5%_2_DY  [RSC_100X050X040_2]  94.26 41.61 180 bottom
R1714  1K_5%_2_DY  [RSC_100X050X040_2]  94.26 40.34 180 bottom
R1715  1K_5%_2_DY  [RSC_100X050X040_2]  102.64 40.29 0 bottom
R1716  1K_5%_2_DY  [RSC_100X050X040_2]  102.84 39.3 0 bottom
R1717  1K_5%_2_DY  [RSC_100X050X040_2]  94.26 39.45 180 bottom
R1718  4.7K_5%_2  [RSC_100X050X040_2]  102.87 38.08 180 bottom
R1900  0_5%_2  [RSC_100X050X040_2]  78.94 49.56 180 bottom
R1901  0_5%_2  [RSC_100X050X040_2]  78.64 50.85 270 bottom
R1902  0_5%_2  [RSC_100X050X040_2]  176.37 29.84 90 top
R1903  10K_5%_2  [RSC_100X050X040_2]  176.43 31.48 270 top
R1904  10K_5%_2  [RSC_100X050X040_2]  79.52 50.85 270 bottom
R1905  10K_5%_2  [RSC_100X050X040_2]  89.76 52.38 0 bottom
R1906  0_5%_2_DY  [RSC_100X050X040_2]  92.33 54.49 90 bottom
R2400  10K_5%_2_DY  [RSC_100X050X040_2]  301.34 19.99 180 bottom
R2401  10K_5%_2_DY  [RSC_100X050X040_2]  301.39 21.95 0 bottom
R2402  10K_5%_2  [RSC_100X050X040_2]  297.96 19.99 180 bottom
R2403  4.7K_5%_2_DY  [RSC_100X050X040_2]  296.44 25 90 bottom
R2404  4.7K_5%_2_DY  [RSC_100X050X040_2]  295.59 126.87 270 top
R2405  4.7K_5%_2_DY  [RSC_100X050X040_2]  294.7 126.87 270 top
R2406  4.7K_5%_2_DY  [RSC_100X050X040_2]  289.18 114.43 180 bottom
R2407  4.7K_5%_2_DY  [RSC_100X050X040_2]  289.05 113.54 180 bottom
R2408  4.7K_5%_2_DY  [RSC_100X050X040_2]  289.05 112.65 180 bottom
R2409  4.7K_5%_2_DY  [RSC_100X050X040_2]  280.74 115.68 180 bottom
R2410  120K_1%_2  [RSC_100X050X040_2]  294.28 20.07 0 bottom
R2411  10K_5%_2  [RSC_100X050X040_2]  303.6 11.81 90 top
R2412  4.7K_5%_2_DY  [RSC_100X050X040_2]  289.35 116.61 90 bottom
R2413  4.7K_5%_2_DY  [RSC_100X050X040_2]  289.46 115.32 180 bottom
R2414  4.99K_1%_2  [RSC_100X050X040_2]  282.9 120.82 90 bottom
R2415  10K_5%_2_DY  [RSC_100X050X040_2]  281.06 119.12 180 bottom
R2416  4.7K_5%_2_DY  [RSC_100X050X040_2]  281.52 120.19 180 bottom
R2417  4.7K_5%_2_DY  [RSC_100X050X040_2]  280.77 118.22 180 bottom
R2418  4.7K_5%_2_DY  [RSC_100X050X040_2]  280.77 117.33 180 bottom
R2419  4.99K_1%_2  [RSC_100X050X040_2]  298.57 122.23 0 top
R2420  10K_5%_2_DY  [RSC_100X050X040_2]  299.08 120.45 0 top
R2421  4.7K_5%_2_DY  [RSC_100X050X040_2]  298.57 121.34 0 top
R2422  4.7K_5%_2_DY  [RSC_100X050X040_2]  293.81 126.87 270 top
R2423  4.7K_5%_2_DY  [RSC_100X050X040_2]  292.92 126.87 270 top
R2424  4.7K_5%_2_DY  [RSC_100X050X040_2]  292.03 126.87 270 top
R2426  4.7K_5%_2_DY  [RSC_100X050X040_2]  299.08 119.56 0 top
R2427  4.7K_5%_2_DY  [RSC_100X050X040_2]  288.92 119.56 180 top
R2428  4.7K_5%_2_DY  [RSC_100X050X040_2]  288.92 120.45 180 top
R2500  10K_5%_2_DY  [RSC_100X050X040_2]  289 30.38 180 top
R2501  10K_5%_2_DY  [RSC_100X050X040_2]  287.27 33.71 270 top
R2502  0_5%_3  [RSC_160X080X055_2]  302.99 22.25 270 top
R2503  0_5%_3  [RSC_160X080X055_2]  301.85 22.25 270 top
R2504  0_5%_3  [RSC_160X080X055_2]  304.42 21.19 270 bottom
R2505  0_5%_3  [RSC_160X080X055_2]  303.27 21.19 270 bottom
R2506  220K_5%_2  [RSC_100X050X040_2]  304.67 22.84 0 bottom
R2507  220K_5%_2  [RSC_100X050X040_2]  303.02 22.84 180 bottom
R2508  220K_5%_2  [RSC_100X050X040_2]  304.39 22.99 180 top
R2509  220K_5%_2  [RSC_100X050X040_2]  306.04 22.99 0 top
R2510  0_5%_2_DY  [RSC_100X050X040_2]  305.76 14.18 0 bottom
R2511  0_5%_2_DY  [RSC_100X050X040_2]  305.76 13.29 0 bottom
R2512  0_5%_3  [RSC_160X080X055_2]  304.64 21.34 270 top
R2513  0_5%_3  [RSC_160X080X055_2]  305.79 21.34 270 top
R2514  0_5%_3  [RSC_160X080X055_2]  306.98 20.15 270 bottom
R2515  0_5%_3  [RSC_160X080X055_2]  305.84 20.15 270 bottom
R2523  0_5%_2_DY  [RSC_100X050X040_2]  299.13 31.45 0 top
R2524  0_5%_2_DY  [RSC_100X050X040_2]  299.13 30.56 0 top
R2529  0_5%_3  [RSC_160X080X055_2]  291.82 33.89 0 top
R2530  0_5%_3  [RSC_160X080X055_2]  291.82 32.74 0 top
R2531  0_5%_3  [RSC_160X080X055_2]  299.56 29.49 0 top
R2532  0_5%_3  [RSC_160X080X055_2]  299.56 28.35 0 top
R2551  19.6K_1%_2  [RSC_100X050X040_2]  280.39 33.71 270 top
R2552  33K_1%_2  [RSC_100X050X040_2]  279.5 33.71 270 top
R2553  0_5%_2  [RSC_100X050X040_2]  285.77 27.87 90 top
R2554  0_5%_2  [RSC_100X050X040_2]  279.52 27.64 90 top
R2555  0_5%_2  [RSC_100X050X040_2]  281.63 29.85 0 top
R2557  10K_5%_2_DY  [RSC_100X050X040_2]  287.98 29.49 0 top
R2558  0_5%_2  [RSC_100X050X040_2]  286.66 27.87 90 top
R2559  10K_5%_2  [RSC_100X050X040_2]  281.17 30.97 0 top
R2649  8.45K_1%_2  [RSC_100X050X040_2]  300.86 24.64 180 bottom
R2680  21K_1%_2  [RSC_100X050X040_2]  298.45 24.21 180 bottom
R2681  21K_1%_2  [RSC_100X050X040_2]  297.74 28.63 0 bottom
R3000  100_5%_2  [RSC_100X050X040_2]  28.57 62.97 90 top
R3001  short_0402_5  [RSC_100X050X040_2_SHORT]  29.94 62.94 90 top
R3002  100K_5%_2  [RSC_100X050X040_2]  38.22 56.54 90 bottom
R3004  100_5%_2  [RSC_100X050X040_2]  21.26 80.75 0 bottom
R3005  100_5%_2  [RSC_100X050X040_2]  36.56 60.69 0 bottom
R3006  100K_5%_2_DY  [RSC_100X050X040_2]  36.56 62.46 180 bottom
R3008  100K_5%_2  [RSC_100X050X040_2]  38.27 61.24 0 bottom
R3013  2.2K_5%_2_DY  [RSC_100X050X040_2]  38.27 59.46 0 bottom
R3014  0_5%_2  [RSC_100X050X040_2]  38.68 58.27 0 bottom
R3500  10K_5%_2  [RSC_100X050X040_2]  228.9 23.83 270 bottom
R3501  10K_5%_2  [RSC_100X050X040_2]  231.92 28.53 90 bottom
R3502  10K_5%_2  [RSC_100X050X040_2]  237.11 22.53 270 bottom
R3503  33_5%_2  [RSC_100X050X040_2]  228.01 23.83 90 bottom
R3504  short_0402_5  [RSC_100X050X040_2_SHORT]  231.04 28.53 270 bottom
R3505  33_5%_2  [RSC_100X050X040_2]  237.46 23.8 180 bottom
R3506  33_5%_2  [RSC_100X050X040_2]  232.81 28.53 270 bottom
R4116  10K_5%_2  [RSC_100X050X040_2]  84.91 108.66 180 bottom
R4119  0_5%_2  [RSC_100X050X040_2]  151.06 63.66 90 top
R4144  1K_1%_2  [RSC_100X050X040_2]  127.12 61.17 0 top
R4145  1K_1%_2  [RSC_100X050X040_2]  83.82 125.35 270 top
R4148  2_1%_2  [RSC_100X050X040_2]  84.71 126.29 270 top
R4149  24.9_1%_2  [RSC_100X050X035_2]  83.46 127.51 0 top
R4150  1K_1%_2  [RSC_100X050X040_2]  122.26 74.83 90 top
R4152  1K_1%_2  [RSC_100X050X040_2]  80.08 124.84 180 top
R4153  2_1%_2  [RSC_100X050X040_2]  81.3 123.55 180 top
R4155  24.9_1%_2  [RSC_100X050X035_2]  79.68 122.66 180 top
R4200  240_1%_2  [RSC_100X050X040_2]  118.44 64.68 270 top
R4201  240_1%_2  [RSC_100X050X040_2]  113.76 74.83 90 top
R4210  0_5%_2  [RSC_100X050X040_2]  145.46 78.18 270 top
R4211  short_0402_15  [RSC_100X050X040_2_15_SHORT]  125.32 75.38 0 top
R4212  0_5%_2  [RSC_100X050X040_2]  146.35 78.18 270 top
R4213  short_0402_15  [RSC_100X050X040_2_15_SHORT]  147.98 75.39 270 top
R4214  0_5%_2  [RSC_100X050X040_2]  125.32 74.47 180 top
R4216  0_5%_2  [RSC_100X050X040_2]  151.08 65.52 270 top
R4217  short_0402_15  [RSC_100X050X040_2_15_SHORT]  148.97 64.82 270 top
R4218  short_0402_15  [RSC_100X050X040_2_15_SHORT]  151.99 65.53 270 top
R4219  short_0402_15  [RSC_100X050X040_2_15_SHORT]  128.75 66.42 90 top
R4220  0_5%_2  [RSC_100X050X040_2]  128.75 68.05 270 top
R4300  10K_5%_2  [RSC_100X050X040_2]  61.82 56.42 270 bottom
R4301  10K_5%_2  [RSC_100X050X040_2]  61.82 58.04 90 bottom
R4302  10K_5%_2  [RSC_100X050X040_2]  273.94 74.32 180 top
R4305  10K_5%_2  [RSC_100X050X040_2]  275.99 74.32 0 top
R4452  10K_5%_2  [RSC_100X050X040_2]  146.84 120.69 180 bottom
R4453  10K_5%_2  [RSC_100X050X040_2]  143.56 111.03 270 bottom
R4454  short_0402_5_nsp  [RSC_100X050X040_2_NSP_SHORT]  144.57 118.98 270 bottom
R4455  short_0402_15_nsp  [RSC_100X050X040_2_15_NSP_SHORT]  144.45 111.03 90 bottom
R4501  24.9_1%_2  [RSC_100X050X035_2]  125.35 110.87 90 bottom
R4505  499_1%_2  [RSC_100X050X040_2]  84.84 139.6 180 top
R4507  1K_5%_2  [RSC_100X050X040_2]  86.46 139.6 180 top
R4508  51_5%_2  [RSC_100X050X040_2]  83.54 138.03 0 top
R4509  100_5%_2  [RSC_100X050X040_2]  92.05 138.46 180 top
R4510  51_5%_2  [RSC_100X050X040_2]  85.15 138.21 0 top
R4511  220_5%_2  [RSC_100X050X040_2]  90.62 138.87 90 top
R4513  20_5%_2  [RSC_100X050X040_2]  83.74 141 0 top
R4514  12.1_1%_2  [RSC_100X050X040_2]  85.37 141.84 180 top
R4515  51_5%_2  [RSC_100X050X040_2]  89.33 140.52 90 top
R4516  100_5%_2  [RSC_100X050X040_2]  86.4 138.29 90 top
R4517  100_1%_2  [RSC_100X050X040_2]  119.99 142.98 270 top
R4518  121_1%_2  [RSC_100X050X040_2]  126.23 110.87 90 bottom
R4519  49.9_1%_2  [RSC_100X050X040_2]  84.68 135.18 180 top
R4520  0_5%_2  [RSC_100X050X040_2]  86.76 112.17 180 bottom
R4521  100_1%_2  [RSC_100X050X040_2]  119.1 142.98 270 top
R4522  100_1%_2  [RSC_100X050X040_2]  121.08 126.85 180 top
R4523  1K_5%_2  [RSC_100X050X040_2]  83.61 132.34 180 top
R4524  100_1%_2  [RSC_100X050X040_2]  122.32 127.36 90 top
R4525  100_1%_2  [RSC_100X050X040_2]  105 143.01 270 top
R4526  1K_5%_2_DY  [RSC_100X050X040_2]  82.71 129.73 0 top
R4527  100_1%_2  [RSC_100X050X040_2]  106.55 142.98 270 top
R4528  1K_5%_2_DY  [RSC_100X050X040_2]  88.43 130.04 180 top
R4529  1K_5%_2_DY  [RSC_100X050X040_2]  86.78 135.2 180 top
R4530  1K_5%_2_DY  [RSC_100X050X040_2]  85.56 131.79 0 top
R4531  100_1%_2  [RSC_100X050X040_2]  107.95 143.03 270 top
R4532  short_0402_5  [RSC_100X050X040_2_SHORT]  251.18 70.79 90 bottom
R4533  49.9_1%_2  [RSC_100X050X040_2]  82.3 156 180 top
R4534  1K_1%_2  [RSC_100X050X040_2]  83 133.28 180 top
R4535  2.2K_5%_2  [RSC_100X050X040_2]  88.4 134.74 180 top
R4538  56.2_1%_2  [RSC_100X050X040_2]  92.05 139.35 180 top
R4540  100_1%_2  [RSC_100X050X040_2]  123.57 110.87 90 bottom
R4541  75_1%_2  [RSC_100X050X040_2]  124.46 110.87 90 bottom
R4544  24.9_1%_2  [RSC_100X050X035_2]  122.67 135.91 180 top
R4570  short_0402_15_nsp  [RSC_100X050X040_2_15_NSP_SHORT]  232.05 54.56 0 top
R4600  150_1%_2  [RSC_100X050X040_2]  262.28 70.11 0 bottom
R4601  10K_5%_2_DY  [RSC_100X050X040_2]  257.02 66.07 180 top
R4602  100K_5%_2  [RSC_100X050X040_2]  257.02 65.18 180 top
R4603  10K_5%_2_DY  [RSC_100X050X040_2]  261.03 71.4 90 bottom
R4604  10K_5%_2_DY  [RSC_100X050X040_2]  258.62 66.96 180 top
R4605  200_1%_2  [RSC_100X050X040_2]  260.22 62.56 0 top
R4606  200_1%_2  [RSC_100X050X040_2]  265.76 64.11 0 bottom
R4607  200_1%_2  [RSC_100X050X040_2]  261.13 65.33 0 top
R4608  100_1%_2  [RSC_100X050X040_2]  238.12 59.21 270 top
R4699  100K_5%_2_DY  [RSC_100X050X040_2]  243.02 36.73 270 bottom
R4701  33_5%_2  [RSC_100X050X040_2]  256.33 35.28 90 bottom
R4702  4.7K_5%_2_DY  [RSC_100X050X040_2]  263.72 56.39 0 bottom
R4703  100K_5%_2  [RSC_100X050X040_2]  263.72 57.28 0 bottom
R4705  2.2K_5%_2  [RSC_100X050X040_2]  265.12 54.46 270 top
R4706  0_5%_2  [RSC_100X050X040_2]  268.32 38.33 270 bottom
R4707  10K_5%_2  [RSC_100X050X040_2]  246.35 48.52 270 top
R4708  10K_5%_1  [RSC_060X030X030_2]  263.93 49.63 0 bottom
R4710  0_5%_2  [RSC_100X050X040_2]  267.43 38.33 270 bottom
R4711  100K_5%_1  [RSC_060X030X030_2]  263.93 50.42 0 bottom
R4713  10K_5%_2  [RSC_100X050X040_2]  255.06 65.05 0 top
R4714  10K_1%_2_DY  [RSC_100X050X040_2]  259.76 52.12 180 top
R4715  10K_1%_2_DY  [RSC_100X050X040_2]  254.89 49.91 180 top
R4716  33_5%_2  [RSC_100X050X040_2]  245.52 68.82 90 bottom
R4717  1K_5%_2  [RSC_100X050X040_2]  263.72 55.48 0 bottom
R4718  100K_5%_2  [RSC_100X050X040_2]  265.96 42.47 270 bottom
