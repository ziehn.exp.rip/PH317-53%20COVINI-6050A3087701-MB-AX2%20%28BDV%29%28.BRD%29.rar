# Allegro board PH317-53 COVINI-6050A3087701-MB-AX2 (BDV)(.BRD).brd (continued)
## Nets (continued)
DB_WOL_PWEN: CN601.32 R403.1(A)
DCPRTC: C4814.1(A) U4710.BF47(DCPRTC1) U4710.BG47(DCPRTC2)
DDR4_DRAMRST#_CPU: CN4100.108(RESET#) CN4125.108(RESET#) R4770.2(B)
DDR_CA_CPU_VREF_A: C4172.1(A) R4153.1(A) U4555.BN13(DDR_VREF_CA)
DDR_CA_CPU_VREF_RC: C4172.2(B) R4155.1(A)
DDR_DQ_CPU_VREF_A: TP4524.1 U4555.BP13(DDR0_VREF_DQ)
DDR_DQ_CPU_VREF_B: C4169.1(A) R4148.1(A) U4555.BR13(DDR1_VREF_DQ)
DDR_DQ_CPU_VREF_RC: C4169.2(B) R4149.1(A)
DDR_PG_CTRL: R42.1(A) U4555.BT13(DDR_VTT_CNTL)
DDR_PG_CTRL#: Q1.C Q2.1(G) R41.1(A)
DDR_PG_CTRL_R: Q1.B R42.2(B) R43.1(A)
DDR_RCOMP_0: R4518.2(B) U4555.G1(DDR_RCOMP_0)
DDR_RCOMP_1: R4541.2(B) U4555.H1(DDR_RCOMP_1)
DDR_RCOMP_2: R4540.2(B) U4555.J2(DDR_RCOMP_2)
DDR_VTT_PG_CTRL: D7000.3(A1) Q2.3(D) R44.2(B) R4116.1(A) R7001.1(A)
DEVSLP_SSD1: R1900.1(A) U4710.AH35(GPP_E5/SATA_DEVSLP1)
DEVSLP_SSD7: TP4805.1 U4710.AP47(GPP_F9/SATA_DEVSLP7)
DGPU_FB_CAL_PD_VDDQ: R52210.1(A) U50000.R44(FB_CAL_PD_VDDQ)
DGPU_FB_CAL_PU_GND: R52211.1(A) U50000.P44(FB_CAL_PU_GND)
DGPU_FB_CAL_TERM_GND: R52212.1(A) U50000.R45(FB_CAL_TERM_GND)
DGPU_FBVDDQ_SENSE: R52230.1(A) U50000.E52(FBVDDQ_SENSE)
DGPU_JTAG_SEL: R51508.2(B) U50000.BK23(NVJTAG_SEL)
DGPU_JTAG_TRSTB: R51507.2(B) U50000.BL24(JTAG_TRST*)
DGPU_PEX_TERMP: R50091.1(A) U50000.BL44(PEX_TERMP)
DGPU_PWR_EN: Q4.3(D) R51680.1(A) R53505.1(A) R53583.1(A) R56251.2(B) TP53500.1 U53500.1
DGPU_PWR_Q_EN: C51681.1(A) Q51640.1(G) Q51660.1(G) Q51680.6 R51682.1(A)
DGPU_PWR_R_EN: Q51680.5 R51680.2(B)
DGPU_PWR_R_EN#: Q51680.2 Q51680.3 R51681.1(A)
DGPU_PWRLEVEL: Q51550.D R323.2(B) TP51550.1
DGPU_PWROK: R345.2(B) U1.80(DAC4/DCD0#/GPJ4<3>) U4710.AW26(GPP_B19/GSPI1_CS0#)
DGPU_ROM_CS#: R51401.1(A) U50000.BJ4(ROM_CS*)
DGPU_ROM_SCLK: R51402.2(B) R51423.2(B) R51424.1(A) U50000.BK3(ROM_SCLK)
DGPU_ROM_SI: R51403.2(B) R51421.2(B) U50000.BK2(ROM_SI)
DGPU_ROM_SO: R51422.2(B) U50000.BK4(ROM_SO) U51400.2(SO)
DGPU_STRAP0: R51430.2(B) R51431.1(A) U50000.BL3(STRAP0)
DGPU_STRAP1: R51432.2(B) R51433.1(A) U50000.BL4(STRAP1)
DGPU_STRAP2: R51434.2(B) R51435.1(A) U50000.BM4(STRAP2)
DGPU_STRAP3: R51436.2(B) R51437.1(A) U50000.BM5(STRAP3)
DGPU_STRAP4: R51438.2(B) R51439.1(A) U50000.BK5(STRAP4)
DGPU_STRAP5: R51440.2(B) R51441.1(A) U50000.BJ5(STRAP5)
DGPU_XTAL_IN: C51310.1(A) U50000.BL6(XTAL_IN) X51310.1
DGPU_XTAL_OUT: C51311.1(A) U50000.BM6(XTAL_OUT) X51310.3
DGPU_XTAL_OUTBUFF: R51321.1(A) TP5631.1 U50000.BK6(XTAL_OUTBUFF)
DGPU_XTAL_SSIN: R51316.1(A) U50000.BJ6(EXT_REFCLK_FL)
DIS_FBVDD: Q55230.G R55231.2(B)
DIS_NVVDD: Q55210.G R55211.2(B)
DIS_PEXVDD: Q55220.G R55221.2(B)
DISP_RCOMP: R4544.1(A) U4555.D37(DISP_RCOMP)
DMI_RX0_DN: U4555.E8(DMI_RXN_0) U4710.C33(DMI0_TXN)
DMI_RX0_DP: U4555.D8(DMI_RXP_0) U4710.B33(DMI0_TXP)
DMI_RX1_DN: U4555.F6(DMI_RXN_1) U4710.C32(DMI1_TXN)
DMI_RX1_DP: U4555.E6(DMI_RXP_1) U4710.B32(DMI1_TXP)
DMI_RX2_DN: U4555.E5(DMI_RXN_2) U4710.C31(DMI2_TXN)
DMI_RX2_DP: U4555.D5(DMI_RXP_2) U4710.B31(DMI2_TXP)
DMI_RX3_DN: U4555.J9(DMI_RXN_3) U4710.C29(DMI3_TXN)
DMI_RX3_DP: U4555.J8(DMI_RXP_3) U4710.B29(DMI3_TXP)
DMI_TX0_DN: U4555.A8(DMI_TXN_0) U4710.K34(DMI0_RXN)
DMI_TX0_DP: U4555.B8(DMI_TXP_0) U4710.J35(DMI0_RXP)
DMI_TX1_DN: U4555.B6(DMI_TXN_1) U4710.G33(DMI1_RXN)
DMI_TX1_DP: U4555.C6(DMI_TXP_1) U4710.F34(DMI1_RXP)
DMI_TX2_DN: U4555.A5(DMI_TXN_2) U4710.K32(DMI2_RXN)
DMI_TX2_DP: U4555.B5(DMI_TXP_2) U4710.J32(DMI2_RXP)
DMI_TX3_DN: U4555.B4(DMI_TXN_3) U4710.G30(DMI3_RXN)
DMI_TX3_DP: U4555.D4(DMI_TXP_3) U4710.F30(DMI3_RXP)
DMIC__R_DATA: CN5.33 R3000.2(B)
DMIC_CLK: C18.1(A) C3005.1(A) R512.1(A) R3001.1(A)
DMIC_CLK_R: R512.2(B) U500.3(GPIO1/DMIC-CLK)
DMIC_DATA: C3004.1(A) R3000.1(A) U500.2(GPIO0/DMIC-DATA)
DMIC_R_CLK: CN5.32 R3001.2(B)
DP_AUX#_GATE: Q51630.3(D) Q51641.3(D)
DP_AUX_GATE: Q51650.3(D) Q51661.3(D)
DP_CABLE_DET: CN56200.4 D56230.4 D56230.7 R51670.1(A) R56200.2(B)
DP_CABLE_DET#: Q51670.2 Q51670.3 R51671.1(A)
DP_CABLE_R_DET: Q51670.5 R51670.2(B)
DP_CN_HPD: C56261.1(A) CN56200.2 D56230.5 D56230.6 R56261.2(B) R56271.2(B) R56281.2(B)
DP_IFPB_0: C51627.1(A) U50000.BE20(IFPC_L0)
DP_IFPB_0#: C51626.1(A) U50000.BF20(IFPC_L0*)
DP_IFPB_1: C51625.1(A) U50000.BH20(IFPC_L1)
DP_IFPB_1#: C51624.1(A) U50000.BG20(IFPC_L1*)
DP_IFPB_2: C51623.1(A) U50000.BG18(IFPC_L2)
DP_IFPB_2#: C51622.1(A) U50000.BF18(IFPC_L2*)
DP_IFPB_3: C51621.1(A) U50000.BE17(IFPC_L3)
DP_IFPB_3#: C51620.1(A) U50000.BF17(IFPC_L3*)
DP_IFPB_AUX: Q51660.2(S) R51660.2(B) U50000.BK9(IFPC_AUX_SCL)
DP_IFPB_AUX#: Q51640.2(S) R51640.1(A) U50000.BL9(IFPC_AUX_SDA*)
DP_IFPB_MODS: C51671.1(A) Q51630.1(G) Q51641.1(G) Q51650.1(G) Q51661.1(G) Q51670.6 R51672.1(A)
DP_LANE_0N: C51626.2(B) U55800.5(A0RX-)
DP_LANE_0P: C51627.2(B) U55800.4(A0RX+)
DP_LANE_1N: C51624.2(B) U55800.8(A1RX-)
DP_LANE_1P: C51625.2(B) U55800.7(A1RX+)
DP_LANE_2N: C51622.2(B) U55800.11(A2RX-)
DP_LANE_2P: C51623.2(B) U55800.10(A2RX+)
DP_LANE_3N: C51620.2(B) U55800.14(A3RX-)
DP_LANE_3P: C51621.2(B) U55800.13(A3RX+)
DP_MA_HPD#: Q56280.3(C) R56282.1(A) U4710.BD34(GPP_A19/ISH_GP1)
DP_NA_HPD: Q56280.1(B) R56280.2(B) R56281.1(A)
DP_NV_HPD: Q56260.1(B) R56260.2(B) R56261.1(A)
DP_P1_HPD: R4853.2(B) U4710.AT6(GPP_I0/DDPB_HPD0/DISP_MISC0)
DP_P2_HPD: R4854.2(B) U4710.AN10(GPP_I1/DDPC_HPD1/DISP_MISC1)
DP_REP_CFG0: R55818.1(A) U55800.37(FG0)
DP_REP_CFG1: R55819.1(A) U55800.38(FG1/I2C_RESET#)
DP_REP_EQ0: R55812.1(A) U55800.39(EQ0/AD0)
DP_REP_EQ1: R55813.1(A) U55800.40(EQ1/AD1)
DP_REP_EQ2: R55814.1(A) U55800.41(EQ2/AD2)
DP_REP_EQ3: R55815.1(A) U55800.42(EQ3/AD3)
DP_REP_HPD: Q56270.1(B) R56270.2(B) R56271.1(A)
DP_REP_HPD#: Q56270.3(C) R55830.1(A) U55800.20(PRSNT#)
DP_REP_I2CEN: R55810.1(A) R55811.1(A) U55800.21(ENI2C)
DP_REP_SW0: R55817.1(A) U55800.2(SW0)
DP_REP_SW1: R55816.1(A) U55800.1(SW1)
DP_UTIL: TP4500.1 U4555.A33(EDP_DISP_UTIL)
DPB_DDCCLK: R4806.1(A) U4710.AL13(GPP_I5/DDPB_CTRLCLK)
DPB_DDCDATA: R4807.1(A) U4710.AR8(GPP_I6/DDPB_CTRLDATA)
DPC_DDCCLK: R4808.1(A) U4710.AN13(GPP_I7/DDPC_CTRLCLK)
DPC_DDCDATA: R4809.1(A) U4710.AL10(GPP_I8/DDPC_CTRLDATA)
DPC_L_TX0N: CN56200.5 D56220.2 D56220.9 L56220.4(IND)
DPC_L_TX0P: CN56200.3 D56220.1 D56220.10 L56220.3(INB)
DPC_L_TX1N: CN56200.11 D56220.5 D56220.6 L56221.4(IND)
DPC_L_TX1P: CN56200.9 D56220.4 D56220.7 L56221.3(INB)
DPC_L_TX2N: CN56200.17 D56225.2 D56225.9 L56225.4(IND)
DPC_L_TX2P: CN56200.15 D56225.1 D56225.10 L56225.3(INB)
DPC_L_TX3N: CN56200.12 D56225.5 D56225.6 L56226.4(IND)
DPC_L_TX3P: CN56200.10 D56225.4 D56225.7 L56226.3(INB)
DPWROK: U1.19(L80HLAT/BAO/GPE0) U4710.AW41(DSW_PWROK)
EC_ACPRESENT: D4801.3(A1) R367.1(A) U1.122(DTR1#/SBUSY/GPG1/ID7)
EC_CPU_PROCHOT#: R339.1(A) U1.108(RXD/SIN0/GPB0)
EC_CTL1: R2554.1(A) U1.2(GPJ7)
EC_CTL2: R2553.1(A) U1.128(GPJ6)
EC_CTL3: R2558.1(A) U1.77(GPJ1<3>)
EC_GPG2: R324.2(B) U1.100(SSCE0#/GPG2)
EC_GPJ0: C302.2(B) CN253.2 R344.2(B) U1.76(TACH2/GPJ0<3>)
EC_PECI: C314.1(A) R300.1(A) U1.117(PECI/SMCLK2/GPF6<3>)
EC_PWRBTN#: R254.1(A) R333.2(B)
EC_RST#: C63.2(B) D300.1(A2) R321.2(B) U1.14(WRST#)
EC_RTC_RESET: Q300.2(G1) Q300.5(G2) R7031.2(B) R7032.1(A) U1.113(CRX0/GPC0)
EC_SCI#: R318.2(B) U1.23(ECSCI#/GPD3) U4710.U47(GPP_K3)
EC_SMB1_CLK: R361.2(B) R6050.1(A) U1.115(SMCLK1/GPC1) U60000.12
EC_SMB1_DATA: R362.2(B) R6051.1(A) U1.116(SMDAT1/GPC2) U60000.11
EC_SMBCLK0: Q51530.3 R305.1(A)
EC_SMBDATA0: Q51530.6 R303.1(A)
EC_SMI#: R319.2(B) R4699.1(A) U1.15(ECSMI#/GPD4<3>) U4710.T48(GPP_K19/SMI#)
EDP_AUX_DN: C3019.2(B) U4555.B26(EDP_AUXN)
EDP_AUX_DP: C3020.2(B) U4555.C26(EDP_AUXP)
EDP_BKLTEN: C3007.1(A) CN5.20 D3000.2(A2) R3008.2(B) R3013.2(B) R3014.1(A)
EDP_HPD: CN5.22 R4858.2(B) U4710.AN6(GPP_I4/EDP_HPD/DISP_MISC4)
EDP_PWM: C3008.1(A) CN5.21 R3005.2(B) R3006.1(A)
EDP_TX0_DN: C3014.2(B) U4555.E29(EDP_TXN_0)
EDP_TX0_DP: C3013.2(B) U4555.D29(EDP_TXP_0)
EDP_TX1_DN: C3016.2(B) U4555.E28(EDP_TXN_1)
EDP_TX1_DP: C3017.2(B) U4555.F28(EDP_TXP_1)
EDP_TX2_DN: C3027.2(B) U4555.B29(EDP_TXN_2)
EDP_TX2_DP: C3026.2(B) U4555.A29(EDP_TXP_2)
EDP_TX3_DN: C3029.2(B) U4555.B28(EDP_TXN_3)
EDP_TX3_DP: C3028.2(B) U4555.C28(EDP_TXP_3)
EN_1V0S_DGPU: C53582.1(A) D53581.1(A2) R53581.2(B) R55221.1(A) TP53582.1 TP67601.1 U53590.1 U67600.5
EN_1V05A: C139.1(A) D7005.1(A2) R7003.2(B) TP60901.1 U60900.11(EN2)
EN_1V8: C138.1(A) R148.2(B) R7002.2(B) TP60601.1 U60600.1
EN_1V8S_DGPU: C53501.2(B) R53500.2(B) R53501.2(B) TP53501.1 TP53502.1 TP67401.1 U67400.11(EN2)
EN_1V8S_R_DGPU: R53500.1(A) U53500.4
EN_2V5: C7033.1(A) R7027.2(B) R7040.2(B) TP60401.1 U60400.1
EN_3A5A: C7006.1(A) R6987.2(B) R6988.2(B) R7012.1(A) R7013.1(A) R7033.2(B)
EN_3V: R6987.1(A) R60110.2(B) TP60101.1 U60100.11
EN_5V: R6900.2(B) R6980.2(B) R6988.1(A) R60204.1(A) R60205.2(B) TP60201.1 U60200.12
EN_5V0: R6980.1(A) R60254.1(A) TP60251.1 U60250.12(EN1)
EN_NVVDD: R53573.2(B) U53570.1 U53570.2
EN_PEXVDD: R53583.2(B) R53584.2(B) U53580.2
EN_PEXVDD_AND: D53581.3(A1) R53580.1(A) R53581.1(A) U53580.4
EN_PVCORE: D7002.1(A2) Q4751.5(G2) R7004.2(B) R7007.2(B) R66000.1(A)
EN_VCCIO: C7036.1(A) D7004.1(A2) R7054.2(B) R60523.1(A) TP60501.1 U60500.5
EN_VDDQ: C7000.1(A) R7041.2(B) R7042.2(B) TP60301.1 U60300.15
EN_VRAM_DGPU: C53592.2(B) R53591.2(B) R55231.1(A) R67211.1(A) TP53592.1 TP67201.1
EN_VTT: C7015.1(A) D7000.1(A2) R7001.2(B) TP60351.1 U60300.16
ESPI_LPC#: R4702.1(A) R4703.1(A) U4710.BF24(GPP_C5/SML0ALERT#)
ESPI_RST#: R4897.1(A) R4902.1(A) U4710.BF38(GPP_A14/SUS_STAT#/ESPI_RESET#)
EVENT_PCH#: R4822.2(B) R4921.2(B) U4710.T45(GPP_K21)
FAN1_PWM: C4301.1(A) CN4300.3 R4301.2(B) TP4302.1 U1.30(PWM4/GPA4)
FAN1_TACH: C4305.1(A) CN4300.2 R4300.2(B) U1.47(TACH0A/GPD6<3>)
FAN2_PWM: C4306.1(A) CN4301.3 R4302.2(B) TP4303.1 U1.28(PWM2/GPA2)
FAN2_TACH: C4300.1(A) CN4301.2 R4305.2(B) U1.79(DAC3/TACH1B/GPJ3<3>)
FB_PLLAVDD: C50100.1(A) C50101.1(A) C50102.1(A) C50103.1(A) C50110.1(A) C50111.1(A) C50200.1(A) C50300.1(A) C50400.1(A) L50100.2(INB) TP50100.1 TP50200.1 TP50300.1 TP50400.1 U50000.AF42(FB_REFPLL_AVDD0) U50000.AN42(FBA_PLL_AVDD) U50000.L17(FBC_PLL_AVDD) U50000.L29(FB_REFPLL_AVDD1) U50000.L38(FBB_PLL_AVDD) U50000.V11(FBD_PLL_AVDD)
FBA1_VREFC: R50510.2(B) U50500.K1(VREFC)
FBA2_VREFC: R50610.2(B) U50600.K1(VREFC)
FBA_CLK0: U50000.AG45(FBA_CLK0) U50500.J10(CLK)
FBA_CLK0#: U50000.AG46(FBA_CLK0*) U50500.K10(CLK*)
FBA_CLK1: U50000.AK46(FBA_CLK1) U50600.J10(CLK)
FBA_CLK1#: U50000.AK45(FBA_CLK1*) U50600.K10(CLK*)
FBA_CMD0: U50000.Y51(FBA_CMD0) U50500.H3(CA0_A)
FBA_CMD1: U50000.Y52(FBA_CMD1) U50500.J3(CA9_A) U50500.K3(CA9_B)
FBA_CMD2_RST: R50506.1(A) U50000.Y49(FBA_CMD2) U50500.J1(RESET*)
FBA_CMD3: U50000.AA52(FBA_CMD3) U50500.J4(CA8_A) U50500.K4(CA8_B)
FBA_CMD4: U50000.AA51(FBA_CMD4) U50500.L3(CA0_B)
FBA_CMD5: U50000.AA50(FBA_CMD5) U50500.M4(CA2_B)
FBA_CMD6: U50000.AC50(FBA_CMD6) U50500.J5(CABI_A) U50500.K5(CABI_B)
FBA_CMD7: U50000.AC51(FBA_CMD7) U50500.H5(CA4_A) U50500.L5(CA4_B)
FBA_CMD8: U50000.AC52(FBA_CMD8) U50500.G4(CA2_A)
FBA_CMD9: U50000.AC49(FBA_CMD9) U50500.G11(CA1_A)
FBA_CMD10_CKE: R50505.1(A) U50000.AD52(FBA_CMD10) U50500.G10(CKE_A) U50500.M10(CKE_B)
FBA_CMD11: U50000.AD51(FBA_CMD11) U50500.H10(CA5_A) U50500.L10(CA5_B)
FBA_CMD12: U50000.AD50(FBA_CMD12) U50500.M11(CA1_B)
FBA_CMD13: U50000.AF50(FBA_CMD13) U50500.L12(CA3_B)
FBA_CMD14: U50000.AF51(FBA_CMD14) U50500.J11(CA7_A) U50500.K11(CA7_B)
FBA_CMD15: U50000.AF52(FBA_CMD15) U50500.J12(CA6_A) U50500.K12(CA6_B)
FBA_CMD16: U50000.AN50(FBA_CMD16) U50600.L3(CA0_B)
FBA_CMD17: U50000.AN51(FBA_CMD17) U50600.J3(CA9_A) U50600.K3(CA9_B)
FBA_CMD18_RST: R50606.1(A) U50000.AN52(FBA_CMD18) U50600.J1(RESET*)
FBA_CMD19: U50000.AM49(FBA_CMD19) U50600.J4(CA8_A) U50600.K4(CA8_B)
FBA_CMD20: U50000.AM52(FBA_CMD20) U50600.H3(CA0_A)
FBA_CMD21: U50000.AM51(FBA_CMD21) U50600.G4(CA2_A)
FBA_CMD22: U50000.AM50(FBA_CMD22) U50600.J5(CABI_A) U50600.K5(CABI_B)
FBA_CMD23: U50000.AK50(FBA_CMD23) U50600.H5(CA4_A) U50600.L5(CA4_B)
FBA_CMD24: U50000.AK51(FBA_CMD24) U50600.M4(CA2_B)
FBA_CMD25: U50000.AK52(FBA_CMD25) U50600.M11(CA1_B)
FBA_CMD26_CKE: R50605.1(A) U50000.AJ49(FBA_CMD26) U50600.G10(CKE_A) U50600.M10(CKE_B)
FBA_CMD27: U50000.AJ52(FBA_CMD27) U50600.H10(CA5_A) U50600.L10(CA5_B)
FBA_CMD28: U50000.AJ51(FBA_CMD28) U50600.G11(CA1_A)
FBA_CMD29: U50000.AJ50(FBA_CMD29) U50600.H12(CA3_A)
FBA_CMD30: U50000.AG50(FBA_CMD30) U50600.J12(CA6_A) U50600.K12(CA6_B)
FBA_CMD31: U50000.AG51(FBA_CMD31) U50600.J11(CA7_A) U50600.K11(CA7_B)
FBA_CMD32: U50000.AF49(FBA_CMD32) U50500.H12(CA3_A)
FBA_CMD33: U50000.AG52(FBA_CMD33) U50600.L12(CA3_B)
FBA_D0: U50000.U51(FBA_D0) U50500.G2(DQ0_A)
FBA_D1: U50000.U48(FBA_D1) U50500.B3(DQ7_A)
FBA_D2: U50000.U50(FBA_D2) U50500.F2(DQ3_A)
FBA_D3: U50000.U49(FBA_D3) U50500.E3(DQ6_A)
FBA_D4: U50000.R51(FBA_D4) U50500.B4(DQ1_A)
FBA_D5: U50000.R50(FBA_D5) U50500.B2(DQ5_A)
FBA_D6: U50000.R47(FBA_D6) U50500.E2(DQ2_A)
FBA_D7: U50000.U46(FBA_D7) U50500.A3(DQ4_A)
FBA_D8: U50000.V46(FBA_D8) U50500.B11(DQ11_A)
FBA_D9: U50000.Y45(FBA_D9) U50500.G13(DQ15_A)
FBA_D10: U50000.Y47(FBA_D10) U50500.E13(DQ8_A)
FBA_D11: U50000.Y46(FBA_D11) U50500.F13(DQ9_A)
FBA_D12: U50000.V50(FBA_D12) U50500.E12(DQ13_A)
FBA_D13: U50000.V47(FBA_D13) U50500.B12(DQ12_A)
FBA_D14: U50000.U52(FBA_D14) U50500.B13(DQ10_A)
FBA_D15: U50000.V51(FBA_D15) U50500.A12(DQ14_A)
FBA_D16: U50000.AJ44(FBA_D16) U50500.P13(DQ11_B)
FBA_D17: U50000.AG48(FBA_D17) U50500.U13(DQ8_B)
FBA_D18: U50000.AJ45(FBA_D18) U50500.M13(DQ15_B)
FBA_D19: U50000.AG49(FBA_D19) U50500.N13(DQ14_B)
FBA_D20: U50000.AF46(FBA_D20) U50500.U12(DQ13_B)
FBA_D21: U50000.AF47(FBA_D21) U50500.P12(DQ12_B)
FBA_D22: U50000.AF48(FBA_D22) U50500.V12(DQ10_B)
FBA_D23: U50000.AD47(FBA_D23) U50500.U11(DQ9_B)
FBA_D24: U50000.AD49(FBA_D24) U50500.N2(DQ7_B)
FBA_D25: U50000.AD48(FBA_D25) U50500.P3(DQ5_B)
FBA_D26: U50000.AC46(FBA_D26) U50500.M2(DQ6_B)
FBA_D27: U50000.AC47(FBA_D27) U50500.P2(DQ4_B)
FBA_D28: U50000.AA47(FBA_D28) U50500.U3(DQ3_B)
FBA_D29: U50000.AA46(FBA_D29) U50500.V3(DQ0_B)
FBA_D30: U50000.AA45(FBA_D30) U50500.U4(DQ1_B)
FBA_D31: U50000.Y44(FBA_D31) U50500.U2(DQ2_B)
FBA_D32: U50000.AW51(FBA_D32) U50600.B3(DQ7_A)
FBA_D33: U50000.BA52(FBA_D33) U50600.E2(DQ2_A)
FBA_D34: U50000.AW50(FBA_D34) U50600.E3(DQ6_A)
FBA_D35: U50000.BA51(FBA_D35) U50600.A3(DQ4_A)
FBA_D36: U50000.BA50(FBA_D36) U50600.G2(DQ0_A)
FBA_D37: U50000.BB50(FBA_D37) U50600.F2(DQ3_A)
FBA_D38: U50000.BA49(FBA_D38) U50600.B2(DQ5_A)
FBA_D39: U50000.AW49(FBA_D39) U50600.B4(DQ1_A)
FBA_D40: U50000.AV48(FBA_D40) U50600.E13(DQ8_A)
FBA_D41: U50000.AT49(FBA_D41) U50600.F13(DQ9_A)
FBA_D42: U50000.AT47(FBA_D42) U50600.B13(DQ10_A)
FBA_D43: U50000.AT48(FBA_D43) U50600.B11(DQ11_A)
FBA_D44: U50000.AT46(FBA_D44) U50600.B12(DQ12_A)
FBA_D45: U50000.AV51(FBA_D45) U50600.E12(DQ13_A)
FBA_D46: U50000.AV52(FBA_D46) U50600.A12(DQ14_A)
FBA_D47: U50000.AV49(FBA_D47) U50600.G13(DQ15_A)
FBA_D48: U50000.AJ48(FBA_D48) U50600.U13(DQ8_B)
FBA_D49: U50000.AJ46(FBA_D49) U50600.U11(DQ9_B)
FBA_D50: U50000.AJ47(FBA_D50) U50600.V12(DQ10_B)
FBA_D51: U50000.AK49(FBA_D51) U50600.P13(DQ11_B)
FBA_D52: U50000.AM47(FBA_D52) U50600.P12(DQ12_B)
FBA_D53: U50000.AM46(FBA_D53) U50600.U12(DQ13_B)
FBA_D54: U50000.AN48(FBA_D54) U50600.N13(DQ14_B)
FBA_D55: U50000.AN49(FBA_D55) U50600.M13(DQ15_B)
FBA_D56: U50000.AM44(FBA_D56) U50600.V3(DQ0_B)
FBA_D57: U50000.AM45(FBA_D57) U50600.U4(DQ1_B)
FBA_D58: U50000.AN45(FBA_D58) U50600.U2(DQ2_B)
FBA_D59: U50000.AN46(FBA_D59) U50600.U3(DQ3_B)
FBA_D60: U50000.AR48(FBA_D60) U50600.P2(DQ4_B)
FBA_D61: U50000.AN47(FBA_D61) U50600.P3(DQ5_B)
FBA_D62: U50000.AR47(FBA_D62) U50600.M2(DQ6_B)
FBA_D63: U50000.AR46(FBA_D63) U50600.N2(DQ7_B)
FBA_DBI0: U50000.U47(FBA_DQM0) U50500.D2(DBI0_A)
FBA_DBI1: U50000.Y48(FBA_DQM1) U50500.D13(DBI1_A)
FBA_DBI2: U50000.AG47(FBA_DQM2) U50500.R13(DBI1_B)
FBA_DBI3: U50000.AC48(FBA_DQM3) U50500.R2(DBI0_B)
FBA_DBI4: U50000.BB51(FBA_DQM4) U50600.D2(DBI0_A)
FBA_DBI5: U50000.AV50(FBA_DQM5) U50600.D13(DBI1_A)
FBA_DBI6: U50000.AM48(FBA_DQM6) U50600.R13(DBI1_B)
FBA_DBI7: U50000.AR49(FBA_DQM7) U50600.R2(DBI0_B)
FBA_DEBUG0: R50120.1(A) U50000.Y50(FBA_CMD34)
FBA_DEBUG1: R50121.1(A) U50000.AR50(FBA_CMD35)
FBA_EDC0: U50000.R48(FBA_DQS_WP0) U50500.C2(EDC0_A)
FBA_EDC1: U50000.V48(FBA_DQS_WP1) U50500.C13(EDC1_A)
FBA_EDC2: U50000.AF44(FBA_DQS_WP2) U50500.T13(EDC1_B)
FBA_EDC3: U50000.AA48(FBA_DQS_WP3) U50500.T2(EDC0_B)
FBA_EDC4: U50000.BB52(FBA_DQS_WP4) U50600.C2(EDC0_A)
FBA_EDC5: U50000.AT50(FBA_DQS_WP5) U50600.C13(EDC1_A)
FBA_EDC6: U50000.AK48(FBA_DQS_WP6) U50600.T13(EDC1_B)
FBA_EDC7: U50000.AR51(FBA_DQS_WP7) U50600.T2(EDC0_B)
FBA_WCK01: U50000.U45(FBA_WCK01) U50500.D4(WCK0_A)
FBA_WCK01#: U50000.U44(FBA_WCK01*) U50500.D5(WCK0_A*)
FBA_WCK23: U50000.AC45(FBA_WCK23) U50500.R11(WCK1_B)
FBA_WCK23#: U50000.AC44(FBA_WCK23*) U50500.R10(WCK1_B*)
FBA_WCK45: U50000.AV47(FBA_WCK45) U50600.D4(WCK0_A)
FBA_WCK45#: U50000.AV46(FBA_WCK45*) U50600.D5(WCK0_A*)
FBA_WCK67: U50000.AR45(FBA_WCK67) U50600.R11(WCK1_B)
FBA_WCK67#: U50000.AR44(FBA_WCK67*) U50600.R10(WCK1_B*)
FBA_WCKB01: U50000.V45(FBA_WCKB01) U50500.D11(WCK1_A)
FBA_WCKB01#: U50000.V44(FBA_WCKB01*) U50500.D10(WCK1_A*)
FBA_WCKB23: U50000.AD46(FBA_WCKB23) U50500.R4(WCK0_B)
FBA_WCKB23#: U50000.AD45(FBA_WCKB23*) U50500.R5(WCK0_B*)
FBA_WCKB45: U50000.AW48(FBA_WCKB45) U50600.D11(WCK1_A)
FBA_WCKB45#: U50000.AW47(FBA_WCKB45*) U50600.D10(WCK1_A*)
FBA_WCKB67: U50000.AT45(FBA_WCKB67) U50600.R4(WCK0_B)
FBA_WCKB67#: U50000.AT44(FBA_WCKB67*) U50600.R5(WCK0_B*)
FBA_ZQ_1_A: R50500.1(A) U50500.J14(ZQ_A)
FBA_ZQ_1_B: R50501.1(A) U50500.K14(ZQ_B)
FBA_ZQ_2_A: R50600.1(A) U50600.J14(ZQ_A)
FBA_ZQ_2_B: R50601.1(A) U50600.K14(ZQ_B)
FBB1_VREFC: R50710.2(B) U50700.K1(VREFC)
FBB2_VREFC: R50810.2(B) U50800.K1(VREFC)
FBB_CLK0: U50000.H42(FBB_CLK0) U50700.J10(CLK)
FBB_CLK0#: U50000.G42(FBB_CLK0*) U50700.K10(CLK*)
FBB_CLK1: U50000.F47(FBB_CLK1) U50800.J10(CLK)
FBB_CLK1#: U50000.E47(FBB_CLK1*) U50800.K10(CLK*)
FBB_CMD0: U50000.B35(FBB_CMD0) U50700.H3(CA0_A)
FBB_CMD1: U50000.A35(FBB_CMD1) U50700.J3(CA9_A) U50700.K3(CA9_B)
FBB_CMD2_RST: R50706.1(A) U50000.D35(FBB_CMD2) U50700.J1(RESET*)
FBB_CMD3: U50000.A36(FBB_CMD3) U50700.J4(CA8_A) U50700.K4(CA8_B)
FBB_CMD4: U50000.B36(FBB_CMD4) U50700.L3(CA0_B)
FBB_CMD5: U50000.C36(FBB_CMD5) U50700.M4(CA2_B)
FBB_CMD6: U50000.C38(FBB_CMD6) U50700.J5(CABI_A) U50700.K5(CABI_B)
FBB_CMD7: U50000.B38(FBB_CMD7) U50700.H5(CA4_A) U50700.L5(CA4_B)
FBB_CMD8: U50000.A38(FBB_CMD8) U50700.G4(CA2_A)
FBB_CMD9: U50000.D38(FBB_CMD9) U50700.G11(CA1_A)
FBB_CMD10_CKE: R50705.1(A) U50000.A39(FBB_CMD10) U50700.G10(CKE_A) U50700.M10(CKE_B)
FBB_CMD11: U50000.B39(FBB_CMD11) U50700.H10(CA5_A) U50700.L10(CA5_B)
FBB_CMD12: U50000.C39(FBB_CMD12) U50700.M11(CA1_B)
FBB_CMD13: U50000.C41(FBB_CMD13) U50700.L12(CA3_B)
FBB_CMD14: U50000.B41(FBB_CMD14) U50700.J11(CA7_A) U50700.K11(CA7_B)
FBB_CMD15: U50000.A41(FBB_CMD15) U50700.J12(CA6_A) U50700.K12(CA6_B)
FBB_CMD16: U50000.B49(FBB_CMD16) U50800.L3(CA0_B)
FBB_CMD17: U50000.A49(FBB_CMD17) U50800.J3(CA9_A) U50800.K3(CA9_B)
FBB_CMD18_RST: R50806.1(A) U50000.A48(FBB_CMD18) U50800.J1(RESET*)
FBB_CMD19: U50000.D47(FBB_CMD19) U50800.J4(CA8_A) U50800.K4(CA8_B)
FBB_CMD20: U50000.A47(FBB_CMD20) U50800.H3(CA0_A)
FBB_CMD21: U50000.B47(FBB_CMD21) U50800.G4(CA2_A)
FBB_CMD22: U50000.C47(FBB_CMD22) U50800.J5(CABI_A) U50800.K5(CABI_B)
FBB_CMD23: U50000.C45(FBB_CMD23) U50800.H5(CA4_A) U50800.L5(CA4_B)
FBB_CMD24: U50000.B45(FBB_CMD24) U50800.M4(CA2_B)
FBB_CMD25: U50000.A45(FBB_CMD25) U50800.M11(CA1_B)
FBB_CMD26_CKE: R50805.1(A) U50000.D44(FBB_CMD26) U50800.G10(CKE_A) U50800.M10(CKE_B)
FBB_CMD27: U50000.A44(FBB_CMD27) U50800.H10(CA5_A) U50800.L10(CA5_B)
FBB_CMD28: U50000.B44(FBB_CMD28) U50800.G11(CA1_A)
FBB_CMD29: U50000.C44(FBB_CMD29) U50800.H12(CA3_A)
FBB_CMD30: U50000.C42(FBB_CMD30) U50800.J12(CA6_A) U50800.K12(CA6_B)
FBB_CMD31: U50000.B42(FBB_CMD31) U50800.J11(CA7_A) U50800.K11(CA7_B)
FBB_CMD32: U50000.D41(FBB_CMD32) U50700.H12(CA3_A)
FBB_CMD33: U50000.A42(FBB_CMD33) U50800.L12(CA3_B)
FBB_D0: U50000.H32(FBB_D0) U50700.F2(DQ3_A)
FBB_D1: U50000.D32(FBB_D1) U50700.B4(DQ1_A)
FBB_D2: U50000.A33(FBB_D2) U50700.B3(DQ7_A)
FBB_D3: U50000.B32(FBB_D3) U50700.E2(DQ2_A)
FBB_D4: U50000.E32(FBB_D4) U50700.B2(DQ5_A)
FBB_D5: U50000.G32(FBB_D5) U50700.E3(DQ6_A)
FBB_D6: U50000.J30(FBB_D6) U50700.A3(DQ4_A)
FBB_D7: U50000.F32(FBB_D7) U50700.G2(DQ0_A)
FBB_D8: U50000.H36(FBB_D8) U50700.E13(DQ8_A)
FBB_D9: U50000.G36(FBB_D9) U50700.F13(DQ9_A)
FBB_D10: U50000.J36(FBB_D10) U50700.G13(DQ15_A)
FBB_D11: U50000.F36(FBB_D11) U50700.B13(DQ10_A)
FBB_D12: U50000.F33(FBB_D12) U50700.B12(DQ12_A)
FBB_D13: U50000.D33(FBB_D13) U50700.B11(DQ11_A)
FBB_D14: U50000.J32(FBB_D14) U50700.A12(DQ14_A)
FBB_D15: U50000.G33(FBB_D15) U50700.E12(DQ13_A)
FBB_D16: U50000.E45(FBB_D16) U50700.V12(DQ10_B)
FBB_D17: U50000.D45(FBB_D17) U50700.U13(DQ8_B)
FBB_D18: U50000.F45(FBB_D18) U50700.P12(DQ12_B)
FBB_D19: U50000.G45(FBB_D19) U50700.M13(DQ15_B)
FBB_D20: U50000.D42(FBB_D20) U50700.U12(DQ13_B)
FBB_D21: U50000.E42(FBB_D21) U50700.U11(DQ9_B)
FBB_D22: U50000.F42(FBB_D22) U50700.P13(DQ11_B)
FBB_D23: U50000.H41(FBB_D23) U50700.N13(DQ14_B)
FBB_D24: U50000.E41(FBB_D24) U50700.U4(DQ1_B)
FBB_D25: U50000.F39(FBB_D25) U50700.P3(DQ5_B)
FBB_D26: U50000.E39(FBB_D26) U50700.P2(DQ4_B)
FBB_D27: U50000.D39(FBB_D27) U50700.N2(DQ7_B)
FBB_D28: U50000.F38(FBB_D28) U50700.M2(DQ6_B)
FBB_D29: U50000.E38(FBB_D29) U50700.U3(DQ3_B)
FBB_D30: U50000.D36(FBB_D30) U50700.V3(DQ0_B)
FBB_D31: U50000.E36(FBB_D31) U50700.U2(DQ2_B)
FBB_D32: U50000.M50(FBB_D32) U50800.B3(DQ7_A)
FBB_D33: U50000.P48(FBB_D33) U50800.A3(DQ4_A)
FBB_D34: U50000.M51(FBB_D34) U50800.E2(DQ2_A)
FBB_D35: U50000.M49(FBB_D35) U50800.B4(DQ1_A)
FBB_D36: U50000.P47(FBB_D36) U50800.B2(DQ5_A)
FBB_D37: U50000.P52(FBB_D37) U50800.F2(DQ3_A)
FBB_D38: U50000.R46(FBB_D38) U50800.G2(DQ0_A)
FBB_D39: U50000.P46(FBB_D39) U50800.E3(DQ6_A)
FBB_D40: U50000.L50(FBB_D40) U50800.B12(DQ12_A)
FBB_D41: U50000.L51(FBB_D41) U50800.E12(DQ13_A)
FBB_D42: U50000.L52(FBB_D42) U50800.B11(DQ11_A)
FBB_D43: U50000.L49(FBB_D43) U50800.A12(DQ14_A)
FBB_D44: U50000.M46(FBB_D44) U50800.E13(DQ8_A)
FBB_D45: U50000.L47(FBB_D45) U50800.B13(DQ10_A)
FBB_D46: U50000.M48(FBB_D46) U50800.F13(DQ9_A)
FBB_D47: U50000.M47(FBB_D47) U50800.G13(DQ15_A)
FBB_D48: U50000.D48(FBB_D48) U50800.V12(DQ10_B)
FBB_D49: U50000.C50(FBB_D49) U50800.P12(DQ12_B)
FBB_D50: U50000.C48(FBB_D50) U50800.U13(DQ8_B)
FBB_D51: U50000.C49(FBB_D51) U50800.P13(DQ11_B)
FBB_D52: U50000.E49(FBB_D52) U50800.U12(DQ13_B)
FBB_D53: U50000.E50(FBB_D53) U50800.N13(DQ14_B)
FBB_D54: U50000.F49(FBB_D54) U50800.M13(DQ15_B)
FBB_D55: U50000.F48(FBB_D55) U50800.U11(DQ9_B)
FBB_D56: U50000.F50(FBB_D56) U50800.P3(DQ5_B)
FBB_D57: U50000.D52(FBB_D57) U50800.U3(DQ3_B)
FBB_D58: U50000.J50(FBB_D58) U50800.M2(DQ6_B)
FBB_D59: U50000.H48(FBB_D59) U50800.V3(DQ0_B)
FBB_D60: U50000.H51(FBB_D60) U50800.N2(DQ7_B)
FBB_D61: U50000.J51(FBB_D61) U50800.P2(DQ4_B)
FBB_D62: U50000.H49(FBB_D62) U50800.U4(DQ1_B)
FBB_D63: U50000.H52(FBB_D63) U50800.U2(DQ2_B)
FBB_DBI0: U50000.C32(FBB_DQM0) U50700.D2(DBI0_A)
FBB_DBI1: U50000.E33(FBB_DQM1) U50700.D13(DBI1_A)
FBB_DBI2: U50000.E44(FBB_DQM2) U50700.R13(DBI1_B)
FBB_DBI3: U50000.G39(FBB_DQM3) U50700.R2(DBI0_B)
FBB_DBI4: U50000.P49(FBB_DQM4) U50800.D2(DBI0_A)
FBB_DBI5: U50000.L48(FBB_DQM5) U50800.D13(DBI1_A)
FBB_DBI6: U50000.D50(FBB_DQM6) U50800.R13(DBI1_B)
FBB_DBI7: U50000.H50(FBB_DQM7) U50800.R2(DBI0_B)
FBB_DEBUG0: R50220.1(A) U50000.C35(FBB_CMD34)
FBB_DEBUG1: R50221.1(A) U50000.B50(FBB_CMD35)
FBB_EDC0: U50000.B33(FBB_DQS_WP0) U50700.C2(EDC0_A)
FBB_EDC1: U50000.E35(FBB_DQS_WP1) U50700.C13(EDC1_A)
FBB_EDC2: U50000.G44(FBB_DQS_WP2) U50700.T13(EDC1_B)
FBB_EDC3: U50000.H38(FBB_DQS_WP3) U50700.T2(EDC0_B)
FBB_EDC4: U50000.P50(FBB_DQS_WP4) U50800.C2(EDC0_A)
FBB_EDC5: U50000.J48(FBB_DQS_WP5) U50800.C13(EDC1_A)
FBB_EDC6: U50000.D51(FBB_DQS_WP6) U50800.T13(EDC1_B)
FBB_EDC7: U50000.F51(FBB_DQS_WP7) U50800.T2(EDC0_B)
FBB_WCK01: U50000.J33(FBB_WCK01) U50700.D4(WCK0_A)
FBB_WCK01#: U50000.H33(FBB_WCK01*) U50700.D5(WCK0_A*)
FBB_WCK23: U50000.J39(FBB_WCK23) U50700.R11(WCK1_B)
FBB_WCK23#: U50000.H39(FBB_WCK23*) U50700.R10(WCK1_B*)
FBB_WCK45: U50000.L46(FBB_WCK45) U50800.D4(WCK0_A)
FBB_WCK45#: U50000.L45(FBB_WCK45*) U50800.D5(WCK0_A*)
FBB_WCK67: U50000.H47(FBB_WCK67) U50800.R11(WCK1_B)
FBB_WCK67#: U50000.H46(FBB_WCK67*) U50800.R10(WCK1_B*)
FBB_WCKB01: U50000.G35(FBB_WCKB01) U50700.D11(WCK1_A)
FBB_WCKB01#: U50000.H35(FBB_WCKB01*) U50700.D10(WCK1_A*)
FBB_WCKB23: U50000.F41(FBB_WCKB23) U50700.R4(WCK0_B)
FBB_WCKB23#: U50000.G41(FBB_WCKB23*) U50700.R5(WCK0_B*)
FBB_WCKB45: U50000.M44(FBB_WCKB45) U50800.D11(WCK1_A)
FBB_WCKB45#: U50000.M45(FBB_WCKB45*) U50800.D10(WCK1_A*)
FBB_WCKB67: U50000.J47(FBB_WCKB67) U50800.R4(WCK0_B)
FBB_WCKB67#: U50000.J46(FBB_WCKB67*) U50800.R5(WCK0_B*)
FBB_ZQ_1_A: R50700.1(A) U50700.J14(ZQ_A)
FBB_ZQ_1_B: R50701.1(A) U50700.K14(ZQ_B)
FBB_ZQ_2_A: R50800.1(A) U50800.J14(ZQ_A)
FBB_ZQ_2_B: R50801.1(A) U50800.K14(ZQ_B)
FBC1_VREFC: R50910.2(B) U50900.K1(VREFC)
FBC2_VREFC: R51010.2(B) U51000.K1(VREFC)
FBC_CLK0: U50000.G15(FBC_CLK0) U50900.J10(CLK)
FBC_CLK0#: U50000.F15(FBC_CLK0*) U50900.K10(CLK*)
FBC_CLK1: U50000.H21(FBC_CLK1) U51000.J10(CLK)
FBC_CLK1#: U50000.J21(FBC_CLK1*) U51000.K10(CLK*)
FBC_CMD0: U50000.C11(FBC_CMD0) U50900.H3(CA0_A)
FBC_CMD1: U50000.B11(FBC_CMD1) U50900.J3(CA9_A) U50900.K3(CA9_B)
FBC_CMD2_RST: R50906.1(A) U50000.A11(FBC_CMD2) U50900.J1(RESET*)
FBC_CMD3: U50000.D11(FBC_CMD3) U50900.J4(CA8_A) U50900.K4(CA8_B)
FBC_CMD4: U50000.A12(FBC_CMD4) U50900.L3(CA0_B)
FBC_CMD5: U50000.B12(FBC_CMD5) U50900.M4(CA2_B)
FBC_CMD6: U50000.C12(FBC_CMD6) U50900.J5(CABI_A) U50900.K5(CABI_B)
FBC_CMD7: U50000.C14(FBC_CMD7) U50900.H5(CA4_A) U50900.L5(CA4_B)
FBC_CMD8: U50000.B14(FBC_CMD8) U50900.G4(CA2_A)
FBC_CMD9: U50000.A14(FBC_CMD9) U50900.G11(CA1_A)
FBC_CMD10_CKE: R50905.1(A) U50000.D14(FBC_CMD10) U50900.G10(CKE_A) U50900.M10(CKE_B)
FBC_CMD11: U50000.A15(FBC_CMD11) U50900.H10(CA5_A) U50900.L10(CA5_B)
FBC_CMD12: U50000.B15(FBC_CMD12) U50900.M11(CA1_B)
FBC_CMD13: U50000.C15(FBC_CMD13) U50900.L12(CA3_B)
FBC_CMD14: U50000.C17(FBC_CMD14) U50900.J11(CA7_A) U50900.K11(CA7_B)
FBC_CMD15: U50000.B17(FBC_CMD15) U50900.J12(CA6_A) U50900.K12(CA6_B)
FBC_CMD16: U50000.B24(FBC_CMD16) U51000.L3(CA0_B)
FBC_CMD17: U50000.A24(FBC_CMD17) U51000.J3(CA9_A) U51000.K3(CA9_B)
FBC_CMD18_RST: R51006.1(A) U50000.D23(FBC_CMD18) U51000.J1(RESET*)
FBC_CMD19: U50000.A23(FBC_CMD19) U51000.J4(CA8_A) U51000.K4(CA8_B)
FBC_CMD20: U50000.B23(FBC_CMD20) U51000.H3(CA0_A)
FBC_CMD21: U50000.C23(FBC_CMD21) U51000.G4(CA2_A)
FBC_CMD22: U50000.C21(FBC_CMD22) U51000.J5(CABI_A) U51000.K5(CABI_B)
FBC_CMD23: U50000.B21(FBC_CMD23) U51000.H5(CA4_A) U51000.L5(CA4_B)
FBC_CMD24: U50000.A21(FBC_CMD24) U51000.M4(CA2_B)
FBC_CMD25: U50000.D20(FBC_CMD25) U51000.M11(CA1_B)
FBC_CMD26_CKE: R51005.1(A) U50000.A20(FBC_CMD26) U51000.G10(CKE_A) U51000.M10(CKE_B)
FBC_CMD27: U50000.B20(FBC_CMD27) U51000.H10(CA5_A) U51000.L10(CA5_B)
FBC_CMD28: U50000.C20(FBC_CMD28) U51000.G11(CA1_A)
FBC_CMD29: U50000.C18(FBC_CMD29) U51000.H12(CA3_A)
FBC_CMD30: U50000.B18(FBC_CMD30) U51000.J12(CA6_A) U51000.K12(CA6_B)
FBC_CMD31: U50000.A18(FBC_CMD31) U51000.J11(CA7_A) U51000.K11(CA7_B)
FBC_CMD32: U50000.A17(FBC_CMD32) U50900.H12(CA3_A)
FBC_CMD33: U50000.D17(FBC_CMD33) U51000.L12(CA3_B)
FBC_D0: U50000.C6(FBC_D0) U50900.F2(DQ3_A)
FBC_D1: U50000.D6(FBC_D1) U50900.B4(DQ1_A)
FBC_D2: U50000.A6(FBC_D2) U50900.G2(DQ0_A)
FBC_D3: U50000.B6(FBC_D3) U50900.E2(DQ2_A)
FBC_D4: U50000.B4(FBC_D4) U50900.B2(DQ5_A)
FBC_D5: U50000.A4(FBC_D5) U50900.B3(DQ7_A)
FBC_D6: U50000.B3(FBC_D6) U50900.E3(DQ6_A)
FBC_D7: U50000.C4(FBC_D7) U50900.A3(DQ4_A)
FBC_D8: U50000.D9(FBC_D8) U50900.B12(DQ12_A)
FBC_D9: U50000.C9(FBC_D9) U50900.E13(DQ8_A)
FBC_D10: U50000.E9(FBC_D10) U50900.G13(DQ15_A)
FBC_D11: U50000.B9(FBC_D11) U50900.F13(DQ9_A)
FBC_D12: U50000.B8(FBC_D12) U50900.B13(DQ10_A)
FBC_D13: U50000.A8(FBC_D13) U50900.E12(DQ13_A)
FBC_D14: U50000.F6(FBC_D14) U50900.B11(DQ11_A)
FBC_D15: U50000.E6(FBC_D15) U50900.A12(DQ14_A)
FBC_D16: U50000.F18(FBC_D16) U50900.M13(DQ15_B)
FBC_D17: U50000.G18(FBC_D17) U50900.N13(DQ14_B)
FBC_D18: U50000.E18(FBC_D18) U50900.P12(DQ12_B)
FBC_D19: U50000.H18(FBC_D19) U50900.P13(DQ11_B)
FBC_D20: U50000.D15(FBC_D20) U50900.V12(DQ10_B)
FBC_D21: U50000.E15(FBC_D21) U50900.U13(DQ8_B)
FBC_D22: U50000.G17(FBC_D22) U50900.U12(DQ13_B)
FBC_D23: U50000.H17(FBC_D23) U50900.U11(DQ9_B)
FBC_D24: U50000.J15(FBC_D24) U50900.P2(DQ4_B)
FBC_D25: U50000.H15(FBC_D25) U50900.U4(DQ1_B)
FBC_D26: U50000.E14(FBC_D26) U50900.P3(DQ5_B)
FBC_D27: U50000.F14(FBC_D27) U50900.M2(DQ6_B)
FBC_D28: U50000.H11(FBC_D28) U50900.U3(DQ3_B)
FBC_D29: U50000.G11(FBC_D29) U50900.V3(DQ0_B)
FBC_D30: U50000.F11(FBC_D30) U50900.N2(DQ7_B)
FBC_D31: U50000.E11(FBC_D31) U50900.U2(DQ2_B)
FBC_D32: U50000.J29(FBC_D32) U51000.E2(DQ2_A)
FBC_D33: U50000.F30(FBC_D33) U51000.F2(DQ3_A)
FBC_D34: U50000.H29(FBC_D34) U51000.A3(DQ4_A)
FBC_D35: U50000.G30(FBC_D35) U51000.E3(DQ6_A)
FBC_D36: U50000.B30(FBC_D36) U51000.B3(DQ7_A)
FBC_D37: U50000.A30(FBC_D37) U51000.G2(DQ0_A)
FBC_D38: U50000.H30(FBC_D38) U51000.B4(DQ1_A)
FBC_D39: U50000.C30(FBC_D39) U51000.B2(DQ5_A)
FBC_D40: U50000.D27(FBC_D40) U51000.B11(DQ11_A)
FBC_D41: U50000.J26(FBC_D41) U51000.G13(DQ15_A)
FBC_D42: U50000.F27(FBC_D42) U51000.B13(DQ10_A)
FBC_D43: U50000.G27(FBC_D43) U51000.A12(DQ14_A)
FBC_D44: U50000.C27(FBC_D44) U51000.E12(DQ13_A)
FBC_D45: U50000.B27(FBC_D45) U51000.E13(DQ8_A)
FBC_D46: U50000.A27(FBC_D46) U51000.B12(DQ12_A)
FBC_D47: U50000.G29(FBC_D47) U51000.F13(DQ9_A)
FBC_D48: U50000.H20(FBC_D48) U51000.U12(DQ13_B)
FBC_D49: U50000.D18(FBC_D49) U51000.U13(DQ8_B)
FBC_D50: U50000.G20(FBC_D50) U51000.V12(DQ10_B)
FBC_D51: U50000.E20(FBC_D51) U51000.U11(DQ9_B)
FBC_D52: U50000.F23(FBC_D52) U51000.P13(DQ11_B)
FBC_D53: U50000.E21(FBC_D53) U51000.P12(DQ12_B)
FBC_D54: U50000.D21(FBC_D54) U51000.M13(DQ15_B)
FBC_D55: U50000.E23(FBC_D55) U51000.N13(DQ14_B)
FBC_D56: U50000.G24(FBC_D56) U51000.U4(DQ1_B)
FBC_D57: U50000.H26(FBC_D57) U51000.V3(DQ0_B)
FBC_D58: U50000.F24(FBC_D58) U51000.U3(DQ3_B)
FBC_D59: U50000.G26(FBC_D59) U51000.U2(DQ2_B)
FBC_D60: U50000.F26(FBC_D60) U51000.P3(DQ5_B)
FBC_D61: U50000.D26(FBC_D61) U51000.P2(DQ4_B)
FBC_D62: U50000.B26(FBC_D62) U51000.N2(DQ7_B)
FBC_D63: U50000.C26(FBC_D63) U51000.M2(DQ6_B)
FBC_DBI0: U50000.A5(FBC_DQM0) U50900.D2(DBI0_A)
FBC_DBI1: U50000.C8(FBC_DQM1) U50900.D13(DBI1_A)
FBC_DBI2: U50000.J18(FBC_DQM2) U50900.R13(DBI1_B)
FBC_DBI3: U50000.F12(FBC_DQM3) U50900.R2(DBI0_B)
FBC_DBI4: U50000.D29(FBC_DQM4) U51000.D2(DBI0_A)
FBC_DBI5: U50000.E27(FBC_DQM5) U51000.D13(DBI1_A)
FBC_DBI6: U50000.F20(FBC_DQM6) U51000.R13(DBI1_B)
FBC_DBI7: U50000.E26(FBC_DQM7) U51000.R2(DBI0_B)
FBC_DEBUG0: R50320.1(A) U50000.A9(FBC_CMD34)
FBC_DEBUG1: R50321.1(A) U50000.C24(FBC_CMD35)
FBC_EDC0: U50000.D5(FBC_DQS_WP0) U50900.C2(EDC0_A)
FBC_EDC1: U50000.D8(FBC_DQS_WP1) U50900.C13(EDC1_A)
FBC_EDC2: U50000.E17(FBC_DQS_WP2) U50900.T13(EDC1_B)
FBC_EDC3: U50000.E12(FBC_DQS_WP3) U50900.T2(EDC0_B)
FBC_EDC4: U50000.E30(FBC_DQS_WP4) U51000.C2(EDC0_A)
FBC_EDC5: U50000.B29(FBC_DQS_WP5) U51000.C13(EDC1_A)
FBC_EDC6: U50000.G21(FBC_DQS_WP6) U51000.T13(EDC1_B)
FBC_EDC7: U50000.E24(FBC_DQS_WP7) U51000.T2(EDC0_B)
FBC_WCK01: U50000.F8(FBC_WCK01) U50900.D4(WCK0_A)
FBC_WCK01#: U50000.G8(FBC_WCK01*) U50900.D5(WCK0_A*)
FBC_WCK23: U50000.H12(FBC_WCK23) U50900.R11(WCK1_B)
FBC_WCK23#: U50000.G12(FBC_WCK23*) U50900.R10(WCK1_B*)
FBC_WCK45: U50000.J27(FBC_WCK45) U51000.D4(WCK0_A)
FBC_WCK45#: U50000.H27(FBC_WCK45*) U51000.D5(WCK0_A*)
FBC_WCK67: U50000.G23(FBC_WCK67) U51000.R11(WCK1_B)
FBC_WCK67#: U50000.H23(FBC_WCK67*) U51000.R10(WCK1_B*)
FBC_WCKB01: U50000.G9(FBC_WCKB01) U50900.D11(WCK1_A)
FBC_WCKB01#: U50000.F9(FBC_WCKB01*) U50900.D10(WCK1_A*)
FBC_WCKB23: U50000.G14(FBC_WCKB23) U50900.R4(WCK0_B)
FBC_WCKB23#: U50000.H14(FBC_WCKB23*) U50900.R5(WCK0_B*)
FBC_WCKB45: U50000.E29(FBC_WCKB45) U51000.D11(WCK1_A)
FBC_WCKB45#: U50000.F29(FBC_WCKB45*) U51000.D10(WCK1_A*)
FBC_WCKB67: U50000.H24(FBC_WCKB67) U51000.R4(WCK0_B)
FBC_WCKB67#: U50000.J24(FBC_WCKB67*) U51000.R5(WCK0_B*)
FBC_ZQ_1_A: R50900.1(A) U50900.J14(ZQ_A)
FBC_ZQ_1_B: R50901.1(A) U50900.K14(ZQ_B)
FBC_ZQ_2_A: R51000.1(A) U51000.J14(ZQ_A)
FBC_ZQ_2_B: R51001.1(A) U51000.K14(ZQ_B)
FBD1_VREFC: R51110.2(B) U51100.K1(VREFC)
FBD2_VREFC: R51210.2(B) U51200.K1(VREFC)
FBD_CLK0: U50000.Y8(FBD_CLK0) U51100.J10(CLK)
FBD_CLK0#: U50000.Y7(FBD_CLK0*) U51100.K10(CLK*)
FBD_CLK1: U50000.R8(FBD_CLK1) U51200.J10(CLK)
FBD_CLK1#: U50000.R7(FBD_CLK1*) U51200.K10(CLK*)
FBD_CMD0: U50000.AD2(FBD_CMD0) U51100.H3(CA0_A)
FBD_CMD1: U50000.AD1(FBD_CMD1) U51100.J3(CA9_A) U51100.K3(CA9_B)
FBD_CMD2_RST: R51106.1(A) U50000.AD4(FBD_CMD2) U51100.J1(RESET*)
FBD_CMD3: U50000.AC1(FBD_CMD3) U51100.J4(CA8_A) U51100.K4(CA8_B)
FBD_CMD4: U50000.AC2(FBD_CMD4) U51100.L3(CA0_B)
FBD_CMD5: U50000.AC3(FBD_CMD5) U51100.M4(CA2_B)
FBD_CMD6: U50000.AA3(FBD_CMD6) U51100.J5(CABI_A) U51100.K5(CABI_B)
FBD_CMD7: U50000.AA2(FBD_CMD7) U51100.H5(CA4_A) U51100.L5(CA4_B)
FBD_CMD8: U50000.AA1(FBD_CMD8) U51100.G4(CA2_A)
FBD_CMD9: U50000.AA4(FBD_CMD9) U51100.G11(CA1_A)
FBD_CMD10_CKE: R51105.1(A) U50000.Y1(FBD_CMD10) U51100.G10(CKE_A) U51100.M10(CKE_B)
FBD_CMD11: U50000.Y2(FBD_CMD11) U51100.H10(CA5_A) U51100.L10(CA5_B)
FBD_CMD12: U50000.Y3(FBD_CMD12) U51100.M11(CA1_B)
FBD_CMD13: U50000.V3(FBD_CMD13) U51100.L12(CA3_B)
FBD_CMD14: U50000.V2(FBD_CMD14) U51100.J11(CA7_A) U51100.K11(CA7_B)
FBD_CMD15: U50000.V1(FBD_CMD15) U51100.J12(CA6_A) U51100.K12(CA6_B)
FBD_CMD16: U50000.L3(FBD_CMD16) U51200.L3(CA0_B)
FBD_CMD17: U50000.L2(FBD_CMD17) U51200.J3(CA9_A) U51200.K3(CA9_B)
FBD_CMD18_RST: R51206.1(A) U50000.L1(FBD_CMD18) U51200.J1(RESET*)
FBD_CMD19: U50000.M4(FBD_CMD19) U51200.J4(CA8_A) U51200.K4(CA8_B)
FBD_CMD20: U50000.M1(FBD_CMD20) U51200.H3(CA0_A)
FBD_CMD21: U50000.M2(FBD_CMD21) U51200.G4(CA2_A)
FBD_CMD22: U50000.M3(FBD_CMD22) U51200.J5(CABI_A) U51200.K5(CABI_B)
FBD_CMD23: U50000.P3(FBD_CMD23) U51200.H5(CA4_A) U51200.L5(CA4_B)
FBD_CMD24: U50000.P2(FBD_CMD24) U51200.M4(CA2_B)
FBD_CMD25: U50000.P1(FBD_CMD25) U51200.M11(CA1_B)
FBD_CMD26_CKE: R51205.1(A) U50000.R4(FBD_CMD26) U51200.G10(CKE_A) U51200.M10(CKE_B)
FBD_CMD27: U50000.R1(FBD_CMD27) U51200.H10(CA5_A) U51200.L10(CA5_B)
FBD_CMD28: U50000.R2(FBD_CMD28) U51200.G11(CA1_A)
FBD_CMD29: U50000.R3(FBD_CMD29) U51200.H12(CA3_A)
FBD_CMD30: U50000.U3(FBD_CMD30) U51200.J12(CA6_A) U51200.K12(CA6_B)
FBD_CMD31: U50000.U2(FBD_CMD31) U51200.J11(CA7_A) U51200.K11(CA7_B)
FBD_CMD32: U50000.V4(FBD_CMD32) U51100.H12(CA3_A)
FBD_CMD33: U50000.U1(FBD_CMD33) U51200.L12(CA3_B)
FBD_D0: U50000.AK8(FBD_D0) U51100.B3(DQ7_A)
FBD_D1: U50000.AK4(FBD_D1) U51100.A3(DQ4_A)
FBD_D2: U50000.AK2(FBD_D2) U51100.F2(DQ3_A)
FBD_D3: U50000.AK3(FBD_D3) U51100.B2(DQ5_A)
FBD_D4: U50000.AK5(FBD_D4) U51100.G2(DQ0_A)
FBD_D5: U50000.AK6(FBD_D5) U51100.B4(DQ1_A)
FBD_D6: U50000.AK9(FBD_D6) U51100.E3(DQ6_A)
FBD_D7: U50000.AK7(FBD_D7) U51100.E2(DQ2_A)
FBD_D8: U50000.AG4(FBD_D8) U51100.B12(DQ12_A)
FBD_D9: U50000.AF9(FBD_D9) U51100.F13(DQ9_A)
FBD_D10: U50000.AG6(FBD_D10) U51100.E12(DQ13_A)
FBD_D11: U50000.AG7(FBD_D11) U51100.G13(DQ15_A)
FBD_D12: U50000.AJ4(FBD_D12) U51100.B13(DQ10_A)
FBD_D13: U50000.AJ5(FBD_D13) U51100.B11(DQ11_A)
FBD_D14: U50000.AJ6(FBD_D14) U51100.A12(DQ14_A)
FBD_D15: U50000.AG5(FBD_D15) U51100.E13(DQ8_A)
FBD_D16: U50000.Y6(FBD_D16) U51100.N13(DQ14_B)
FBD_D17: U50000.Y5(FBD_D17) U51100.P12(DQ12_B)
FBD_D18: U50000.V5(FBD_D18) U51100.M13(DQ15_B)
FBD_D19: U50000.Y4(FBD_D19) U51100.P13(DQ11_B)
FBD_D20: U50000.AA6(FBD_D20) U51100.U13(DQ8_B)
FBD_D21: U50000.AA5(FBD_D21) U51100.V12(DQ10_B)
FBD_D22: U50000.AC5(FBD_D22) U51100.U12(DQ13_B)
FBD_D23: U50000.AC4(FBD_D23) U51100.U11(DQ9_B)
FBD_D24: U50000.AD7(FBD_D24) U51100.M2(DQ6_B)
FBD_D25: U50000.AC6(FBD_D25) U51100.P3(DQ5_B)
FBD_D26: U50000.AF6(FBD_D26) U51100.U3(DQ3_B)
FBD_D27: U50000.AD6(FBD_D27) U51100.P2(DQ4_B)
FBD_D28: U50000.AF7(FBD_D28) U51100.V3(DQ0_B)
FBD_D29: U50000.AF8(FBD_D29) U51100.N2(DQ7_B)
FBD_D30: U50000.AF2(FBD_D30) U51100.U4(DQ1_B)
FBD_D31: U50000.AF3(FBD_D31) U51100.U2(DQ2_B)
FBD_D32: U50000.F4(FBD_D32) U51200.B3(DQ7_A)
FBD_D33: U50000.E1(FBD_D33) U51200.A3(DQ4_A)
FBD_D34: U50000.F3(FBD_D34) U51200.E3(DQ6_A)
FBD_D35: U50000.F5(FBD_D35) U51200.B4(DQ1_A)
FBD_D36: U50000.D2(FBD_D36) U51200.F2(DQ3_A)
FBD_D37: U50000.D1(FBD_D37) U51200.B2(DQ5_A)
FBD_D38: U50000.C3(FBD_D38) U51200.G2(DQ0_A)
FBD_D39: U50000.C2(FBD_D39) U51200.E2(DQ2_A)
FBD_D40: U50000.J5(FBD_D40) U51200.B13(DQ10_A)
FBD_D41: U50000.J4(FBD_D41) U51200.A12(DQ14_A)
FBD_D42: U50000.L8(FBD_D42) U51200.B12(DQ12_A)
FBD_D43: U50000.J2(FBD_D43) U51200.B11(DQ11_A)
FBD_D44: U50000.F1(FBD_D44) U51200.E13(DQ8_A)
FBD_D45: U50000.F2(FBD_D45) U51200.G13(DQ15_A)
FBD_D46: U50000.H4(FBD_D46) U51200.E12(DQ13_A)
FBD_D47: U50000.H5(FBD_D47) U51200.F13(DQ9_A)
FBD_D48: U50000.V7(FBD_D48) U51200.V12(DQ10_B)
FBD_D49: U50000.V8(FBD_D49) U51200.U11(DQ9_B)
FBD_D50: U50000.V6(FBD_D50) U51200.U13(DQ8_B)
FBD_D51: U50000.V9(FBD_D51) U51200.N13(DQ14_B)
FBD_D52: U50000.U4(FBD_D52) U51200.U12(DQ13_B)
FBD_D53: U50000.R5(FBD_D53) U51200.P13(DQ11_B)
FBD_D54: U50000.R6(FBD_D54) U51200.M13(DQ15_B)
FBD_D55: U50000.U8(FBD_D55) U51200.P12(DQ12_B)
FBD_D56: U50000.P6(FBD_D56) U51200.U4(DQ1_B)
FBD_D57: U50000.R9(FBD_D57) U51200.P3(DQ5_B)
FBD_D58: U50000.P4(FBD_D58) U51200.U3(DQ3_B)
FBD_D59: U50000.P5(FBD_D59) U51200.V3(DQ0_B)
FBD_D60: U50000.L7(FBD_D60) U51200.U2(DQ2_B)
FBD_D61: U50000.L6(FBD_D61) U51200.N2(DQ7_B)
FBD_D62: U50000.L4(FBD_D62) U51200.P2(DQ4_B)
FBD_D63: U50000.L5(FBD_D63) U51200.M2(DQ6_B)
FBD_DBI0: U50000.AJ1(FBD_DQM0) U51100.D2(DBI0_A)
FBD_DBI1: U50000.AG1(FBD_DQM1) U51100.D13(DBI1_A)
FBD_DBI2: U50000.AA7(FBD_DQM2) U51100.R13(DBI1_B)
FBD_DBI3: U50000.AD5(FBD_DQM3) U51100.R2(DBI0_B)
FBD_DBI4: U50000.D3(FBD_DQM4) U51200.D2(DBI0_A)
FBD_DBI5: U50000.H3(FBD_DQM5) U51200.D13(DBI1_A)
FBD_DBI6: U50000.U5(FBD_DQM6) U51200.R13(DBI1_B)
FBD_DBI7: U50000.M9(FBD_DQM7) U51200.R2(DBI0_B)
FBD_DEBUG0: R50420.1(A) U50000.AD3(FBD_CMD34)
FBD_DEBUG1: R50421.1(A) U50000.J3(FBD_CMD35)
FBD_EDC0: U50000.AJ3(FBD_DQS_WP0) U51100.C2(EDC0_A)
FBD_EDC1: U50000.AG2(FBD_DQS_WP1) U51100.C13(EDC1_A)
FBD_EDC2: U50000.AA9(FBD_DQS_WP2) U51100.T13(EDC1_B)
FBD_EDC3: U50000.AF4(FBD_DQS_WP3) U51100.T2(EDC0_B)
FBD_EDC4: U50000.E3(FBD_DQS_WP4) U51200.C2(EDC0_A)
FBD_EDC5: U50000.H2(FBD_DQS_WP5) U51200.C13(EDC1_A)
FBD_EDC6: U50000.U6(FBD_DQS_WP6) U51200.T13(EDC1_B)
FBD_EDC7: U50000.M5(FBD_DQS_WP7) U51200.T2(EDC0_B)
FBD_WCK01: U50000.AJ8(FBD_WCK01) U51100.D4(WCK0_A)
FBD_WCK01#: U50000.AJ7(FBD_WCK01*) U51100.D5(WCK0_A*)
FBD_WCK23: U50000.AD8(FBD_WCK23) U51100.R11(WCK1_B)
FBD_WCK23#: U50000.AD9(FBD_WCK23*) U51100.R10(WCK1_B*)
FBD_WCK45: U50000.J6(FBD_WCK45) U51200.D4(WCK0_A)
FBD_WCK45#: U50000.J7(FBD_WCK45*) U51200.D5(WCK0_A*)
FBD_WCK67: U50000.P8(FBD_WCK67) U51200.R11(WCK1_B)
FBD_WCK67#: U50000.P7(FBD_WCK67*) U51200.R10(WCK1_B*)
FBD_WCKB01: U50000.AG8(FBD_WCKB01) U51100.D11(WCK1_A)
FBD_WCKB01#: U50000.AG9(FBD_WCKB01*) U51100.D10(WCK1_A*)
FBD_WCKB23: U50000.AC7(FBD_WCKB23) U51100.R4(WCK0_B)
FBD_WCKB23#: U50000.AC8(FBD_WCKB23*) U51100.R5(WCK0_B*)
FBD_WCKB45: U50000.H7(FBD_WCKB45) U51200.D11(WCK1_A)
FBD_WCKB45#: U50000.H6(FBD_WCKB45*) U51200.D10(WCK1_A*)
FBD_WCKB67: U50000.M7(FBD_WCKB67) U51200.R4(WCK0_B)
FBD_WCKB67#: U50000.M8(FBD_WCKB67*) U51200.R5(WCK0_B*)
FBD_ZQ_1_A: R51100.1(A) U51100.J14(ZQ_A)
FBD_ZQ_1_B: R51101.1(A) U51100.K14(ZQ_B)
FBD_ZQ_2_A: R51200.1(A) U51200.J14(ZQ_A)
FBD_ZQ_2_B: R51201.1(A) U51200.K14(ZQ_B)
FBVDD_EN_OR: R53590.1(A) R53591.1(A) U53590.4
FGC6_FB_EN: Q51595.6 R51595.2(B) U4710.M45(GPP_K23/IMGCLKOUT1) U53555.2
FGC6_FB_EN#: Q51595.2 Q51595.3 R51596.1(A)
FGC6_OR_NVVDD_PG: R53585.2(B) U53580.1 U53585.4
G_OVERT#: Q51510.S R51510.1(A) U50000.BG5(OVERT)
GC6_FB_EN#: Q51592.2 Q51592.3 R51593.1(A)
GC6_FB_EN_PCH: Q51592.6 R4922.1(A) R51592.2(B) TP53590.1 U53555.1 U53590.2
GC6_FB_EN_PCH1: R4922.2(B) U4710.T46(GPP_K20)
GPD7: R4793.1(A) U4710.BE41(GPD7)
GPIO0_GPU_VID: R51579.1(A) U50000.BD6(GPIO0)
GPIO1_GC6_FB_EN: Q51592.5 R51570.1(A) TP53930.1 U50000.BB5(GPIO1)
GPIO2_DGPU_EVENT#: Q51545.S R51545.1(A) U50000.BD1(GPIO2)
GPIO4_1V8_MAIN_EN: R51566.1(A) R53512.1(A) U50000.BE1(GPIO4)
GPIO5_FRM_LCK#: R51567.1(A) U50000.BG2(GPIO5)
GPIO6_NVVDD_PSI#: R51584.1(A) U50000.BD2(GPIO6)
GPIO7_LCD_BL_PWM: R51571.1(A) U50000.BD7(GPIO7)
GPIO8_FBVDD_SEL: R51580.1(A) U50000.BH4(GPIO8)
GPIO9_GPU_THERMAL_ALERT#: R51540.1(A) U50000.BJ3(GPIO9)
GPIO10_MEM_VREF_CTL: R51572.1(A) U50000.BD3(GPIO10)
GPIO11_LCD_VDD_EN: R51573.1(A) U50000.BH3(GPIO11)
GPIO12_DGPU_PWRLEVEL: Q51550.S R51550.1(A) U50000.BE6(GPIO12)
GPIO14_IFPA_HPD: R51560.1(A) U50000.BG4(GPIO14)
GPIO15_IFPB_HPD: R51561.1(A) U50000.BG1(GPIO15)
GPIO17_IFPD_HPD: R51563.1(A) U50000.BH1(GPIO17)
GPIO18_IFPE_HDMI_HPD: Q56470.3 R51564.1(A) U50000.BE3(GPIO18)
GPIO20_FL_SYNC_GPU_FGC6: Q51595.5 R51574.1(A) U50000.BE5(GPIO20)
GPIO20_OR_FGC6: R53551.2(B) R53555.2(B) U53555.4 U53585.1
GPIO21_GPU: R51575.1(A) U50000.BA5(GPIO21)
GPIO22_GPU: R51568.1(A) U50000.BB6(GPIO22)
GPIO23_GPU: R51576.1(A) U50000.BG3(GPIO23)
GPIO24_IFPF_HPD: R51565.1(A) U50000.BD5(GPIO24)
GPIO25_FBVDD_PSI#: R51582.1(A) U50000.BB2(GPIO25)
GPIO26_FP_FUSE: R52101.2(B) U50000.BE7(GPIO26) UU52100.C2
GPIO27_IFPC_DP_HPD: Q56260.3(C) R51562.1(A) U50000.BA4(GPIO27)
GPIO28_ADC_MUX_SEL: R51569.1(A) R52003.2(B) U50000.BB4(GPIO28)
GPIO29_IDLE_IN_SW: R51577.1(A) U50000.BA3(GPIO29)
GPP_A7: R4813.1(A) U4710.BA36(GPP_A7/PIRQA#/ESPI_ALERT0#)
GPP_B22: R4826.2(B) U4710.BA26(GPP_B22/GSPI1_MOSI)
GPP_F3: TP4704.1 U4710.AM47(GPP_F3/SATAXPCIE6/SATAGP6)
GPP_F14: R4779.1(A) R4787.2(B) U4710.AP41(GPP_F14/EXT_PWR_GATE#/PS_ON#)
GPP_H19: R4811.1(A) U4710.AH46(GPP_H19/ISH_I2C0_SDA)
GPP_H20: R4818.1(A) U4710.AG45(GPP_H20/ISH_I2C0_SCL)
GPPJ_RCOMP: R4607.1(A) U4710.BD1(GPPJ_RCOMP_1P81) U4710.BE1(GPPJ_RCOMP_1P82) U4710.BE2(GPPJ_RCOMP_1P83)
GPU_DP_AUX: C51631.2(B) CN56200.16 D56230.1 D56230.10 Q51650.2(S) R51650.2(B)
GPU_DP_AUX#: C51630.2(B) CN56200.18 D56230.2 D56230.9 Q51630.2(S) R51630.1(A)
GPU_EN: C53572.2(B) D53571.1(A2) R53571.2(B) R55211.1(A) TP53572.1 TP67001.1 U67000.36(EN)
GPU_EVENT_PCH#: Q51545.D R4921.1(A) TP51545.1
GPU_FB_VREF: C52200.1(A) R52200.1(A) TP52200.1 U50000.P45(FB_VREF)
GPU_GND_SENSE: R52111.2(B) R67001.2(B)
GPU_HDMI_CLKN: C51700.1(A) U50000.BG14(IFPE_L3*)
GPU_HDMI_CLKP: C51701.1(A) U50000.BH14(IFPE_L3)
GPU_HDMI_D0N: C51702.1(A) U50000.BF14(IFPE_L2*)
GPU_HDMI_D0P: C51703.1(A) U50000.BE14(IFPE_L2)
GPU_HDMI_D1N: C51704.1(A) U50000.BF15(IFPE_L1*)
GPU_HDMI_D1P: C51705.1(A) U50000.BG15(IFPE_L1)
GPU_HDMI_D2N: C51706.1(A) U50000.BG17(IFPE_L0*)
GPU_HDMI_D2P: C51707.1(A) U50000.BH17(IFPE_L0)
GPU_HDMI_SCL: R51712.1(A) U50000.BK8(IFPE_AUX_SCL)
GPU_HDMI_SDA: R51711.1(A) U50000.BL8(IFPE_AUX_SDA*)
GPU_ID: R338.2(B) R343.1(A) U1.73(ADC7/CTS1#/GPI7<3>)
GPU_NVVDD_SENSE: R52110.2(B) R67000.2(B)
GPU_OVERT_EC#: D51510.3(A1) Q51510.D R51511.1(A) TP51511.1 U1.99(ID6/GPH6)
GPU_OVERT_NVVDD#: D51510.1(A2) R53515.1(A)
GPU_PG: C53530.2(B) R53530.2(B) R53531.1(A) U67000.38(PGOOD)
GPU_PLLVDD_XS_SP: C51300.1(A) C51301.1(A) C51302.1(A) C51303.1(A) C51304.1(A) C51305.1(A) C51306.1(A) L51300.2(INB) R51616.1(A) R51720.1(A) TP51300.1 U50000.AF11(GPCPLL_AVDD1) U50000.BB24(XSN_PLLVDD) U50000.BC12(VID_PLLVDD) U50000.BD12(SP_PLLVDD) U50000.U42(GPCPLL_AVDD0)
GPU_THM_CLK: C311.1(A) R305.2(B) R328.2(B) U1.94(CRX1/SIN1/SMCLK3/GPH1/ID1)
GPU_THM_DAT: C312.1(A) R303.2(B) R329.2(B) U1.95(CTX1/SOUT1/GPH2/SMDAT3/ID2)
H_PECI: R4514.2(B) U4555.BT34(PECI)
H_PM_DOWN: R4513.1(A) U4710.AE2(PM_DOWN)
H_PM_DOWN_R: R4513.2(B) U4555.BP31(PM_DOWN)
H_PM_SYNC: R4778.2(B) U4555.BM34(PM_SYNC)
H_PM_SYNC_R: R4778.1(A) U4710.AF3(PM_SYNC)
H_PRDY#: R4799.2(B) U4555.BP27(PROC_PRDY#)
H_PREQ#: R4798.2(B) U4555.BL30(PROC_PREQ#)
H_PWRGD: C4704.1(A) U4555.BT31(PROCPWRGD) U4710.AE3(CPUPWRGD)
H_TCK: R4508.1(A) R4532.2(B) U4555.BR28(PROC_TCK)
H_TDI: R4515.1(A) R4797.2(B) U4555.BL32(PROC_TDI)
H_TDO: R4516.1(A) R4796.2(B) U4555.BT28(PROC_TDO)
H_THERM#: R4455.2(B) U4450.4
H_THERMDA: C4451.1(A) Q4450.1(B) Q4450.3(C) U4450.2
H_THERMDC: C4451.2(B) Q4450.2(E) U4450.3
H_TMS: R4510.1(A) R4794.2(B) U4555.BP28(PROC_TMS)
H_TRST#: R4801.2(B) U4555.BP30(PROC_TRST#)
HDA_BCLK: R506.2(B) R4972.1(A)
HDA_R_BCLK: R4972.2(B) U4710.BD11(HDA_BCLK/I2S0_SCLK)
HDA_R_BITCLK: C510.1(A) R506.1(A) U500.6(BIT-CLK)
HDA_R_RST#: R4901.2(B) U4710.BE10(HDA_RST#/I2S1_SCLK)
HDA_R_SDIN0: R507.1(A) U500.8(SDATA-IN)
HDA_R_SYNC: R4903.2(B) U4710.BG13(HDA_SYNC/I2S0_SFRM)
HDA_RST#: R4901.1(A) U500.11(RESETB)
HDA_SDIN0: R507.2(B) U4710.BE11(HDA_SDI0/I2S0_RXD)
HDA_SDO: R4869.1(A) U500.5(SDATA-OUT)
HDA_SDO_R: R4861.2(B) R4869.2(B) U4710.BF12(HDA_SDO/I2S0_TXD)
HDA_SYNC: R4903.1(A) U500.10(SYNC)
HDMI_CN_DDCCLK: CN56600.15 D56652.4 D56652.7 Q56690.3 R56679.2(B)
HDMI_CN_DDCDATA: CN56600.16 D56652.5 D56652.6 Q56690.6 R56677.2(B)
HDMI_CN_HPD: C56631.1(A) CN56600.19 R56620.2(B) R56621.2(B)
HDMI_DDCCLK: R4935.1(A) U4710.AL9(GPP_I9/DDPD_CTRLCLK)
HDMI_DDCDATA: R4919.1(A) U4710.AR3(GPP_I10/DDPD_CTRLDATA)
HDMI_GPU_SCL: Q56690.4 R51712.2(B) R56691.1(A)
HDMI_GPU_SDA: Q56690.1 R51711.2(B) R56692.1(A)
HDMI_HPDET: TP4807.1 U4710.AP9(GPP_I2/DPPD_HPD2/DISP_MISC2)
HDMI_ISP_SCL: R56676.1(A) U56400.10(ISPSCL)
HDMI_ISP_SDA: R56673.1(A) U56400.11(ISPSDA)
HDMI_MB_HPD#: Q56470.6 R56472.1(A) U4710.BF35(GPP_A18/ISH_GP0)
HDMI_MPC_SCL: R56413.1(A) R56463.1(A) U56400.1(MPCSCL) U56400.33(PCSCL)
HDMI_MPC_SDA: R56414.1(A) R56462.1(A) U56400.2(MPCSDA) U56400.32(PCSDA)
HDMI_NV_Q_HPD: Q56470.2 Q56470.5 R56470.2(B) R56471.1(A)
HDMI_OUT_CLKN: C51700.2(B) U56400.45(RXCM)
HDMI_OUT_CLKP: C51701.2(B) U56400.44(RXCP)
HDMI_OUT_D0N: C51702.2(B) U56400.43(RX0M)
HDMI_OUT_D0P: C51703.2(B) U56400.42(RX0P)
HDMI_OUT_D1N: C51704.2(B) U56400.40(RX1M)
HDMI_OUT_D1P: C51705.2(B) U56400.39(RX1P)
HDMI_OUT_D2N: C51706.2(B) U56400.38(RX2M)
HDMI_OUT_D2P: C51707.2(B) U56400.37(RX2P)
HDMI_OUT_R_HPD: D56652.1 D56652.10 R56620.1(A) U56400.12(TXHPD)
HDMI_RET_HPD: R56471.2(B) U56400.5(RXHPD)
HDMI_RET_SCL: R56674.1(A) U56400.35(RXSCL)
HDMI_RET_SDA: R56671.1(A) U56400.34(RXSDA)
HDMI_TXSCL: R56411.1(A) U56400.29(TXSCL)
HDMI_TXSDA: R56410.1(A) U56400.30(TXSDA)
HP_L: C602.2(B) R605.1(A) R606.2(B) U500.32(HP-OUT-L)
HP_R: C603.2(B) R604.1(A) R607.2(B) U500.33(HP-OUT-R)
HP_R_L: CN603.3 R605.2(B)
HP_R_R: CN603.2 R604.2(B)
HPGP_W_DISABLE#: Q1312.3(D) R4824.1(A) U4710.AR18(GPP_D15/ISH_UART0_RTS#/GSPI2_CS1#/CNV_WFEN)
HPS: CN603.8 R502.2(B)
HW_I_ADC: C60007.1(A) C60008.1(A) R351.1(A) U60000.7
I2C_CLK_LED: Q700.1(S1) R701.2(B) U702.25(SCL)
I2C_DATA_LED: Q700.4(S2) R700.2(B) U702.26(SDA)
I2C_RST#: Q51520.2 Q51520.5 Q51530.2 Q51530.5 R51525.1(A) R51526.2(B)
I2CB_SCL_G: R51500.1(A) U50000.BG8(I2CB_SCL)
I2CB_SDA_G: R51501.1(A) U50000.BF8(I2CB_SDA)
I2CC_SCL: Q51520.3 R67007.2(B) U67000.35(SCL)
I2CC_SCL_G: R51521.1(A) TP51521.1 U50000.BG9(I2CC_SCL)
I2CC_SCL_R_G: Q51520.4 R51521.2(B) R51523.1(A)
I2CC_SDA: Q51520.6 R67006.2(B) U67000.34(SDA)
I2CC_SDA_G: R51522.1(A) TP51522.1 U50000.BH9(I2CC_SDA)
I2CC_SDA_R_G: Q51520.1 R51522.2(B) R51524.1(A)
I2CS_SCL_G: R51531.1(A) TP51531.1 U50000.BJ8(I2CS_SCL)
I2CS_SCL_R_G: Q51530.4 R51531.2(B) R51533.1(A)
I2CS_SDA_G: R51532.1(A) TP51532.1 U50000.BH8(I2CS_SDA)
I2CS_SDA_R_G: Q51530.1 R51532.2(B) R51534.1(A)
I_ADP_R: C351.2(B) R351.2(B) U1.72(ADC6/DSR1#/GPI6<3>)
ICM_SH_01: C52010.2(B) R52010.2(B) U52000.32(SH_O1)
ICM_SH_02: C52020.2(B) R52020.2(B) U52000.7(SH_O2)
IDCHG: C60005.1(A) R307.2(B) U60000.8
IFPC_RSET: R51615.2(B) U50000.BD20(IFPCD_RSET)
IFPCD_PLLVDD: C51616.1(A) R51616.2(B) U50000.BD18(IFPCD_PLLVDD)
IFPE_PLLVDD: C51720.1(A) R51720.2(B) U50000.BD15(IFPE_PLLVDD)
IFPE_RSET: R51721.2(B) U50000.BD17(IFPE_RSET)
ILIM_HI: R2551.1(A) U2501.16
ILIM_LO: R2552.1(A) U2501.15
IMVP_PSYS: R66195.1(A) U60000.9
INTRUDER#: R4833.1(A) U4710.BB44(INTRUDER#)
INV_PWM_PCH: R3005.1(A) U4710.AU48(GPP_F21/EDP_BKLTCTL)
IRMT_HOLD_RST#: R4823.1(A) R50021.1(A) TP50021.1 U50020.2
ISCT_WLANPW_EN#: Q1300.2(S) U1.78(DAC2/TACH0B/GPJ2<3>)
IST_TRIG: TP4523.1 U4555.E3(IST_TRIG)
ITP_PMODE: R4891.2(B) U4710.AL3(ITP_PMODE)
KB_BLON: Q251.G Q702.G U1.32(PWM6/SSCK/GPA6)
KB_RST#: R4723.1(A) U1.4(KBRST#/GPB6<3>) U4710.BE39(GPP_A0/RCIN#/ESPI_ALERT1#)
KEYBOARD_ID: R392.2(B) R393.2(B) U1.86(PS2DAT0/TMB1/GPF1)
LAN_DEBUG: R405.1(A) U400.5
LAN_LED2: R419.1(A) TP401.1 U400.23
LAN_LX: L400.1(INA) U400.40
LAN_MDI0N: D402.2 D402.9 U400.12 U401.2(TD1-)
LAN_MDI0P: D402.1 D402.10 U400.11 U401.1(TD+)
LAN_MDI1N: D402.5 D402.6 U400.15 U401.6
LAN_MDI1P: D402.4 D402.7 U400.14 U401.5
LAN_MDI2N: D403.2 D403.9 U400.18 U401.8
LAN_MDI2P: D403.1 D403.10 U400.17 U401.7
LAN_MDI3N: D403.5 D403.6 U400.21 U401.12(TD4-)
LAN_MDI3P: D403.4 D403.7 U400.20 U401.11
LAN_PPS: TP400.1 U400.24
LAN_TRD0_CN_DN: JACK400.2 U401.23(TX1-)
LAN_TRD0_CN_DP: JACK400.1 U401.24(TX+)
LAN_TRD1_CN_DN: JACK400.6 U401.19
LAN_TRD1_CN_DP: JACK400.3 U401.20
LAN_TRD2_CN_DN: JACK400.5 U401.17
LAN_TRD2_CN_DP: JACK400.4 U401.18
LAN_TRD3_CN_DN: JACK400.8 U401.13(TX4-)
LAN_TRD3_CN_DP: JACK400.7 U401.14(TX4+)
LCM_BKLTEN: R349.2(B) R3013.1(A) U1.20(L80LLAT/GPE7) U4710.AV46(GPP_F20/EDP_BKLTEN)
LCM_VDDEN: R40.2(B) U4710.AV44(GPP_F19/EDP_VDDEN)
LED_A_B: CN252.10 U702.5(#OUT2)
LED_A_G: CN252.11 U702.4(#OUT1)
LED_A_R: CN252.12 U702.3(#OUT0)
LED_ACT: R418.2(B) TP403.1 U400.38
LED_B_B: CN252.7 U702.10(#OUT6)
LED_B_G: CN252.8 U702.9(#OUT5)
LED_B_R: CN252.9 U702.8(#OUT4)
LED_C_B: CN252.4 U702.16(#OUT10)
LED_C_G: CN252.5 U702.15(#OUT9)
LED_C_R: CN252.6 U702.14(#OUT8)
LED_D_B: CN252.1 U702.21(#OUT14)
LED_D_G: CN252.2 U702.20(#OUT13)
LED_D_R: CN252.3 U702.19(#OUT12)
LED_LINK: R417.2(B) TP402.1 U400.39
LID_SW#: C253.1(A) CN254.3 R28.1(A) R302.2(B) U250.OUTPUT
LID_SW#_R: R302.1(A) U1.84(EGCLK/GPE3)
LID_SW#_S: C50.1(A) CN1.3 U50.OUTPUT
LID_SW_LCM#: D3000.1(A1) R336.2(B) R3014.2(B) U1.96(ID3/GPH3)
LINE1_L: C602.1(A) U500.22(LINE1-L)
LINE1_R: C603.1(A) U500.21(LINE1-R)
LINE1_REF_L: R606.1(A) U500.31(LINE1-VREFO-L)
LINE1_REF_R: R607.1(A) U500.30(LINE1-VREFO-R)
LOCAL_SHUTDOWN#: C65.1(A) C321.2(B) R25.2(B) R26.1(A) U1.66(ADC0/GPI0<3>)
LOW_PWR_VTG_SHIFT: R60524.2(B)
LOW_PWR_VTG_SHIFT_N: R60525.2(B)
LP#: R7068.1(A) R60522.2(B) U60500.6
LPC_AD<0>: CN301.2 R4846.2(B) U1.10(LAD0/GPM0<3>)
LPC_AD<1>: CN301.3 R4847.2(B) U1.9(LAD1/GPM1<3>)
LPC_AD<2>: CN301.4 R4848.2(B) U1.8(LAD2/GPM2<3>)
LPC_AD<3>: CN301.5 R4849.2(B) U1.7(LAD3/GPM3<3>)
LPC_ESPI_CLK: R4850.1(A) R4852.1(A) U4710.BB36(GPP_A9/CLKOUT_LPC0/ESPI_CLK)
LPC_ESPI_IO0: R4846.1(A) U4710.BB39(GPP_A1/LAD0/ESPI_IO0)
LPC_ESPI_IO1: R4847.1(A) U4710.AW37(GPP_A2/LAD1/ESPI_IO1)
LPC_ESPI_IO2: R4848.1(A) U4710.AV37(GPP_A3/LAD2/ESPI_IO2)
LPC_ESPI_IO3: R4849.1(A) U4710.BA38(GPP_A4/LAD3/ESPI_IO3)
LPC_FRAME#: CN301.7 U1.6(LFRAME#/GPM5<3>) U4710.BE38(GPP_A5/LFRAME#/ESPI_CS0#)
