# Allegro board PH317-53 COVINI-6050A3087701-MB-AX2 (BDV)(.BRD).brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
FBC_CMD2_RST: length 36
  BOTTOM w0.137: U50900.J1 207.26,99.34 205.62,97.7 R50906.1 204.69,97.42 203.84,98.27 200.45,98.27 198.71,100.01 198.33,100.47 198.29,100.51 198.29,102.44 192.4,108.33 192.4,108.82 190.06,111.16 190.06,117.69 187.97,119.78 U50000.A11
FBC_CMD3: length 40.5
  L10 w0.086: v4(206.07,98.74) 206.4,99.4 206.4,99.78 206.5,100.23 206.5,101.82 206.71,102.39 v4(206.88,102.56)
  BOTTOM w0.109: U50900.J4 v4(206.88,102.56) U50900.K4
  BOTTOM w0.137: v4(206.07,98.74) 205.81,98.47 204.24,98.47 204.07,98.64 200.61,98.64 198.99,100.27 198.72,100.6 198.72,102.6 193.72,107.6 193.72,108.23 190.51,111.45 190.51,117.69 188.07,120.13 185.45,120.13 U50000.D11
FBC_CMD4: length 36.7
  L8 w0.086: v4(206.13,101.81) 206.51,101.44 206.51,99.99 206.4,99.89 206.4,99.32 206.21,99.13 205.92,99.13 205.7,98.91 v1(205.47,98.91)
  BOTTOM w0.137: v1(205.47,98.91) 205.34,99.04 200.79,99.04 199.12,100.71 199.12,102.81 194.26,107.67 194.26,108.46 190.86,111.86 190.86,117.86 188.23,120.48 U50000.A12 ; v4(206.13,101.81) U50900.L3
FBC_CMD5: length 31
  BOTTOM w0.137: U50900.M4 204.63,102.57 204.63,103.45 204.27,103.81 199.92,103.81 199.72,103.61 199.19,103.61 198.87,103.61 194.72,107.77 194.72,108.97 191.31,112.37 191.31,117.91 188.39,120.83 187.06,120.83 186.71,120.48 U50000.B12
FBC_CMD6: length 33.7
  BOTTOM w0.109: U50900.K5 206.87,103.3 207.23,102.94 U50900.J5
  BOTTOM w0.137: 206.87,103.3 206.33,103.84 204.75,103.84 204.52,104.07 199.62,104.07 199.54,103.99 199.03,103.99 195.09,107.92 195.09,109.3 191.69,112.7 191.69,117.98 188.6,121.06 186.96,121.06 186.72,120.83 186.36,120.83 186.01,120.48 U50000.C12
FBC_CMD7: length 37.6
  L8 w0.076: v4(208.27,103.51) 208.27,103.74 208.08,103.93 207.23,103.93 207.14,103.85 v4(207.14,103.58) 205.54,103.58 v4(205.4,103.44)
  BOTTOM w0.109: U50900.L5 v4(205.4,103.44) ; v4(208.27,103.51) 208.13,103.2 U50900.H5
  BOTTOM w0.137: v4(207.14,103.58) 206.55,104.17 204.89,104.17 204.72,104.34 199.8,104.34 199.72,104.42 199.22,104.42 195.69,107.94 195.69,109.41 192.07,113.03 192.07,118.13 188.9,121.3 186.89,121.3 186.88,121.31 186.86,121.31 186.64,121.54 186.37,121.54 186.03,121.88 U50000.C14
FBC_CMD8: length 35.4
  BOTTOM w0.137: U50900.G4 209.13,102.56 209.13,103.26 208.22,104.18 207.1,104.18 206.8,104.48 205.06,104.48 204.94,104.6 199.96,104.6 199.74,104.82 199.35,104.82 196.33,107.84 196.33,109.49 192.45,113.37 192.45,118.29 189.2,121.54 186.99,121.54 186.65,121.88 U50000.B14
FBC_CMD9: length 35.2
  BOTTOM w0.137: U50000.A14 189.39,121.88 192.83,118.45 192.83,113.72 197.04,109.51 197.04,107.67 199.51,105.2 199.7,105.2 200.06,104.84 205.04,104.84 205.05,104.83 206.65,104.83 207.05,105.23 208.84,105.23 209.13,105.52 209.13,107.06 U50900.G11
FBC_CMD10_CKE: length 38.9
  TOP w0.137: v4(206.45,105.3) 206.41,105.34 R50905.1
  L8 w0.076: v4(208.61,106.2) 208.59,106.2 208.19,106.03 v4(206.45,105.3) v4(204.66,105.96)
  BOTTOM w0.109: U50900.G10 208.76,106.34 v4(208.61,106.2) ; U50900.M10 205.01,106.31 v4(204.66,105.96)
  BOTTOM w0.137: v4(206.45,105.3) 206.43,105.3 206.27,105.15 206.11,105.15 205.88,105.37 205.69,105.37 205.47,105.15 200.1,105.15 197.96,107.28 197.96,109.33 193.21,114.09 193.21,118.6 189.58,122.23 185.45,122.23 U50000.D14
FBC_CMD11: length 34.6
  BOTTOM w0.109: U50900.H10 208.11,106.58 208.11,106.26 207.76,105.9 207.11,105.9 206.96,105.74 206.77,105.94 205.98,105.94 205.76,106.16 U50900.L10
  BOTTOM w0.137: 206.96,105.74 206.91,105.69 205.51,105.69 205.25,105.43 200.35,105.43 198.51,107.28 198.51,109.5 193.59,114.42 193.59,118.76 189.79,122.56 187.22,122.56 U50000.A15
FBC_CMD12: length 30.8
  BOTTOM w0.137: U50000.B15 186.71,122.58 187.04,122.9 189.98,122.9 193.96,118.92 193.96,114.79 199.1,109.65 199.1,107.28 200.69,105.69 204.03,105.69 204.23,105.89 204.23,106.1 204.63,106.5 204.63,107.06 U50900.M11
FBC_CMD13: length 31.3
  L8 w0.086: v4(206.1,110.1) 205.78,109.78 205.78,108.14 v4(206.1,107.82)
  BOTTOM w0.137: v4(206.1,107.82) 205.76,108.16 U50900.L12 ; U50000.C15 185.99,122.58 186.34,122.93 186.7,122.93 186.93,123.16 188.69,123.16 188.77,123.24 190.18,123.24 194.34,119.07 194.34,115.28 199.09,110.54 205.66,110.54 v4(206.1,110.1)
FBC_CMD14: length 35.1
  L8 w0.086: v1(207.35,111.52) 207.25,111.43 207.25,107.48 v4(206.88,107.11)
  BOTTOM w0.109: U50900.K11 206.84,107.11 v4(206.88,107.11) 206.93,107.11 U50900.J11
  BOTTOM w0.137: v1(207.35,111.52) 207.35,111.27 207.11,111.04 199.31,111.04 196.99,113.36 194.73,115.62 194.73,116.44 194.73,119.26 191.13,122.87 191.13,122.9 190.5,123.52 188.35,123.52 188.23,123.4 186.91,123.4 186.69,123.62 186.34,123.62 185.99,123.98 U50000.C17
FBC_CMD15: length 31.3
  L8 w0.086: v4(206.88,108.56) 206.48,108.96 206.48,111.12 v1(206.08,111.52)
  BOTTOM w0.109: U50900.J12 207.25,108.19 v4(206.88,108.56) U50900.K12
  BOTTOM w0.137: v1(206.08,111.52) 199.54,111.52 195.11,115.95 195.11,119.42 191.13,123.4 191.13,123.43 190.76,123.8 188.23,123.8 188.07,123.64 187.05,123.64 186.71,123.98 U50000.B17
FBC_CMD16: length 30.9
  L10 w0.086: v4(209.18,126.03) 208.78,125.63 208.78,123.75 208.53,123.5 208.01,123.5 v4(207.63,123.12)
  BOTTOM w0.137: v4(207.63,123.12) U51000.L3 ; v4(209.18,126.03) 209.18,126.91 207.46,128.63 203.2,128.63 202.41,127.84 198.12,127.84 195.31,130.65 190.88,130.65 189.45,129.22 187.05,129.22 186.71,128.88 U50000.B24
FBC_CMD17: length 28.6
  L10 w0.086: v4(206.87,123.86) 207.25,124.24 207.25,124.92 v4(207.79,125.47)
  BOTTOM w0.109: U51000.K3 206.89,123.86 v4(206.87,123.86) U51000.J3
  BOTTOM w0.137: v4(207.79,125.47) 207.79,126.04 208.32,126.56 208.32,127.22 207.31,128.22 203.32,128.22 202.57,127.46 197.89,127.46 197.36,127.99 196.57,127.99 194.29,130.27 190.89,130.27 189.5,128.88 U50000.A24
FBC_CMD18_RST: length 26.1
  BOTTOM w0.137: U51000.J1 206.63,125.12 206.63,126.47 206.15,126.94 R51006.1 205.46,127.69 204.85,127.08 196.74,127.08 193.95,129.87 190.92,129.87 189.58,128.53 185.45,128.53 U50000.D23
FBC_CMD19: length 25.8
  L10 w0.086: v4(206.06,126.04) 206.5,125.6 206.5,122.76 v4(206.88,122.37)
  BOTTOM w0.109: U51000.J4 v4(206.88,122.37) U51000.K4
  BOTTOM w0.137: v4(206.06,126.04) 205.74,126.35 196.91,126.35 193.88,129.38 190.87,129.38 189.74,128.26 187.27,128.26 U50000.A23
FBC_CMD20: length 24.2
  L10 w0.086: v4(205.38,125.37) 205.76,124.99 205.76,123.49 v4(206.14,123.11)
  BOTTOM w0.137: v4(205.38,125.37) 204.84,125.92 199.44,125.92 199.29,125.76 196.9,125.76 193.69,128.97 190.89,128.97 189.89,127.97 187.51,127.97 187.39,127.85 187.04,127.85 186.71,128.18 U50000.B23 ; v4(206.14,123.11) U51000.H3
FBC_CMD21: length 25.1
  BOTTOM w0.137: U50000.C23 185.91,128.18 186.25,127.84 186.64,127.84 186.88,127.6 187.57,127.6 187.7,127.73 190.08,127.73 190.09,127.74 190.11,127.74 190.88,128.5 193.57,128.5 199.79,122.28 199.79,121.77 200.02,121.54 201.5,121.54 202.07,120.97 202.44,120.97 203,121.53 205.11,121.53 205.37,121.8 205.37,121.84 205.38,122.15 205.37,122.15 205.37,122.38 U51000.G4
FBC_CMD22: length 26.6
  L8 w0.086: v4(205.8,121.44) 205.89,121.53 v4(206.87,121.53)
  BOTTOM w0.109: U51000.K5 207.26,121.91 v4(206.87,121.53) 206.51,121.89 U51000.J5
  BOTTOM w0.137: U50000.C21 186.01,126.78 186.36,127.13 186.7,127.13 186.93,127.36 190.2,127.36 190.91,128.07 193.26,128.07 194.35,126.98 194.35,126.81 194.99,126.17 195.37,126.17 199.41,122.12 199.41,121.62 199.77,121.26 201.39,121.26 201.94,120.71 202.62,120.71 203.1,121.19 205.56,121.19 v4(205.8,121.44)
FBC_CMD23: length 27.3
  BOTTOM w0.109: U51000.L5 207.33,121.32 206.87,121.04 206.86,121.05 206.64,121.11 U51000.H5
  BOTTOM w0.137: U50000.B21 186.74,126.78 187.06,127.1 187.33,127.1 187.37,127.07 190.3,127.07 190.9,127.67 192.95,127.67 193.97,126.65 193.97,126.65 194.84,125.79 195.21,125.79 199.01,122 199.01,121.44 199.57,120.88 201.31,120.88 201.76,120.43 202.82,120.43 203.24,120.85 206.67,120.85 206.86,121.05
FBC_CMD24: length 26.8
  BOTTOM w0.137: U50000.A21 190.42,126.78 190.93,127.29 192.62,127.29 194.7,125.21 195.25,125.21 198.6,121.87 198.6,121.32 199.41,120.5 201.17,120.5 201.52,120.15 203,120.15 203.43,120.59 207.76,120.59 208.39,121.21 208.39,122.38 U51000.M4
FBC_CMD25: length 30.7
  BOTTOM w0.137: U50000.D20 185.45,126.43 190.44,126.43 190.93,126.92 192.44,126.92 195.27,124.08 195.85,124.08 198.22,121.71 198.22,121.16 199.26,120.12 201.13,120.12 201.38,119.86 203.29,119.86 203.74,120.31 208.89,120.31 209.23,119.97 209.23,118.52 209.13,118.42 209.13,117.87 U51000.M11
FBC_CMD26_CKE: length 34.1
  TOP w0.137: v4(207.38,119.45) 207.38,119.48 R51005.1
  L8 w0.076: v4(205.45,119.31) 206.42,119.05 206.63,119.05 v4(207.38,119.45) 207.55,119.28 208.97,119.28 209.19,119.05 209.19,118.84 209.11,118.75 v4(208.83,118.75)
  BOTTOM w0.109: v4(208.83,118.75) 208.83,118.32 U51000.M10 ; U51000.G10 v4(205.45,119.31)
  BOTTOM w0.137: v4(207.38,119.45) 208.7,119.45 208.86,119.6 208.86,119.9 208.69,120.06 204.06,120.06 203.58,119.58 201.28,119.58 201.13,119.74 199.42,119.74 199.11,119.74 197.84,121 197.84,121.56 196.45,122.94 195.87,122.94 192.28,126.54 190.95,126.54 190.56,126.14 187.26,126.14 U50000.A20
FBC_CMD27: length 28.4
  BOTTOM w0.109: U51000.L10 208.11,118.35 208.11,118.78 207.87,119.02 205.97,119.02 205.76,118.81 205.76,118.78 U51000.H10
  BOTTOM w0.137: U50000.B20 186.69,126.08 187.03,125.74 187.51,125.74 187.64,125.87 187.64,125.87 187.66,125.88 190.76,125.88 191.04,126.16 192.12,126.16 196.47,121.82 196.8,121.82 197.46,121.15 197.46,120.85 198.97,119.34 203.85,119.34 204.25,119.75 206.25,119.75 206.33,119.82 206.79,119.82 206.99,119.62 206.99,119.02
FBC_CMD28: length 23.8
  BOTTOM w0.137: U50000.C20 185.99,126.08 186.34,125.73 186.64,125.73 186.87,125.5 187.6,125.5 187.61,125.5 187.73,125.63 191.01,125.63 191.16,125.78 191.97,125.78 197.51,120.24 197.51,120.02 198.61,118.92 199.74,118.92 199.88,119.06 204.49,119.06 204.63,118.91 204.63,117.87 U51000.G11
FBC_CMD29: length 32.9
  L10 w0.086: v4(204.67,113.72) 205.46,113.72 205.76,114.02 205.76,114.25 206.5,114.99 206.5,116.68 206.09,117.08 v4(206.09,117.12)
  BOTTOM w0.137: v4(204.67,113.72) 204.63,113.72 204.62,113.74 203.94,113.74 203.8,113.88 203.8,114.09 203.67,114.23 203.39,114.23 203.25,114.09 203.25,113.88 203.12,113.74 202.84,113.74 202.71,113.88 202.71,114.09 202.57,114.23 202.29,114.23 202.16,114.09 202.16,113.88 202.02,113.74 201.75,113.74 201.61,113.88 201.61,114.09 201.47,114.23 201.2,114.23 201.06,114.09 201.06,113.88 200.92,113.74 200.64,113.74 199.16,115.22 199.16,116.97 197.01,119.12 197.01,120.2 191.81,125.4 191.27,125.4 191.2,125.33 187.78,125.33 187.71,125.26 187.71,125.26 187.7,125.26 186.86,125.26 186.61,125 186.36,125 186.04,124.68 U50000.C18 ; v4(206.09,117.12) 206.05,117.08 206.05,117.08 205.76,116.79 U51000.H12
FBC_CMD30: length 33.2
  L10 w0.086: v4(206.35,114.17) 206.78,114.17 207.27,114.66 207.27,115.99 v4(206.88,116.37)
  BOTTOM w0.109: U51000.K12 v4(206.88,116.37) U51000.J12
  BOTTOM w0.137: U50000.B18 186.7,124.68 187.04,125.02 187.8,125.02 187.8,125.02 191.65,125.02 196.63,120.05 196.63,118.23 197.43,117.43 197.89,117.43 198.5,116.82 198.5,115.35 200.46,113.39 204,113.39 204.33,113.06 204.58,113.06 204.72,113.2 204.72,113.23 204.86,113.36 205.13,113.36 205.27,113.23 205.27,113.2 205.41,113.06 205.61,113.06 205.89,113.34 205.89,114.63 206.03,114.76 206.22,114.76 206.35,114.63 v4(206.35,114.17)
FBC_CMD31: length 32.9
  L8 w0.086: v4(206.89,117.86) 206.89,117.83 206.5,117.44 206.5,115.36 206.61,115.25 207.05,115.25 207.23,115.07 207.23,114.33 207.35,114.21 v1(207.35,114.17)
  BOTTOM w0.109: U51000.K11 v4(206.89,117.86) U51000.J11
  BOTTOM w0.137: U50000.A18 187.23,124.64 191.5,124.64 196.25,119.89 196.25,117.31 197.41,116.16 197.41,115.9 200.32,112.99 203.78,112.99 204.13,112.64 205.69,112.64 207.17,114.11 207.29,114.11 v1(207.35,114.17)
FBC_CMD32: length 34.7
  L8 w0.086: v4(207.67,107.81) 208.01,108.16 208.51,108.16 208.77,108.42 v1(208.77,111.48)
  BOTTOM w0.137: v4(207.67,107.81) 208.01,108.15 U50900.H12 ; U50000.A17 187.91,123.98 187.98,124.04 191.03,124.04 195.49,119.58 195.49,116.4 199.92,111.96 206.08,111.96 207.01,112.89 208,112.89 208.77,112.12 v1(208.77,111.48)
FBC_CMD33: length 35.5
  L8 w0.086: v4(207.63,117.12) 208.01,116.75 208.59,116.75 208.77,116.57 208.77,114.43 v1(208.36,114.03)
  BOTTOM w0.137: v1(208.36,114.03) 208.36,113.94 207.83,113.41 206.97,113.41 205.86,112.31 203.95,112.31 203.75,112.51 200.09,112.51 195.87,116.73 195.87,119.74 191.24,124.36 187.96,124.36 187.94,124.34 185.46,124.34 U50000.D17 ; U51000.L12 v4(207.63,117.12)
FBC_D0: length 38.2
  L8 w0.109: v4(209.13,100.31) 208.75,99.93 208.75,98.88 206.88,97.01 200.5,97.01 189.23,108.29 189.23,115 188.09,116.14 187.27,116.14 186.65,116.76 v4(186.06,116.76)
  BOTTOM w0.17: U50900.F2 v4(209.13,100.31) ; v4(186.06,116.76) U50000.C6
FBC_D1: length 44.3
  L10 w0.109: v4(185.45,115.96) 185.81,115.6 186.98,115.6 187.24,115.34 187.24,113.68 187.54,113.39 187.54,111.06 188.08,110.52 190.24,108.36 190.24,105.85 199.44,96.65 209.76,96.65 212.29,99.18 212.29,99.18 212.52,99.4 212.52,99.41 212.52,99.41 212.52,102.2 v4(212.88,102.56)
  BOTTOM w0.17: v4(212.88,102.56) U50900.B4 ; v4(185.45,115.96) U50000.D6
FBC_D2: length 36.2
  L8 w0.109: v4(187.81,116.51) 188.36,116.51 189.68,115.19 189.68,108.55 200,98.23 204.01,98.23 204.39,97.85 207.03,97.85 207.32,98.14 207.32,100.58 207.46,100.71 208.03,100.71 v4(208.38,101.06)
  BOTTOM w0.17: U50900.G2 v4(208.38,101.06) ; U50000.A6 187.49,116.28 187.72,116.51 v4(187.81,116.51)
FBC_D3: length 38.9
  L8 w0.109: v4(209.88,101.06) 209.54,100.72 209.54,100.46 209.54,100.46 209.54,99.03 207.03,96.52 200.32,96.52 188.77,108.07 188.77,114.81 187.89,115.7 187.08,115.7 v4(186.8,115.98)
  BOTTOM w0.17: v4(186.8,115.98) U50000.B6 ; v4(209.88,101.06) U50900.E2
FBC_D4: length 42.3
  L10 w0.109: v4(186.86,114.53) 186.54,114.21 186.54,112.54 186.97,112.11 186.97,110.76 189.75,107.98 189.75,105.67 199.18,96.24 199.21,96.24 199.25,96.2 210.59,96.2 213.27,98.87 213.27,100.68 v4(212.88,101.06)
  BOTTOM w0.17: v4(212.88,101.06) U50900.B2 ; v4(186.86,114.53) U50000.B4
FBC_D5: length 39.4
  L10 w0.109: v4(188.17,114.14) 188.11,114.14 187.85,113.88 187.85,112.66 188.28,112.23 188.28,111.27 190.82,108.73 190.82,105.91 198.81,97.92 203.75,97.92 204.31,97.36 207.64,97.36 208.22,97.95 210.3,97.95 211.76,99.41 211.76,101.44 v4(212.13,101.81)
  BOTTOM w0.17: v4(188.17,114.14) 188.17,114.31 187.62,114.86 187.22,114.86 U50000.A4 ; v4(212.13,101.81) U50900.B3
FBC_D6: length 39.7
  L8 w0.109: v4(210.63,101.81) 211.02,101.43 211.02,99.15 207.93,96.06 199.91,96.06 188.32,107.65 188.32,112.71 v4(188.2,112.83)
  BOTTOM w0.17: v4(210.63,101.81) U50900.E3 ; U50000.B3 186.84,113.84 187.33,113.84 187.87,113.3 v4(188.2,112.83)
FBC_D7: length 45.5
  L10 w0.109: v4(213.63,101.81) 214.03,101.41 214.03,98.98 210.79,95.75 199.06,95.75 199.02,95.79 198.99,95.79 189.24,105.54 189.24,107.47 186.37,110.34 186.37,112.32 185.85,112.84 185.85,113.34 185.78,113.41 185.78,114.85 v4(186.16,115.22)
  BOTTOM w0.17: U50900.A3 v4(213.63,101.81) ; v4(186.16,115.22) U50000.C4
FBC_D8: length 40.7
  L3 w0.109: v4(184.78,118.09) 185.18,117.69 185.79,117.69 185.92,117.56 186.33,117.56 186.41,117.65 187.31,117.65 187.43,117.53 187.95,117.53 188.72,116.75 188.72,116.49 189.89,115.32 191.01,113.34 191.01,110.97 199.8,102.18 208.57,102.18 209.05,102.66 209.05,103.4 210.94,105.29 210.94,105.88 211.01,105.95 211.01,107.22 211.02,107.23 211.02,107.25 211.21,107.44 211.76,107.44 v4(212.12,107.8)
  BOTTOM w0.17: U50000.D9 v4(184.78,118.09) ; v4(212.12,107.8) U50900.B12
FBC_D9: length 36.1
  L3 w0.109: v4(185.65,118.82) 186.02,118.44 187.12,118.44 187.23,118.33 188.67,118.33 192.8,114.2 192.8,110.9 199.07,104.63 205.57,104.63 205.83,104.89 206.81,104.89 207.14,105.23 208.91,105.23 209.22,105.54 209.22,107.32 209.5,107.6 209.5,108.18 v4(209.88,108.56)
  BOTTOM w0.17: v4(209.88,108.56) U50900.E13 ; v4(185.65,118.82) U50000.C9
FBC_D10: length 35.2
  L3 w0.109: v4(208.38,108.56) 208,108.18 207.39,108.18 207.26,108.05 207.26,106.87 207.09,106.7 204.73,106.7 204.29,106.26 204.29,106.06 203.86,105.64 199.92,105.64 194.34,111.22 194.34,114.08 188.75,119.67 186.92,119.67 185.36,119.21 185.11,118.96 184.98,118.7 184.8,118.52 184.56,118.52 v4(184.1,118.68)
  BOTTOM w0.17: v4(184.1,118.68) U50000.E9 ; v4(208.38,108.56) U50900.G13
FBC_D11: length 34.5
  L3 w0.109: v4(209.13,109.31) 208.76,108.94 208.76,106.68 208.65,106.57 208.26,106.57 208.12,106.43 208.12,105.85 208.02,105.74 205.58,105.74 205.02,105.18 199.31,105.18 193.37,111.13 193.37,114.27 188.43,119.21 187.3,119.21 v4(186.92,118.82)
  BOTTOM w0.17: v4(209.13,109.31) U50900.F13 ; v4(186.92,118.82) U50000.B9
FBC_D12: length 42.6
  L3 w0.109: v4(186.98,117.15) 187.01,117.18 187.46,117.18 187.63,117.02 187.69,117.02 187.69,117.02 187.88,117.02 188.19,116.7 188.19,116.23 189.58,114.85 190.27,113.43 190.27,110.92 199.76,101.43 210.78,101.43 211.01,101.66 211.01,104.22 212.73,105.94 212.73,106.42 212.52,106.62 212.52,108.95 v4(212.88,109.31)
  BOTTOM w0.17: v4(186.98,117.15) 186.98,117.2 U50000.B8 ; v4(212.88,109.31) U50900.B13
FBC_D13: length 35.1
  L3 w0.109: v4(210.63,107.81) 210.26,107.43 210.26,106.16 210.25,106.15 210.25,105.79 208.39,103.93 208.12,103.93 207.12,102.94 199.87,102.94 191.54,111.26 191.54,113.93 189.75,116.32 v4(188.43,117.8)
  BOTTOM w0.17: v4(210.63,107.81) 210.63,107.81 U50900.E12 ; U50000.A8 187.35,117.53 188.16,117.53 v4(188.43,117.8)
FBC_D14: length 46.4
  L3 w0.109: v4(212.9,107.05) 213.5,106.45 213.5,105.92 211.77,104.2 211.77,100.83 211.63,100.69 199.81,100.69 189.58,110.92 189.58,113.7 189.23,114.41 187.94,115.7 187.24,116.19 186.97,116.46 186.57,116.46 186.41,116.3 186.3,116.3 186.29,116.3 186,116.3 186,116.3 185.31,116.3 185.08,116.53 185.08,116.73 185.04,116.86 185.04,117.36 184.84,117.57 184.2,117.57 183.57,116.93 v4(183.41,116.59)
  BOTTOM w0.17: v4(212.9,107.05) U50900.B11 ; v4(183.41,116.59) U50000.F6
FBC_D15: length 47.5
  L3 w0.109: v4(213.65,108.64) 214.27,108.01 214.27,105.71 212.51,103.95 212.51,100.17 212.3,99.96 200.3,99.96 200.29,99.95 200.01,99.95 200,99.96 199.89,99.96 188.83,111.02 188.83,114.05 188.38,114.5 187.97,114.5 187.67,114.8 187.49,114.8 187.42,114.87 187.13,115.47 186.92,115.59 185.27,115.59 185.1,115.76 185.1,116.21 v4(184.7,116.6)
  BOTTOM w0.17: v4(184.7,116.6) 184.4,116.31 U50000.E6 ; v4(213.65,108.64) 213.26,108.24 U50900.A12
FBC_D16: length 30
  L3 w0.109: v4(183.37,124.93) 183.38,124.93 183.38,124.92 183.56,124.75 185.08,124.75 185.3,124.53 186.23,124.53 186.66,124.1 189.68,124.1 200.64,113.15 202.56,113.15 205.01,110.69 205.01,109.69 v4(205.38,109.31)
  BOTTOM w0.17: v4(183.37,124.93) U50000.F18 ; v4(205.38,109.31) U50900.M13
FBC_D17: length 30.5
  L3 w0.109: v4(182.65,124.32) 183.03,123.94 184.18,123.94 184.27,123.85 185.11,123.85 185.28,124.01 185.92,124.01 186.31,123.62 189.46,123.62 200.74,112.35 202.23,112.35 204.26,110.32 204.26,108.94 v4(204.63,108.56)
  BOTTOM w0.17: v4(204.63,108.56) U50900.N13 ; U50000.G18 182.65,124.34 v4(182.65,124.32)
FBC_D18: length 29.9
  L8 w0.109: v4(184.05,124.39) 184.41,124.74 185.28,124.74 185.35,124.67 185.96,124.67 186.27,124.98 188.83,124.98 189.21,124.6 189.21,124.6 195.24,118.57 195.24,115.25 199.93,110.56 202.49,110.56 202.76,110.29 202.76,108.94 v4(203.13,108.56)
  BOTTOM w0.17: U50900.P12 v4(203.13,108.56) ; U50000.E18 v4(184.05,124.39)
FBC_D19: length 32.5
  L8 w0.109: v4(181.95,125.02) 182.28,125.35 184.19,125.35 184.86,125.66 189.25,125.66 195.71,119.2 195.71,116.37 197.83,114.24 197.83,113.45 200.27,111.02 202.87,111.02 203.51,110.38 203.51,109.69 v4(203.88,109.31)
  BOTTOM w0.17: v4(203.88,109.31) U50900.P13 ; v4(181.95,125.02) 182.29,124.74 U50000.H18
FBC_D20: length 23.8
  L3 w0.109: v4(184.81,122.27) 184.94,122.4 189.32,122.4 197.08,114.64 197.08,111.73 200.04,108.78 200.04,108.66 v4(200.13,108.56)
  BOTTOM w0.17: U50900.V12 v4(200.13,108.56) ; U50000.D15 v4(184.81,122.27)
FBC_D21: length 24.8
  L3 w0.109: v4(184.16,122.93) 184.25,122.85 186.46,122.85 186.67,123.06 189.3,123.06 200.5,111.85 200.5,109.69 v4(200.88,109.31)
  BOTTOM w0.17: v4(184.16,122.93) U50000.E15 ; v4(200.88,109.31) U50900.U13
FBC_D22: length 27.2
  L3 w0.109: v4(200.89,107.82) 200.52,108.19 200.29,108.19 199.99,108.19 196.54,111.64 196.54,114.43 189.03,121.94 185.26,121.94 185.19,121.87 184.38,121.87 183.91,122.34 183.55,123.35 183.34,123.57 v4(183.31,123.57)
  BOTTOM w0.17: U50000.G17 183.11,123.94 v4(183.31,123.57) ; v4(200.89,107.82) U50900.U12
FBC_D23: length 29.8
  L3 w0.109: v4(201.6,107.08) 201.23,107.45 200.04,107.45 200.02,107.47 199.99,107.47 195.9,111.55 195.9,114.42 189.03,121.3 186.59,121.3 186.21,120.92 185.85,120.92 185.62,121.16 184.81,121.16 184.55,121.42 183.94,121.42 183.55,121.81 183.23,121.81 182.32,122.71 182.32,123.27 v4(181.98,123.61)
  BOTTOM w0.17: U50000.H17 182.3,123.96 v4(181.98,123.61) ; v4(201.6,107.08) 201.26,107.42 U50900.U11
FBC_D24: length 38.5
  L8 w0.109: v4(203.13,101.06) 203.5,101.43 204.12,101.43 204.25,101.57 204.25,104.63 202.25,106.62 200.57,106.62 193.7,113.49 193.7,117.85 188.84,122.72 184.85,122.72 184.34,122.46 184.13,122.46 183.63,122.56 183.39,122.56 183.05,122.52 182.36,122.52 182.31,122.57 181.79,122.57 v4(181.29,122.88)
  BOTTOM w0.17: v4(203.13,101.06) U50900.P2 ; v4(181.29,122.88) U50000.J15
FBC_D25: length 32.4
  L10 w0.109: v4(201.63,102.56) 201.26,102.94 201.26,103.6 201.11,103.75 198.98,103.75 194.35,108.37 194.35,110.52 191.36,113.52 191.36,116.73 187.4,120.68 186.05,120.68 185.57,121.16 185.01,121.16 184.73,121.44 183.76,121.44 183.55,121.64 183.13,121.64 182.57,122.2 v4(181.95,122.2)
  BOTTOM w0.17: v4(201.63,102.56) U50900.U4 ; v4(181.95,122.2) U50000.H15
FBC_D26: length 32.7
  L10 w0.109: v4(203.87,101.8) 203.51,102.16 203.51,104.15 203.4,104.26 199.13,104.26 194.81,108.58 194.81,110.71 191.81,113.71 191.81,116.91 187.53,121.19 186.78,121.19 186.28,121.69 185.58,121.69 v4(185.45,121.56)
  BOTTOM w0.17: U50000.E14 184.62,121.88 184.96,121.54 185.24,121.54 185.24,121.54 185.43,121.54 v4(185.45,121.56) ; U50900.P3 203.87,101.8 v4(203.87,101.8)
FBC_D27: length 36.3
  L10 w0.109: v4(183.4,122.18) 183.53,122.05 184.29,122.05 184.5,121.83 185.03,121.83 185.33,122.13 186.55,122.13 186.85,121.84 187.53,121.84 192.26,117.1 192.26,113.89 195.26,110.9 195.26,108.78 199.32,104.71 203.88,104.71 204.4,104.19 204.4,102.63 205.01,102.02 205.01,101.44 v4(204.63,101.07)
  BOTTOM w0.17: v4(183.4,122.18) U50000.F14 ; v4(204.63,101.07) U50900.M2
FBC_D28: length 33
  L10 w0.109: v4(200.88,101.81) 200.5,102.19 199.9,102.19 198.79,103.3 198.79,103.3 193.9,108.18 193.9,110.34 190.9,113.33 190.9,116.54 187.49,119.95 185.92,119.95 185.59,120.28 184.52,120.28 184.21,120.59 183.93,120.59 183.66,120.32 182.78,119.79 182.48,119.79 182.04,119.5 v4(181.43,118.74)
  BOTTOM w0.17: U50000.H11 182.09,119.57 v4(181.43,118.74) ; v4(200.88,101.81) U50900.U3
FBC_D29: length 29.4
  L8 w0.109: v4(200.13,101.06) 191.46,109.74 191.46,116.01 187.71,119.75 185.89,119.75 185.71,119.93 184.44,119.93 184.11,119.6 v4(183.33,119.45)
  BOTTOM w0.17: v4(183.33,119.45) U50000.G11 ; v4(200.13,101.06) U50900.V3
FBC_D30: length 33
  L10 w0.109: v4(184,120.08) 184.17,119.9 184.86,119.9 185.48,119.28 187.53,119.28 187.86,118.95 187.86,118.94 190.45,116.35 190.45,113.14 193.45,110.15 193.45,106.64 199.4,100.69 203.52,100.69 v4(203.9,100.31)
  BOTTOM w0.17: v4(184,120.08) U50000.F11 ; v4(203.9,100.31) 204.26,100.67 U50900.N2
FBC_D31: length 28.9
  L8 w0.109: v4(200.88,100.31) 200.51,100.69 199.65,100.69 191.01,109.33 191.01,115.82 187.63,119.19 185.69,119.19 185.41,119.48 v4(184.7,119.48)
  BOTTOM w0.17: v4(200.88,100.31) U50900.U2 ; v4(184.7,119.48) U50000.E11
FBC_D32: length 28.8
  L8 w0.109: v4(181.93,132.11) 182.86,132.37 184.21,132.37 184.5,132.44 184.97,132.44 185.32,132.09 185.63,131.67 185.82,131.48 186.86,131.48 187.45,130.89 188.98,130.89 189.43,131.34 191.84,131.34 197.81,125.37 197.81,124.3 199.36,122.75 203.4,122.75 203.51,122.86 203.51,123.5 v4(203.88,123.87)
  BOTTOM w0.17: v4(203.88,123.87) U51000.E2 ; v4(181.93,132.11) U50000.J29
FBC_D33: length 27.1
  L10 w0.109: v4(204.63,124.62) 204.28,124.97 204.28,126.84 203.16,127.97 199.04,127.97 192.92,134.08 187.91,134.08 186.82,132.99 184.21,132.99 v4(184.01,132.78)
  BOTTOM w0.17: U50000.F30 v4(184.01,132.78) ; U51000.F2 v4(204.63,124.62)
FBC_D34: length 22.3
  L3 w0.109: v4(200.13,123.87) 199.58,124.42 192.11,131.91 187.91,131.91 187.41,132.41 185.89,132.41 185.63,132.15 185.21,132.15 184.93,132.43 184.5,132.43 184.18,132.37 183.24,132.37 v4(182.6,132.68)
  BOTTOM w0.17: U50000.H29 v4(182.6,132.68) ; U51000.A3 v4(200.13,123.87)
FBC_D35: length 27.2
  L3 w0.109: v4(203.13,123.12) 202.75,123.5 202.75,125.57 193.85,134.47 187.83,134.47 187.11,133.75 186.34,133.73 185.31,133.73 184.74,133.74 184.34,133.74 184.21,133.61 183.52,133.61 v4(183.36,133.45)
  BOTTOM w0.17: v4(183.36,133.45) U50000.G30 ; v4(203.13,123.12) U51000.E3
FBC_D36: length 21.7
  L3 w0.109: v4(187.87,133.51) 187.87,133.56 188.19,133.88 193.06,133.88 201.27,125.68 201.27,123.49 v4(201.63,123.12)
  BOTTOM w0.17: v4(201.63,123.12) U51000.B3 ; v4(187.87,133.51) 187.1,133.51 186.84,133.43 U50000.B30
FBC_D37: length 24.5
  L10 w0.109: v4(205.38,123.87) 205,124.26 203.73,124.26 203.51,124.48 203.51,126.34 202.53,127.32 198.83,127.32 192.65,133.5 190.02,133.5 v4(189.58,133.06)
  BOTTOM w0.17: v4(189.58,133.06) 189.58,133.03 189.57,132.91 189.03,132.37 188.72,132.37 187.4,132.99 187.4,132.99 U50000.A30 ; U51000.G2 v4(205.38,123.87)
FBC_D38: length 25.7
  L3 w0.109: v4(181.95,133.45) 182.53,133.12 182.9,133.12 182.93,133.09 183.51,133.09 183.92,133.24 184.1,133.24 184.62,132.97 187.71,132.97 188.29,132.38 193.74,132.38 200.18,125.92 200.51,125.59 200.51,124.03 200.51,124.03 200.51,123.72 200.51,123.72 200.51,123.21 200.62,123.1 v4(200.9,123.1)
  BOTTOM w0.17: U51000.B4 v4(200.9,123.1) ; U50000.H30 v4(181.95,133.45)
FBC_D39: length 21.4
  L8 w0.109: v4(186.1,133.37) 187.45,133.37 187.7,133.11 188.58,133.11 189.2,133.74 192.41,133.74 199.41,126.73 199.41,125.41 199.84,124.99 201.27,124.99 v4(201.63,124.62)
  BOTTOM w0.17: v4(186.1,133.37) U50000.C30 ; U51000.B2 v4(201.63,124.62)
FBC_D40: length 23.3
  L10 w0.109: v4(185.4,131.28) 185.62,131.5 186.93,131.5 187.63,130.8 189.86,130.8 190.05,130.61 190.05,130.22 195.53,124.74 195.54,124.74 200.5,119.78 200.5,118.23 v4(200.86,117.87)
  BOTTOM w0.17: U51000.B11 201.23,117.5 v4(200.86,117.87) ; v4(185.4,131.28) U50000.D27
FBC_D41: length 36.5
  L8 w0.109: v4(181.3,129.96) 181.53,130.2 182.1,130.2 182.49,130.36 182.97,130.36 183.26,130.07 183.35,130.07 183.74,129.68 183.74,129.4 184.34,128.79 190.76,128.79 198.39,121.16 198.39,117.57 199.98,115.98 200.39,115.98 200.51,115.85 200.51,114.61 200.73,114.39 204.83,114.39 205.04,114.61 205.04,116.03 v4(205.4,116.39)
  BOTTOM w0.17: v4(181.3,129.96) 181.58,130.28 U50000.J26 ; v4(205.4,116.39) U51000.G13
FBC_D42: length 27.6
  L10 w0.109: v4(200.88,116.37) 200.5,115.99 199.67,115.99 198.76,116.9 198.76,119.6 189.33,129.03 188.24,129.03 187.8,129.47 186.88,129.47 186.73,129.62 186.73,130.61 186.37,130.96 185.99,130.96 185.22,130.19 184.53,130.19 184.15,130.57 183.42,130.57 183.36,130.57 v4(183.36,130.57)
  BOTTOM w0.17: v4(200.88,116.37) U51000.B13 ; U50000.F27 183.36,130.62 v4(183.36,130.57)
FBC_D43: length 26.2
  L10 w0.109: v4(182.65,131.33) 182.86,131.12 183.63,131.12 183.91,130.83 184.42,130.83 184.58,130.99 185.03,130.99 185.18,130.85 185.49,130.85 185.88,131.23 186.68,131.23 187.57,130.34 188.46,130.34 188.83,129.97 189.67,129.97 199.73,119.91 199.73,119.53 199.73,119.53 199.73,117.63 200.13,117.23 v4(200.13,117.12)
  BOTTOM w0.17: v4(182.65,131.33) U50000.G27 ; v4(200.13,117.12) U51000.A12
FBC_D44: length 25.8
  L10 w0.109: v4(203.13,117.12) 202.78,117.47 202.24,117.47 202.01,117.71 202.01,119.55 193.69,127.87 193.69,128.79 190.72,131.76 187.4,131.76 v4(187.3,131.66)
  BOTTOM w0.17: v4(203.13,117.12) U51000.E12 ; U50000.C27 186.37,131.33 186.71,131.33 187.28,131.61 v4(187.3,131.66)
FBC_D45: length 25.4
  L10 w0.109: v4(188.32,129.93) 188.32,129.76 188.56,129.52 189.48,129.52 199.28,119.72 199.28,117.34 199.87,116.75 203.51,116.75 v4(203.88,116.37)
  BOTTOM w0.17: U50000.B27 187.03,130.64 187.44,130.64 187.98,130.33 v4(188.32,129.93) ; v4(203.88,116.37) U51000.E13
FBC_D46: length 22.5
  L10 w0.109: v4(201.63,117.12) 201.26,117.49 201.26,119.66 195.54,125.38 195.53,125.38 190.5,130.41 190.5,130.79 190.03,131.27 188.74,131.27 v4(188.65,131.36)
  BOTTOM w0.17: v4(201.63,117.12) U51000.B12 ; U50000.A27 187.81,130.97 187.99,130.93 188.22,130.93 v4(188.65,131.36)
FBC_D47: length 32.9
  L8 w0.109: v4(183.33,132) 183.36,131.98 183.37,131.98 183.46,131.89 183.72,130.99 184.64,130.07 185.59,130.07 185.76,130.24 186.45,130.24 186.72,129.98 186.72,129.63 186.94,129.41 190.78,129.41 198.84,121.35 198.84,117.81 199.91,116.75 201.03,116.75 201.26,116.52 201.26,115.34 201.41,115.2 204.24,115.2 v4(204.65,115.61)
  BOTTOM w0.17: v4(183.33,132) 183.32,132 U50000.G29 ; v4(204.65,115.61) U51000.F13
FBC_D48: length 44.1
  L10 w0.109: v4(181.96,126.38) 182.35,126.77 182.77,126.77 182.79,126.8 183.46,126.8 183.68,126.59 183.68,126.31 183.88,126.1 184.5,126.1 184.61,125.99 185.11,125.99 185.34,125.76 186.17,125.76 186.67,125.27 187.89,125.27 194.95,118.21 194.95,115.19 199.59,110.55 206.67,110.55 207.23,111.11 208.07,111.11 208.35,111.38 208.35,111.68 208.71,112.04 209.77,112.64 211.76,114.63 211.76,116.75 v4(212.13,117.12)
  BOTTOM w0.17: v4(181.96,126.38) 182.26,126.08 U50000.H20 ; U51000.U12 v4(212.13,117.12)
FBC_D49: length 40.6
  L10 w0.109: v4(212.9,116.39) 212.52,116.01 212.52,115.22 212.58,115.16 212.58,114.67 209.97,112.07 209.85,112.07 209.29,111.51 209.29,111.39 208.51,110.6 207.62,110.6 207.29,110.27 207.29,109.96 207.02,109.69 199.75,109.69 194.5,114.94 194.5,118.02 187.66,124.86 185.68,124.86 v4(185.48,125.06)
  BOTTOM w0.17: v4(185.48,125.06) U50000.D18 ; v4(212.9,116.39) U51000.U13
FBC_D50: length 48.9
  L10 w0.109: v4(213.63,117.12) 214.16,116.6 214.16,114.39 213.8,114.04 213.8,114.03 210.4,110.63 210.4,110.63 210.26,110.5 209.73,110.5 209.51,110.28 209.51,108.36 209.33,108.19 199.4,108.19 197.87,109.72 197.87,110.3 193.6,114.56 193.6,117.64 187.88,123.36 186.64,123.36 185.99,124.02 185.27,124.02 185.16,123.91 184.64,123.91 184.43,124.12 184.43,124.66 183.74,125.35 183.17,125.35 182.69,125.83 v4(182.67,125.83)
  BOTTOM w0.17: U50000.G20 183,126.07 182.69,125.83 v4(182.67,125.83) ; U51000.V12 v4(213.63,117.12)
FBC_D51: length 46.4
  L10 w0.109: v4(212.88,117.87) 212.88,117.63 213.26,117.25 213.26,116.84 213.35,116.75 213.35,114.22 210.22,111.09 209.72,111.09 209.1,110.47 208.99,110.47 208.76,110.24 208.76,109.45 208.76,109.45 208.76,109.13 208.76,109.13 208.76,109.07 208.62,108.94 199.57,108.94 198.4,110.1 198.4,110.4 194.05,114.75 194.05,117.83 187.5,124.38 185.38,124.38 185.09,124.66 185.09,124.9 185.13,124.94 185.13,125.34 184.95,125.52 184.29,125.52 184.06,125.74 v4(184.05,125.74)
  BOTTOM w0.17: v4(184.05,125.74) 184.06,125.74 184.4,126.08 U50000.E20 ; U51000.U11 v4(212.88,117.87)
FBC_D52: length 39
  L8 w0.109: v4(183.35,127.85) 183.6,127.61 184.18,127.61 184.53,127.5 185.11,127.5 185.81,127.84 186.32,127.84 186.83,127.33 190.21,127.33 197.06,120.48 197.06,116.93 199.19,114.8 199.19,114.02 200.64,112.57 205.19,112.57 205.52,112.9 208.02,112.9 209.51,114.39 209.51,115.11 209.65,115.25 210.26,115.25 v4(210.63,115.62)
  BOTTOM w0.17: v4(183.35,127.85) 183.37,127.86 183.37,127.9 U50000.F23 ; U51000.P13 v4(210.63,115.62)
FBC_D53: length 38.6
  L10 w0.109: v4(184.14,127.19) 184.76,126.58 185.07,126.58 185.39,126.25 186.39,126.25 186.95,125.69 188.1,125.69 195.42,118.38 195.42,115.39 199.56,111.25 205.18,111.25 205.85,111.92 205.9,111.92 205.92,111.93 207.72,111.93 209.48,113.69 209.48,115.97 v4(209.88,116.37)
  BOTTOM w0.17: U50000.E21 184.41,126.84 v4(184.14,127.19) ; U51000.P12 v4(209.88,116.37)
FBC_D54: length 34.3
  L10 w0.109: v4(208.38,116.37) 208.03,116.02 208.03,114.51 207.9,114.39 207.9,114.03 207.44,113.57 206.7,113.57 206.32,113.19 205.47,113.19 205.13,112.86 199.24,112.86 196.33,115.77 196.33,118.75 188.5,126.58 187.34,126.58 186.85,127.07 185.69,127.07 185.55,127.21 185.55,127.24 v4(185.54,127.24)
  BOTTOM w0.17: v4(185.54,127.24) 185.54,127.2 U50000.D21 ; v4(208.38,116.37) U51000.M13
FBC_D55: length 36.2
  L10 w0.109: v4(209.13,115.62) 208.79,115.28 208.79,113.81 207.75,112.77 207.18,112.77 206.9,112.5 205.46,112.5 205.16,112.2 199.26,112.2 195.88,115.58 195.88,118.56 188.31,126.13 187.25,126.13 186.67,126.7 185.4,126.7 185.14,126.96 185.14,127.44 v4(184.7,127.88)
  BOTTOM w0.17: U51000.N13 v4(209.13,115.62) ; v4(184.7,127.88) U50000.E23
FBC_D56: length 41.2
  L3 w0.109: v4(212.88,122.37) 213.26,122 213.26,121.29 211.4,119.43 211.31,119.43 210.89,119.01 210.05,119.01 209.9,119.15 208.63,119.15 207.41,119.02 205.83,119.02 205.01,118.2 205.01,116.89 204.85,116.73 199.27,116.73 189.68,126.32 184.69,126.32 184.2,126.81 183.91,126.81 183.74,126.98 183.74,127.57 183.9,127.72 183.9,127.98 183.3,128.58 v4(183.3,129.18)
  BOTTOM w0.17: v4(212.88,122.37) U51000.U4 ; v4(183.3,129.18) U50000.G24
FBC_D57: length 47.6
  L10 w0.109: v4(212.88,123.87) 212.88,123.62 212.51,123.25 212.51,122.97 212.29,122.75 210.48,122.75 210.26,122.53 210.26,122.08 208.79,120.61 205.83,120.61 205.03,119.82 205.03,115.37 204.88,115.22 204.27,115.22 203.32,114.27 199.93,114.27 197.85,116.35 197.85,119.23 188.99,128.09 187.43,128.09 186.84,128.68 185.39,128.68 185.26,128.81 184.35,128.81 183.59,129.57 183.59,129.87 183.33,130.14 183.18,130.14 182.75,130.57 v4(182.01,130.57)
  BOTTOM w0.17: v4(212.88,123.87) U51000.V3 ; v4(182.01,130.57) U50000.H26
FBC_D58: length 38.7
  L3 w0.109: v4(184,128.58) 184.27,128.31 184.27,127.77 184.55,127.49 184.89,127.49 185.16,127.23 185.16,127.08 185.45,126.78 190.01,126.78 199.3,117.49 204.03,117.49 204.26,117.71 204.26,118.14 204.9,118.78 204.9,119.31 205.37,119.77 205.51,119.8 205.93,119.88 207.48,119.88 208.69,119.64 210.31,119.64 210.55,119.88 211.21,119.88 212.51,121.18 212.51,122.75 v4(212.13,123.12)
  BOTTOM w0.17: v4(212.13,123.12) U51000.U3 ; v4(184,128.58) U50000.F24
FBC_D59: length 40
  L3 w0.109: v4(182.7,130) 182.81,130.1 183.36,130.1 183.6,129.86 183.6,129.57 185.26,127.92 186.18,127.92 186.67,127.42 190.16,127.42 199.34,118.24 203.32,118.24 203.51,118.42 203.51,118.76 203.73,118.98 203.94,118.98 205.16,120.2 205.96,120.34 207.86,120.34 209.16,120.09 210.01,120.09 211.3,120.83 211.76,121.3 211.76,124.25 v4(212.13,124.62)
  BOTTOM w0.17: v4(212.13,124.62) U51000.U2 ; v4(182.7,130) 182.7,130 U50000.G26
FBC_D60: length 43.1
  L10 w0.109: v4(210.63,123.12) 210.44,123.12 210.07,123.5 209.69,123.5 209.51,123.31 209.51,122.13 209.05,121.67 207.64,121.67 207.04,121.07 205.35,121.07 204.26,119.98 204.26,116.22 204.04,116 203.73,116 203.53,115.8 203.53,115.35 203.37,115.19 200.36,115.19 200.29,115.12 199.8,115.12 198.3,116.62 198.3,119.41 189.18,128.54 187.91,128.54 187.42,129.04 186.87,129.04 186.5,129.41 186.5,130.09 186.33,130.26 185.88,130.26 185.2,129.58 184.64,129.58 184.28,129.94 184.05,129.94 v4(184.03,129.96)
  BOTTOM w0.17: v4(184.03,129.96) U50000.F26 ; v4(210.63,123.12) U51000.P3
FBC_D61: length 33
  L3 w0.109: v4(185.94,129.34) 186.16,129.34 187.01,128.49 190.53,128.49 199.36,119.66 203.32,119.66 205.65,121.99 210.04,121.99 210.26,122.21 210.26,123.5 v4(209.88,123.87)
  BOTTOM w0.17: U51000.P2 v4(209.88,123.87) ; v4(185.94,129.34) U50000.D26
FBC_D62: length 29.9
  L3 w0.109: v4(187.12,129.84) 187.15,129.84 187.48,129.51 190.79,129.51 199.73,120.57 202.86,120.57 204.26,121.96 204.26,123.28 204.47,123.49 208.53,123.49 208.76,123.72 208.76,124.25 v4(209.13,124.62)
  BOTTOM w0.17: v4(187.12,129.84) 187.12,129.86 U50000.B26 ; v4(209.13,124.62) U51000.N2
FBC_D63: length 30
  L3 w0.109: v4(208.38,123.87) 208.01,124.25 203.73,124.25 203.51,124.03 203.51,121.85 202.67,121.02 200.24,121.02 191.25,130.01 188.9,130.01 188.9,130.01 188.77,130.01 188.44,130.33 187.3,130.33 187.02,130.6 v4(186.12,130.6)
  BOTTOM w0.17: v4(186.12,130.6) U50000.C26 ; v4(208.38,123.87) U51000.M2
FBC_DBI0: length 42
  L8 w0.109: v4(211.38,101.06) 211.75,100.69 211.75,99.01 210.45,97.7 210.45,97.39 208.68,95.61 199.49,95.61 187.87,107.23 187.87,111.49 187.53,111.83 187.53,113.49 187.23,113.79 187.23,114.54 187.61,114.93 187.61,115.11 187.65,115.14 v4(187.65,115.24)
  BOTTOM w0.17: v4(187.65,115.24) U50000.A5 ; v4(211.38,101.06) U50900.D2
FBC_DBI1: length 45.6
  L10 w0.109: v4(186.17,118.05) 186.55,118.43 187.14,118.43 187.24,118.32 187.79,118.32 188.04,118.07 188.04,117.64 188.27,117.42 188.68,117.42 190,116.1 190,112.96 193,109.96 193,106.45 199.51,99.94 204.77,99.94 205.27,100.43 205.27,102.95 205.02,103.19 205.02,103.98 205.18,104.15 208.57,104.15 210.26,105.83 210.26,108.94 v4(210.63,109.31)
  BOTTOM w0.17: v4(210.63,109.31) U50900.D13 ; v4(186.17,118.05) U50000.C8
FBC_DBI2: length 30.8
  L8 w0.109: v4(181.3,124.38) 181.31,124.28 181.67,123.97 182.26,123.97 182.43,123.8 182.88,123.8 183.01,123.93 184.1,123.93 184.17,123.86 184.97,123.86 185.32,124.21 188.83,124.21 194.79,118.25 194.79,114.64 199.73,109.69 202.01,109.69 v4(202.38,109.31)
  BOTTOM w0.17: v4(202.38,109.31) U50900.R13 ; v4(181.3,124.38) U50000.J18
FBC_DBI3: length 32.1
  L8 w0.109: v4(183.4,120.78) 184.22,120.57 184.45,120.34 187.77,120.34 191.91,116.2 191.91,112.11 200.51,103.51 200.51,101.6 200.67,101.44 201.05,101.44 201.26,101.23 201.26,100.79 201.36,100.69 201.86,100.69 202.23,100.32 v4(202.39,100.32)
  BOTTOM w0.17: U50900.R2 v4(202.39,100.32) ; v4(183.4,120.78) U50000.F12
FBC_DBI4: length 24.1
  L8 w0.109: v4(203.13,124.62) 202.76,124.25 202.76,123.63 202.62,123.49 199.3,123.49 198.41,124.38 198.41,125.41 191.89,131.93 187.55,131.93 187.05,132.43 186.59,132.43 v4(186.06,131.9)
  BOTTOM w0.17: U51000.D2 v4(203.13,124.62) ; U50000.D29 185.23,132.25 185.84,131.9 v4(186.06,131.9)
FBC_DBI5: length 29.3
  L8 w0.109: v4(184.11,131.29) 184.11,131.27 184.37,131.01 185,131.01 185.24,130.78 185.66,130.78 185.85,130.97 186.57,130.97 187.11,130.43 188.37,130.43 188.95,129.86 190.97,129.86 199.3,121.53 199.3,118.19 199.99,117.5 201.78,117.5 202.01,117.27 202.01,116.14 202.15,116 202.72,116 v4(203.13,115.59)
  BOTTOM w0.17: U50000.E27 184.11,131.27 v4(184.11,131.29) ; U51000.D13 203.13,115.62 v4(203.13,115.59)
FBC_DBI6: length 42.7
  L8 w0.109: v4(211.38,116.37) 211.75,116 212.39,116 212.52,115.87 212.52,115.4 212.53,115.39 212.53,114.67 209.85,111.99 205.93,111.99 205.6,111.66 200.26,111.66 198.29,113.64 198.29,114.43 196.16,116.55 196.16,119.79 189.69,126.25 184.83,126.25 184.29,126.1 183.61,126.1 183.31,126.41 v4(183.31,126.45)
  BOTTOM w0.17: U50000.F20 183.33,126.38 183.31,126.41 v4(183.31,126.45) ; U51000.R13 v4(211.38,116.37)
FBC_DBI7: length 34
  L3 w0.109: v4(210.63,124.62) 210.27,124.26 209.68,124.26 209.51,124.08 209.51,122.97 209.29,122.75 205.68,122.75 205.42,122.49 205.21,122.19 203.14,120.11 199.55,120.11 190.69,128.97 187.24,128.97 186.72,129.49 186.72,129.88 186.37,130.23 185.04,130.23 v4(184.7,130.58)
  BOTTOM w0.17: v4(210.63,124.62) U51000.R2 ; U50000.E26 v4(184.7,130.58)
FBC_DEBUG0: length 8.8
  TOP w0.102: R50320.1 191.73,115.6 188.6,118.73 v4(187.55,118.73)
  BOTTOM w0.109: v4(187.55,118.73) U50000.A9
FBC_DEBUG1: length 10.9
  BOTTOM w0.137: U50000.C24 186.02,128.88 186.35,129.2 186.61,129.2 186.88,129.47 189.31,129.47 190.09,130.25 190.09,131.71 190.49,132.11 192.24,132.11 R50321.1
FBC_EDC0: length 45.4
  L8 w0.109: v4(184.8,115.28) 184.8,115.29 185.2,115.57 185.62,115.57 185.77,115.42 185.77,115.09 186,114.86 186.33,114.86 186.5,114.69 186.5,114.35 186.53,114.18 186.53,112.69 186.73,112.49 186.73,112.21 187.19,111.75 187.19,106.33 198.36,95.16 209.54,95.16 210.9,96.52 210.9,96.58 212.5,98.18 212.5,99.95 v4(212.13,100.31)
  BOTTOM w0.17: U50000.D5 v4(184.8,115.28) ; v4(212.13,100.31) U50900.C2
FBC_EDC1: length 51.8
  L10 w0.109: v4(211.38,108.56) 211.77,108.17 213.07,108.17 213.32,107.93 213.32,106.99 213.25,106.92 213.25,106.9 212.72,106.38 212.72,105.16 211.02,103.46 211.02,99.38 210.05,98.4 207.97,98.4 207.43,97.86 204.45,97.86 203.94,98.38 198.99,98.38 191.55,105.82 191.55,109.2 188.64,112.11 188.64,114.94 187.21,116.37 186.45,116.37 186.38,116.3 186,116.3 186,116.3 185.31,116.3 185.08,116.54 185.08,116.84 185.38,117.15 185.5,117.15 185.51,117.16 v4(185.52,117.16)
  BOTTOM w0.17: v4(211.38,108.56) U50900.C13 ; v4(185.52,117.16) 185.52,117.19 185.49,117.21 U50000.D8
FBC_EDC2: length 26.2
  L8 w0.109: v4(201.63,108.56) 201.26,108.94 199.68,108.94 194.16,114.46 194.16,118.04 188.57,123.63 v4(185.43,123.63)
  BOTTOM w0.17: U50000.E17 184.55,123.98 184.9,123.63 v4(185.43,123.63) ; v4(201.63,108.56) U50900.T13
FBC_EDC3: length 30.4
  L8 w0.109: v4(201.63,101.06) 201.98,101.42 201.98,102.08 201.87,102.19 201.45,102.19 201.26,102.38 201.26,103.66 192.36,112.56 192.36,116.39 187.84,120.91 185.85,120.91 185.6,121.16 185.21,121.16 v4(184.7,120.78)
  BOTTOM w0.17: v4(184.7,120.78) U50000.E12 ; v4(201.63,101.06) U50900.T2
FBC_EDC4: length 22.8
  L8 w0.109: v4(184.71,133.36) 185.17,132.9 187.31,132.9 187.79,132.43 188.71,132.43 188.71,132.43 192.03,132.43 198.94,125.52 198.94,125.13 199.84,124.23 202.02,124.23 v4(202.37,123.88)
  BOTTOM w0.17: v4(202.37,123.88) 202.01,124.23 U51000.C2 ; v4(184.71,133.36) 184.71,133.35 184.7,133.35 184.43,133.08 U50000.E30
FBC_EDC5: length 27.6
  L8 w0.109: v4(189.66,130.4) 192,130.4 197.35,125.05 197.35,124.11 199.75,121.72 199.75,118.44 199.93,118.25 202.56,118.25 202.78,118.04 202.78,117.57 202.75,117.54 202.75,116.74 v4(202.38,116.37)
  BOTTOM w0.17: U50000.B29 186.51,132.42 187.06,132.72 187.34,132.72 187.35,132.71 187.37,132.71 189.06,131.9 189.46,131.5 189.65,130.41 v4(189.66,130.4) ; v4(202.38,116.37) U51000.C13
FBC_EDC6: length 41.1
  L8 w0.109: v4(212.13,115.62) 211.78,115.27 211.78,114.63 209.59,112.44 205.74,112.44 205.42,112.12 200.45,112.12 198.74,113.83 198.74,114.61 196.61,116.74 196.61,120.08 189.92,126.77 185.87,126.77 185.79,126.7 184.7,126.7 184.25,126.83 182.89,126.83 182.62,127.09 v4(182.62,127.12)
  BOTTOM w0.17: U50000.G21 182.62,127.1 v4(182.62,127.12) ; U51000.T13 v4(212.13,115.62)
FBC_EDC7: length 34.7
  L3 w0.109: v4(184.69,129.18) 185.39,128.48 186.31,128.48 186.78,128.01 190.37,128.01 199.17,119.21 203.51,119.21 204.91,120.61 205.88,120.86 209.45,120.86 209.46,120.87 210.02,120.87 210.47,121.01 210.69,121.23 210.91,121.45 210.91,121.91 211,122 211,123.49 v4(211.38,123.87)
  BOTTOM w0.17: v4(211.38,123.87) U51000.T2 ; v4(184.69,129.18) U50000.E24
FBC_WCK01: length 45.1
  L8 w0.097: v4(211.38,102.56) 211.38,102.7 211.17,102.92 205.94,102.92 205.46,102.43 205.46,99.55 204.84,98.94 200.13,98.94 199.94,99.13 190.23,108.84 190.23,115.5 188.61,117.12 187.58,117.12 187.21,117.49 186.63,117.49 186.49,117.35 185.91,117.35 185.74,117.52 185.14,117.52 185.1,117.48 184.44,117.48 184.39,117.43 183.81,117.43 183.53,117.72 183.25,117.72 183.16,117.61 183.16,117.51 v4(183.35,117.33)
  BOTTOM w0.122: v4(211.38,102.56) U50900.D4 ; v4(183.35,117.33) U50000.F8
FBC_WCK01#: length 45.1
  L8 w0.097: v4(182.67,117.94) 182.86,117.78 183,117.78 183.08,117.87 183.1,117.89 183.16,117.94 183.62,117.94 183.91,117.66 184.3,117.66 184.34,117.7 185,117.7 185.05,117.75 185.84,117.75 186.01,117.58 186.4,117.58 186.54,117.71 187.3,117.71 187.67,117.34 188.71,117.34 190.45,115.59 190.45,108.93 200.22,99.16 204.75,99.16 205.24,99.65 205.24,102.53 205.85,103.14 211.25,103.14 211.4,103.29 v4(211.4,103.31)
  BOTTOM w0.122: v4(211.4,103.31) 211.03,102.94 U50900.D5 ; v4(182.67,117.94) U50000.G8
FBC_WCK23: length 30.7
  L3 w0.097: v4(182,120.17) 182.22,119.96 182.22,119.82 182.44,119.59 182.94,119.59 183.41,120.07 183.49,120.07 183.85,120.43 184.15,120.43 184.46,120.25 185.12,120.01 185.68,120.01 186.36,120.14 186.81,120.3 188.92,120.3 194.9,114.32 194.9,111.44 199.85,106.49 201.78,106.49 202.06,106.42 202.71,106.42 202.97,106.68 202.97,106.93 v4(203.11,107.07)
  BOTTOM w0.122: v4(203.11,107.07) 203.11,107.07 203.11,107.12 U50900.R11 ; U50000.H12 182,120.18 v4(182,120.17)
FBC_WCK23#: length 30.7
  L3 w0.097: v4(202.38,107.06) 202.38,107.15 202.48,107.24 202.65,107.24 202.75,107.15 202.75,106.77 202.62,106.65 202.08,106.65 201.81,106.71 199.95,106.71 195.12,111.54 195.12,114.42 189.01,120.52 186.77,120.52 186.3,120.35 185.66,120.24 185.16,120.24 184.56,120.45 184.2,120.65 183.76,120.65 183.4,120.29 183.32,120.29 182.85,119.82 182.54,119.82 182.44,119.91 182.44,120.1 182.54,120.19 v4(182.7,120.19)
  BOTTOM w0.122: U50900.R10 202.75,106.79 202.47,107.05 202.44,107.05 202.43,107.06 v4(202.38,107.06) ; U50000.G12 182.71,120.19 v4(182.7,120.19)
FBC_WCK45: length 27.7
  L3 w0.097: v4(203.12,122.36) 203.02,122.36 202.84,122.17 202.84,122 202.58,121.74 200.36,121.74 191.17,130.94 189.08,130.94 188.89,130.75 187.5,130.75 187.25,131 185.99,131 185.71,130.71 185.04,130.71 184.84,130.92 184.55,130.92 184.37,130.73 183.84,130.73 183.65,130.93 183.05,130.93 182.89,130.76 182.35,130.76 182.11,131.01 181.74,131.01 181.69,131.06 v4(181.3,131.27)
  BOTTOM w0.122: v4(203.12,122.36) 203.12,122.38 U51000.D4 ; U50000.J27 181.31,131.27 v4(181.3,131.27)
FBC_WCK45#: length 27.8
  L3 w0.097: v4(181.89,131.37) 181.89,131.64 181.99,131.74 182.14,131.74 182.27,131.61 182.27,131.16 182.45,130.99 182.79,130.99 182.96,131.15 183.74,131.15 183.94,130.95 184.27,130.95 184.46,131.14 184.93,131.14 185.13,130.94 185.61,130.94 185.9,131.22 187.35,131.22 187.59,130.97 188.8,130.97 188.99,131.16 191.26,131.16 200.45,121.97 202.49,121.97 202.62,122.09 202.62,122.25 202.5,122.37 v4(202.38,122.37)
  BOTTOM w0.122: v4(202.38,122.37) U51000.D5 ; U50000.H27 182.06,130.98 181.89,131.15 v4(181.89,131.37)
FBC_WCK67: length 47.9
  L8 w0.097: v4(210.63,117.87) 210.63,117.9 210.03,118.5 210.03,118.98 209.17,119.85 205.44,119.85 205.04,119.44 205.04,119.03 205.53,118.54 205.67,118.54 206.05,118.16 206.05,117.66 205.66,117.27 205.66,116.99 206.01,116.64 206.01,115.02 205.97,114.98 205.97,113.87 205.56,113.45 205.29,113.45 204.96,113.12 200.87,113.12 199.74,114.24 199.74,115.03 197.62,117.16 197.62,120.71 190.35,127.97 187.16,127.97 186.85,128.28 184.54,128.28 184.24,127.97 183.75,127.97 183.38,128.34 182.47,128.34 182.37,128.24 182.37,127.98 182.47,127.88 v4(182.7,127.88)
  BOTTOM w0.122: v4(182.7,127.88) U50000.G23 ; U51000.R11 v4(210.63,117.87)
FBC_WCK67#: length 48
  L8 w0.097: v4(182,127.88) 182.15,128.03 182.15,128.34 182.38,128.57 183.47,128.57 183.84,128.2 184.15,128.2 184.45,128.5 186.94,128.5 187.25,128.2 190.44,128.2 197.84,120.8 197.84,117.25 199.97,115.12 199.97,114.34 200.96,113.34 204.87,113.34 205.2,113.67 205.47,113.67 205.75,113.96 205.75,115.08 205.79,115.11 205.79,116.54 205.43,116.9 205.43,117.36 205.83,117.76 205.83,118.06 205.57,118.32 205.43,118.32 204.82,118.94 204.82,119.54 205.35,120.07 209.26,120.07 210.26,119.07 210.26,118.59 210.35,118.49 210.54,118.49 210.63,118.59 v4(210.63,118.62)
  BOTTOM w0.122: v4(182,127.88) U50000.H23 ; U51000.R10 v4(210.63,118.62)
FBC_WCKB01: length 48.9
  L10 w0.097: v4(182.64,118.72) 182.79,118.56 182.79,118.41 183.77,117.43 184.36,117.43 184.44,117.51 185.31,117.51 185.33,117.53 185.84,117.53 185.88,117.49 187.2,117.49 187.39,117.29 187.54,117.29 189.22,115.61 189.22,112.49 192.22,109.49 192.22,106.07 199.37,98.93 204.86,98.93 205.76,99.83 205.76,102.75 205.95,102.94 208.68,102.94 210.01,104.27 210.8,104.27 211.99,105.47 211.99,106.57 211.77,106.8 211.51,107.06 v4(211.38,107.06)
  BOTTOM w0.122: U50900.D11 v4(211.38,107.06) ; v4(182.64,118.72) 182.82,118.67 U50000.G9
FBC_WCKB01#: length 48.9
  L10 w0.097: v4(211.38,106.31) 211.37,106.3 211.14,106.3 211.07,106.37 211.07,106.6 211.16,106.7 211.55,106.7 211.77,106.48 211.77,105.56 210.7,104.49 209.92,104.49 208.59,103.16 205.86,103.16 205.54,102.84 205.54,99.92 204.77,99.15 199.46,99.15 192.44,106.17 192.44,109.58 189.44,112.59 189.44,115.71 187.63,117.51 187.49,117.51 187.29,117.71 185.97,117.71 185.93,117.75 185.24,117.75 185.22,117.73 184.34,117.73 184.27,117.66 183.87,117.66 183.02,118.51 183.02,118.64 183.11,118.74 183.31,118.74 v4(183.35,118.7)
  BOTTOM w0.122: U50900.D10 v4(211.38,106.31) ; v4(183.35,118.7) 183.69,118.38 U50000.F9
FBC_WCKB23: length 33.6
  L8 w0.097: v4(203.13,102.56) 203.13,102.62 202.55,103.2 202.55,103.8 202.24,104.1 201.8,104.1 192.91,112.99 192.91,116.61 187.58,121.95 185.31,121.95 184.95,121.6 183.15,121.6 182.85,121.9 182.52,121.9 182.26,121.64 182.26,121.41 182.36,121.32 182.49,121.32 v4(182.66,121.49)
  BOTTOM w0.122: v4(203.13,102.56) U50900.R4 ; v4(182.66,121.49) U50000.G14
FBC_WCKB23#: length 33.6
  L8 w0.097: v4(203.14,103.32) 203.14,103.3 203.04,103.2 202.87,103.2 202.77,103.3 202.77,103.89 202.33,104.33 201.9,104.33 193.14,113.09 193.14,116.71 187.67,122.18 185.21,122.18 184.86,121.82 183.24,121.82 182.94,122.12 182.43,122.12 182.03,121.73 182.03,121.53 v4(181.86,121.36)
  BOTTOM w0.122: v4(181.86,121.36) 181.92,121.37 U50000.H14 ; v4(203.14,103.32) U50900.R5
FBC_WCKB45: length 27.6
  L10 w0.097: v4(202.39,117.86) 202.59,118.49 202.59,119.75 194.94,127.4 194.94,128.56 191.2,132.29 191.19,132.29 191.17,132.31 188.67,132.31 188.57,132.41 184.59,132.41 184.45,132.28 184.45,132.12 184.55,132.02 v4(184.76,132.02)
  BOTTOM w0.122: v4(202.39,117.86) 202.75,117.5 U51000.D11 ; U50000.E29 184.76,132.02 v4(184.76,132.02)
FBC_WCKB45#: length 27.6
  L10 w0.097: v4(184.06,131.99) 184.23,132.16 184.23,132.37 184.49,132.63 188.48,132.63 188.66,132.63 188.76,132.54 191.27,132.54 191.29,132.52 191.29,132.52 195.16,128.65 195.16,127.49 199.74,122.92 202.82,119.84 202.82,118.82 203.02,118.61 v4(203.12,118.61)
  BOTTOM w0.122: v4(184.06,131.99) U50000.F29 ; v4(203.12,118.61) U51000.D10
FBC_WCKB67: length 46.7
  L10 w0.097: v4(182.02,129.18) 181.8,129.18 181.71,129.09 181.71,128.93 182.02,128.62 183.44,128.62 183.84,128.22 184.16,128.22 184.45,128.5 185.03,128.5 185.38,128.16 186.63,128.16 187.26,127.54 188.76,127.54 197.13,119.17 197.13,116.27 199.75,113.64 203.53,113.64 204.38,114.49 204.83,114.49 205.36,115.02 205.45,115.02 205.69,115.25 205.93,115.5 205.93,116.38 205.39,116.92 205.39,117.27 205.81,117.69 205.81,118 205.53,118.27 205.53,118.87 205.9,119.24 205.9,119.73 206.23,120.06 209.79,120.06 210.77,121.04 210.77,121.11 210.77,121.72 211.38,122.33 v4(211.38,122.37)
  BOTTOM w0.122: v4(182.02,129.18) 182.02,129 182.14,128.88 U50000.H24 ; U51000.R4 v4(211.38,122.37)
