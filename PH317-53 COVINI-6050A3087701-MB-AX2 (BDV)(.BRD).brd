# Allegro board PH317-53 COVINI-6050A3087701-MB-AX2 (BDV)(.BRD).brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
DGND_CHASSIS1: length 1.6
  TOP w0.381: C7580.2 307.55,59.41 ; C7579.2 307.55,60.71
  BOTTOM w0.381: C7581.2 307.55,59.67 ; C7582.2 307.55,60.66
  vias: v1(309.75,59.87) v1(310.21,63.28) v1(312.16,61.14) v1(312.25,57.24) v1(312.59,63.71) v1(313.18,59.11) v1(314.79,57.24) v1(315.46,61.01) v1(318.07,61.57) v1(318.07,59.03) v2(311.5,59.95)
DGND_CHASSIS2: length 1.8
  TOP w0.381: C7553.1 309.68,21.86 ; C7554.1 310.27,20.35
  BOTTOM w0.381: C7555.1 309.29,22.3 ; C7583.1 310.27,20.58
  vias: v1(310.38,23.42) v1(311.86,25.01) v1(312.29,22.53) v1(313.18,19.36) v1(315.21,20.76) v1(316.1,22.53) v1(316.94,25.01) v1(318.07,23.3) v2(314.83,22.79)
DGND_CHASSIS4: length 3.7
  BOTTOM w0.381: 302.8,136 C7569.1 302.4,135.55 ; 302.8,136.88 C7574.1 302.8,137.33 ; 302.17,134.17 C7559.1 302.17,133.72 ; 301.97,135.5 C7558.1 302.17,135.06
DGND_CHASSIS5: length 4
  TOP w0.381: 302.93,116.96 C7576.1 302.93,116.51 ; 302.95,115.39 C7575.1 302.95,114.94
  BOTTOM w0.381: 302.95,115.44 C7577.1 302.95,114.99 ; 302.93,116.78 C7578.1 302.93,116.34
  vias: v2(311.55,116.82)
DVDDL: length 12.8
  TOP w0.292: 280.38,99.91 U400.37
  TOP w0.381: v1(276.98,100.08) 277.02,100.08 277.13,99.96 C438.1 C437.1 279.64,99.96 C412.2 279.69,99.91 280.38,99.91 ; L401.1 277.43,94.15 C436.1 277.82,95.17 C411.2 278.21,97.03 278.37,97.18 L400.2 277.59,97.23 277.14,97.69 v3(277.14,98.38)
  L8 w0.381: v1(276.98,100.08) 276.67,99.76 276.67,98.81 277.05,98.43 277.09,98.43 v3(277.14,98.38)
GND_A: length 11.7
  TOP w0.381: 285.02,152.5 D1.1 ; CN2.G2 v1(289.1,148.06) ; SW1.1 v1(262.82,144.7) ; CN2.4 v1(286.5,153.66) ; CN2.G1 v1(289.12,156.26) ; SW1.2 v1(265.37,144.76) ; CN2.1 v1(288.5,150.66)
  TOP w0.508: 291.93,156.26 CN2.G1 290.75,155.59 ; 290.75,147.39 CN2.G2 ; CN2.G2 291.93,148.06 ; CN2.G2 290.75,148.73
  vias: v1(263.47,140.03) v1(276.32,149.81) v1(276.35,154.38) v1(276.35,152.4) v1(276.42,148.03) v1(279.35,154.41) v1(279.35,152.43) v1(279.32,149.84) v1(279.42,148.06) v1(282.34,149.81) v1(282.37,154.38) v1(282.37,152.4) v1(282.44,148.03) v2(260.65,144.78) v2(273.96,148.19) v2(283.92,154.44)
GND_A1: length 10.9
  TOP w0.381: 259.36,94.45 C51.1 ; C51.1 v1(259.76,95.28) ; C51.1 259.76,94 ; 259.83,96.73 C50.2 259.83,95.84 ; U50.GND v1(259.05,99.48)
  TOP w0.508: CN1.G1 265.64,99.55 ; CN1.G1 265.64,98.21 ; CN1.G1 266.82,98.88 ; CN1.G1 264.46,98.88 ; CN1.G2 266.82,90.68 ; CN1.G2 265.64,91.35 ; CN1.G2 265.64,90.01 ; CN1.G2 264.46,90.68
  vias: v1(263.85,93.28) v1(264.04,90.68) v1(264.18,98.88) v3(259.8,97.11)
GND_ALG: length 13.7
  BOTTOM w0.254: CN601.47 277.34,116.21 v1(277.19,116.06) ; D7533.1 v1(300.3,157.71) ; C25.1 299.34,166.61 299.79,166.15 C24.2 300.32,165.8 300.32,165.8 D7523.1 301.11,166.11 v1(301.11,166.53) ; D7534.1 299.79,164.02 C16.2 v1(298.93,164.02) ; C19.2 v1(299.34,157.71) ; v1(277.16,118.11) 277.56,117.71 CN601.50 ; C23.2 298.45,153.85 v1(298.15,153.56) ; v1(299.34,153.7) R610.2
  BOTTOM w0.381: D7521.1 300.3,153.88 v1(300.12,153.7) 300.19,153.63 D7522.1 ; C612.2 v1(278.62,121.85) ; C614.2 v1(298.23,151.16) ; C613.2 v1(274.98,122.24)
GND_PB: length 103
  TOP w0.254: C2404.2 300.12,121.32 v1(299.62,121.32) ; v3(290.88,101.25) 290.49,100.87 C419.2 ; v1(281.39,107.15) 281.48,107.06 C406.1 ; v1(282.93,103.99) 283.02,103.99 283.28,103.74 U400.27 ; C2419.2 287.85,121.34 v1(287.52,121.01) ; U2403.21 291.12,122.8 v1(290.95,122.63) ; D2400.2 297.56,128.32 297.41,128.17 v1(297.4,128.17) ; D2402.2 v1(292.99,132.39) ; v1(296.74,122.8) U2403.10 ; v1(287.27,102.82) 287.47,103.03 287.8,103.03 288.19,103.41 C408.1 ; v3(297.33,125.66) 297.27,125.72 C2425.2 ; R2419.2 v1(299.82,122.23)
  TOP w0.33: D403.3 D403.8 288.62,104.21 v1(288.6,104.19) ; D402.8 D402.3 v1(290.98,98.89) ; D2403.8 D2403.3 v1(300.96,136.68)
  TOP w0.381: C427.2 C428.2 279.15,89.39 v3(278.3,89.39) ; v1(274.23,98.45) 274.26,98.42 Q401.S 275.85,98.42 C421.2 ; v1(276.96,100.66) 276.89,100.73 Q102.S 276.11,101.43 R109.2 ; X400.2 287.25,91.74 v1(287.25,92.22) ; C423.1 286.64,92.65 v1(286.64,92.23) ; v1(285.47,92.26) 285.49,92.28 285.49,92.51 285.91,92.92 285.91,93.72 C420.2 C424.2 ; R407.1 290.8,94.51 v1(291.06,94.77) ; v1(282.51,95.76) C415.2 C413.2 ; v1(276.84,104.52) C404.2 C409.2 ; v1(286.53,104.27) 286.73,104.47 C407.2 ; C437.2 278.76,99.05 v1(279.27,98.53) 279.65,98.91 C412.1 ; C410.2 277.21,102.75 v1(277.1,102.86) ; C436.2 279.06,94.88 C411.1 v1(279.64,95.56) ; C438.2 277.35,99.11 277.23,99.23 v1(277.21,99.23) ; C7575.2 v1(301.71,114.31) ; v1(283.13,92.23) 282.74,92.23 C418.2 C414.2 ; v1(290.06,91.57) 290.06,92.16 289.37,92.86 C422.1 ; v1(289.42,93.93) 289.42,94.47 C416.2 C417.2 ; C7576.2 v1(301.68,115.71) ; X400.4 288.62,89.57 287.98,88.93 v1(287.98,88.55)
  BOTTOM w0.254: v1(281.1,91.85) 281.05,91.9 CN602.G2 ; CN600.G1 v1(295.83,127.96) ; v1(277.21,99.23) 277.23,99.24 277.23,99.46 277.48,99.71 CN601.14 ; v1(279.27,98.53) 278.95,98.21 CN601.11 ; v1(279.24,105.5) 279.02,105.5 278.8,105.71 CN601.26 ; CN601.23 278.76,104.21 278.77,104.22 v1(278.84,104.22) ; R2414.2 282.87,121.27 v1(281.94,121.27) ; C7558.2 C7559.2 299.8,133.05 v1(299.44,133.05) ; CN601.29 278.62,107.21 v1(278.86,107.46) ; v1(285.4,113.66) 285.4,114.47 U2401.21 ; C2408.2 v1(280.02,114.33) ; v1(274.85,90.76) CN601.G1 ; C7569.2 C7574.2 301.16,136.88 v1(300.96,136.68) ; v1(277.1,102.86) 277.13,102.86 277.27,102.71 CN601.20 ; U2401.10 285.4,118.56 v1(285.4,119.42) ; CN601.17 277.51,101.21 v1(276.96,100.66) ; v1(288.34,127.45) 288.34,127.44 288.59,127.18 D2401.8 D2401.3 ; CN601.8 v1(277.21,96.71) ; Q101.1 281.03,106.28 R104.2 281.23,107 v1(281.39,107.15) ; C608.2 299.48,120.6 299.62,120.74 v1(299.62,121.32) ; v1(297.4,128.17) 297.61,127.96 CN600.G2 ; v1(287.52,121.01) C2409.2
  BOTTOM w0.381: C609.2 296.29,120.64 296.29,120.05 v1(296.29,120.04) ; v1(290.7,124.39) 290.18,123.87 D611.2 ; C610.2 295.42,120.43 v1(295.75,120.77) 295.75,121.58 D609.2 ; 286.85,97.55 C433.2 ; C433.2 286.46,97.55 ; C433.2 286.38,98 v1(286.23,98.15) 286.16,98.22 C425.2 ; v1(299.82,122.23) 299.83,122.24 D608.2 ; Q101.4 282.33,103.52 282.8,103.99 v1(282.93,103.99) ; 286.46,98.67 C401.2 286.46,98.89 ; CN602.G1 286.65,93.26 286.08,92.69 286.08,92.26 v1(286.05,92.23) ; C479.2 v1(299.91,93.75) ; C613.1 v1(274.98,120.23) ; C7578.2 v1(301.68,115.71) ; C612.1 v1(280.63,121.85) ; C2407.2 289.86,121.38 v5(289.86,122) 290.81,122 C2424.2 291.37,121.6 292.45,120.53 C611.2 ; C478.2 v1(299.91,92.87) ; v1(286.53,104.27) 286.53,103.91 286.15,103.53 285.61,103.53 R107.2 ; C7577.2 v1(301.71,114.31) ; v5(286.33,96.6) 285.9,96.6 285.35,97.15 CN602.1 ; CN601.G2 v1(274.85,118.6) ; 299.35,139.71 C2415.2 299.35,140.16 ; C614.1 v1(300.24,151.16) ; v1(290.84,113.72) 291.31,113.72 ; U2400.2 v1(295.83,118.06)
  BOTTOM w0.432: v1(292.99,123.17) 292.85,123.03 D610.2
  vias: v1(271.57,96.97) v1(272.18,98.65) v1(272.79,95.89) v1(273.12,102.29) v1(274.04,96.96) v1(274.39,104.9) v1(274.42,103.05) v1(275.55,104.81) v1(276.42,107.81) v1(277.64,89.39) v1(282.39,102.01) v1(282.39,100.46) v1(282.39,99.04) v1(283.89,102.04) v1(283.89,100.49) v1(283.89,99.06) v1(285.11,117.43) v1(285.11,116.51) v1(285.14,115.55) v1(285.34,102.04) v1(285.34,100.49) v1(285.34,99.06) v1(286.1,117.48) v1(286.08,116.49) v1(286.1,115.5) v1(289.15,88.47) v1(291.56,106.35) v1(291.56,104.42) v1(291.79,96.8) v1(291.94,110.52) v1(292.15,100.73) v1(292.15,98.78) v1(292.63,123.65) v1(293.37,123.65) v1(293.69,94.27) v1(299.34,127.17) v1(299.39,125.3) v1(300.43,89.72) v1(302.44,93.03) v1(302.46,87.18) v1(305.12,93.71) v1(309.76,93.79) v1(311.7,86.5) v1(312.83,91.67) v1(313.92,88.38) v5(296.57,112.8) v5(298.47,140.19) v5(298.65,147.37) v5(299.39,147.4) v5(299.86,114.2) v5(300.22,113.52) v5(300.61,114.2)
P0V6S: length 103.6
  TOP w0.381: 154.32,63.15 C4102.1 ; C4127.1 145.15,74.44 ; C4126.1 145.55,73.08 ; 154.32,62.23 C4101.1 ; C4103.1 154.71,64.51 ; C4125.1 145.55,72.16
  L5 w1.016: v5(146.91,72.85) 146.91,71.15 148.4,69.67 150.29,69.67 151.3,68.65 151.3,65.92 150.92,65.53 150.92,62.51 150.31,61.9 129.49,61.9 128.85,61.27 85.67,61.27 81.28,65.66 81.28,72.6 80.26,73.61 v5(78.36,73.61)
  BOTTOM w0.254: TP60350.1 75.99,84.64 76.7,83.93 76.7,83.49
  BOTTOM w0.305: v5(151.99,63) 151.91,62.91 CN4125.258 ; CN4100.258 v5(146.91,72.85)
P0V6S_DIMM0_VREF_CA: length 100
  TOP w0.254: C4111.1 123.17,75.25 C34.1 ; C4111.1 123.16,75.26 R4150.2 ; C4111.1 123.16,75.76 123.52,76.12 v3(123.55,76.12)
  TOP w0.432: C4171.1 R4153.2 80.88,124.12 81.08,124.31 81.08,124.53 v1(81.09,124.54) 80.78,124.84 R4152.1
  L5 w0.508: v3(123.55,76.12) 123.55,75.49 122.79,74.73 84.2,74.73 83.18,75.75 83.18,82.86 85.21,84.89 85.21,111.18 81.09,115.31 v1(81.09,124.54)
  BOTTOM w0.127: CN4100.164 123.41,74.92
  BOTTOM w0.254: 123.41,74.92 123.41,75.99 v3(123.55,76.12)
P0V6S_DIMM1_VREF_DQ: length 117.7
  TOP w0.254: R4144.2 C4145.1 C4144.1 128.41,62.17 v1(128.41,62.87)
  TOP w0.432: R4148.2 84.62,125.78 83.82,125.78 R4145.1 83.82,125.78 C4167.1 82.08,125.78 v3(82.04,125.73)
  L5 w0.508: v1(128.41,62.87) 127.7,62.16 86.04,62.16 82.34,65.85 82.34,83.67 84.2,85.53 84.2,110.98 80.43,114.74 80.43,124.78 81.38,125.73 v3(82.04,125.73)
  BOTTOM w0.254: v1(128.41,62.87) CN4125.164
P1V0S_DGPU: length 26
  TOP w0.254: C51601.1 157.81,125.96 157.41,125.96 ; C50032.1 157.41,138.54 ; C50056.1 157.29,134.52 ; 158.94,137.33 C50052.1 ; C51900.2 v4(163.06,119.43) ; C51602.1 157.46,125 157.38,125.07 v4(157.35,125.07) 157.41,125.13 157.41,125.96 ; 158.4,128.01 C51732.1 158.35,127.68 v4(158.24,127.79) ; C50055.1 157.29,135.13 ; C51901.2 v4(163.17,120.18) ; 158.98,139.44 C50050.1 ; 158.96,136.12 C50034.1 ; C50057.1 157.31,137.93 ; v4(158.88,123.6) 159.09,123.82 C51801.1 ; 157.34,135.72 C50036.1 C50037.1 157.34,136.98 ; C51730.1 157.09,128.19 C51731.1 ; v4(157.42,124.33) 157.48,124.39 C51612.1 ; C51731.1 157.9,128.52 ; C51731.1 157.83,128.19 v4(158.11,128.48) ; C50035.1 157.31,137.27 ; C50031.1 158.67,134.86 ; 158.94,137.93 C50053.1 ; v4(158.8,128.48) 158.8,128.41 C51611.1 ; 158.94,138.53 C50054.1 ; C51803.1 159.03,125.02 158.85,125.2 v4(158.85,125.71) 159.21,125.71 C51804.1 ; 157.41,125.96 v4(157.41,126.43) 157.52,126.55 C51733.1 157.89,126.87 ; 158.94,136.73 C50051.1 ; v4(158.85,126.42) 158.96,126.32 C51800.1 ; 157.42,134.86 C50030.1 ; v4(158.85,124.3) 158.97,124.42 C51802.1 ; 158.94,139.14 C50033.1
  TOP w0.381: C50039.1 C51000.1 157.71,139.12 ; C51610.1 158.95,128.63 v4(158.8,128.48) ; v4(157.41,126.43) 157.27,126.29 C51600.1 ; C50038.1 149.39,167.3 ; 149.42,165.49 C50058.1
  BOTTOM w0.2: U50000.BB23 v4(158.8,128.48)
  BOTTOM w0.254: U50000.BC18 157.46,125.02 157.4,125.02 v4(157.35,125.07) ; v4(157.41,126.43) 157.45,126.43 U50000.BC20 ; v4(157.42,124.33) 157.78,123.98 U50000.BC17 ; U50000.BC21 157.8,126.79 v4(158.12,127.12)
  BOTTOM w0.305: v4(163.17,120.18) U50000.AT11 v4(163.06,119.43) U50000.AR10
  vias: v4(157.43,135.54) v4(157.45,137.62) v4(158.14,136.25) v4(158.16,137.57) v4(158.16,135.51) v4(158.8,136.22) v5(145.02,161.47) v5(145.18,162.19) v5(145.76,161.48) v5(145.97,162.19) v5(153.01,179.35) v5(153.77,179.35)
P1V0S_HDMI: length 66.9
  TOP w0.254: U56400.28 290.51,79.07 289.71,79.87 289.71,79.94 C56441.1 C56443.1 C56442.1 292.26,79.97 R56440.2 ; L56401.1 282.25,75.49 v1(281.84,75.9)
  TOP w0.292: C56422.2 283.82,69.22 286.63,72.03 U56400.48
  TOP w0.381: C56422.2 283.67,68.47 282.84,67.64 281.25,67.64 v2(280.72,68.17)
  TOP w0.432: v2(280.72,68.17) 280.32,68.58 L56402.1 278.79,69.22 v1(278.69,69.12)
  TOP w0.508: v1(292.53,81.18) R56440.2
  L8 w0.508: v1(281.84,75.9) 281.84,75.92 280.54,77.22 ; 280.54,77.22 280.54,79.63 281.71,80.8 284.35,80.8 284.53,80.62 291.97,80.62 v1(292.53,81.18) 296.19,77.52 296.19,74.79 v1(298.8,72.17) ; 280.54,77.22 280.51,77.24 275.51,77.24 274.29,76.03 274.29,70.62 275.36,69.55 276.88,69.55 277.57,68.86 278.43,68.86 v1(278.69,69.12)
  BOTTOM w0.432: v1(298.8,72.17) 298.95,72.03 L56407.2 299.02,71.44 L56405.2
P1V2: length 359.1
  TOP w0.305: 126.7,62.7 C4170.1 R4144.1 ; v1(294.1,81.77) 294.6,81.77 R56453.1 ; v1(125.91,62.94) 125.85,62.89 C4141.1 ; C4146.1 124.96,62.67 ; v1(124.53,71.65) 124.33,71.84 C4154.1
  TOP w0.381: C4774.1 86.55,109.3 ; 112.89,61.84 C4147.1 ; 112.34,124.92 112.55,125.13 C4700.1 ; 109.51,74.38 C4120.1 ; 115.45,74.41 C4123.1 ; C4771.1 86.55,108.41 ; 98.67,123 C4769.1 ; 121.82,74.4 R4150.1 ; 111.72,70.15 C4155.1 ; 101.5,125.03 101.27,124.8 C4772.1 100.49,124.8 ; 123.45,71.84 C4154.1 ; 111.11,75.28 C4121.1 ; 98.62,124.5 C4768.1 ; 119.01,74.41 C36.1 ; 116.8,69.73 C4157.1 ; 117.99,65.11 R4200.1 ; 113.77,62.92 C4150.1 ; C4775.1 89.64,125.03 ; 122.06,124.87 C4773.1 ; 121.68,125.08 C4508.1 ; 113.32,74.41 R4201.1 ; 109.81,124.59 C4770.1 ; 119.82,62.75 C4151.1 ; C4165.1 86.96,123 ; 113.69,124.73 C4701.1 ; C4763.1 104.97,124.32
  L5 w0.305: v1(294.1,81.77) 294.1,80.98 293.67,80.55 288.67,80.55 287.27,81.94 285.99,81.94 284.93,80.88 260.21,80.88 254.72,75.39 247.32,75.39 246.22,74.3 243.38,74.3 242.95,73.87 242.95,72.88 242.27,72.21 242.27,70.96 239.89,68.58 235.84,68.58 231.26,64.01 224.21,64.01 216.57,71.66 154.76,71.66 154.33,72.09 v1(152.8,72.09)
  L8 w0.381: v1(73.32,92.62) 74.13,92.62 76.22,90.53 76.22,83.24 77.57,81.89 v5(77.57,72.52) v5(77.57,71.78)
  BOTTOM w0.203: U4555.AF5 108.62,120.28 v1(108.21,120.54) ; v1(108.21,120.54) 107.8,120.28 U4555.AG5 ; v1(108.21,120.54) 108.65,120.91 U4555.AF6 ; U4555.AY6 v1(98.16,120.6) U4555.AW6 ; U4555.AR6 100.99,120.94 v1(100.65,120.57) ; v1(113.64,124.52) 113.6,124.56 113.47,124.56 U4555.Y12
  BOTTOM w0.254: U4555.AT12 100.37,124.84 v1(99.93,124.56) ; U4555.AP7 U4555.AP6 U4555.AR6 ; v1(84.77,72.28) 84.04,72.28 83.41,72.9 CN4100.12 ; U4555.AL11 v1(105.41,124.52) U4555.AJ12 ; U4555.AE12 v1(109.96,125.17) ; v1(108.16,123.23) U4555.AG9
  BOTTOM w0.305: C7572.1 81.83,72.01 ; v1(120.91,63.01) CN4125.142 ; CN4100.241 142.66,84.64 142.03,85.27 v2(141.8,85.27) 132.16,85.27 ; v1(108.81,63.78) 108.81,63.79 v1(109.41,63.79) CN4125.96 ; CN4100.178 126.91,72.81 v1(127.66,72.06) 127.56,72.06 127.16,71.66 CN4125.159 ; v1(86.93,85.19) 87.92,85.19 88.66,84.43 CN4100.33 ; C37.1 115.66,84.96 CN4100.141 115.66,81.6 v1(115.6,81.54) ; v1(120.77,71.43) 120.66,71.32 CN4125.141 ; CN4100.163 123.16,84.95 C4108.1 122.57,84.72 v1(122.16,84.72) CN4100.159 ; v1(94.84,72.75) 94.71,72.62 94.71,72.35 93.66,71.29 CN4125.33 ; v1(98.88,62.87) 98.91,62.84 CN4125.54 ; v1(127.37,62.96) 127.41,62.92 CN4125.160 ; v1(119.52,63) 119.41,62.88 CN4125.136 ; v1(127.66,71.43) 127.83,71.43 128.16,71.11 CN4125.163 ; CN4100.147 119.16,85.04 C4118.1 C4117.1 120.5,85.07 120.85,85.43 v1(121.26,85.43) 121.26,85.02 120.66,84.43 CN4100.153 ; v1(115.67,72.45) 115.91,72.69 CN4100.142 ; CN4100.135 114.16,84.37 113.86,84.67 v1(113.34,84.67) 113.04,84.67 112.72,85 C4109.1 112.54,84.43 112.66,84.31 CN4100.129 ; v1(138.01,71.78) 137.53,71.78 137.16,71.4 CN4125.199 ; v1(138.01,71.78) 138.01,72.58 137.41,73.18 CN4100.220 ; v1(138.01,71.78) 147.02,71.78 147.66,71.14 CN4125.241 ; 132.16,85.27 CN4100.199 ; 132.16,85.27 131.42,85.27 v1(131.26,85.43) ; v1(94.36,73.21) 94.26,73.21 93.91,73.56 CN4100.54 ; CN4100.136 v1(114.41,73.27) 114.35,73.21 113.22,73.21 112.91,73.51 CN4100.130 ; v1(98.34,85.29) 99.16,84.46 CN4100.75 ; v1(114.86,62.85) 114.86,62.83 114.91,62.79 CN4125.118 ; CN4100.96 104.41,72.92 v1(103.62,72.13) 103.62,71.64 104.16,71.11 CN4125.75 ; CN4125.123 116.16,71.38 v1(116.25,71.48) ; CN4100.160 v1(122.41,72.78) ; CN4125.178 v1(131.91,62.95) ; CN4125.153 125.66,71.34 125.35,71.65 v1(124.53,71.65) 124.16,71.28 CN4125.147 ; CN4100.148 119.41,73.52 119.89,73.04 v1(120.64,73.04) 120.91,73.32 CN4100.154 ; v1(108.98,85.15) 109.25,84.87 C4116.1 109.66,84.83 CN4100.117 ; CN4125.129 117.66,71.15 117.9,71.4 v1(118.46,71.4) 118.81,71.4 119.16,71.06 CN4125.135 ; R4771.2 113.41,59.56 CN4125.112 113.41,62.46 113.23,62.88 v1(113.01,63.1) ; CN4100.118 109.91,72.37 109.61,72.07 108.93,72.07 v1(108.91,72.08) 108.91,72.08 108.41,72.58 CN4100.112 ; CN4125.117 114.66,71.27 115,71.61 v1(115,72.59) 114.26,72.59 113.16,71.48 CN4125.111 ; CN4125.148 124.41,62.77 124.02,63.15 v1(124.02,63.48) ; CN4125.154 v1(125.91,62.94) ; U4555.AR12 101.03,125.11 100.64,125.11 U4555.AT12 ; CN4125.130 v1(117.91,62.95) ; v1(108.03,85.99) 107.89,85.85 C4106.1 108.16,84.82 CN4100.111 ; v1(111.37,76.55) 111.41,76.51 CN4100.124 ; U4555.W6 113.57,120.94 v1(113.24,120.61) 113.17,120.61 U4555.AA6 ; v1(111.48,84.72) 111.33,84.87 C4119.1 110.79,84.66 111.16,84.29 CN4100.123 ; CN4125.12 v1(88.41,62.9) ; v1(142.41,63.02) CN4125.220 ; CN4125.124 v1(116.41,63.01)
  BOTTOM w0.381: v1(73.32,92.62) 72.48,92.62 Q7007.D 71.53,92.35 C7041.1
  vias: v1(78.23,72.52) v1(78.23,71.94) v1(78.51,71.38) v1(78.84,72.52) v1(78.84,71.94) v1(79.14,71.38) v1(79.47,72.52) v1(79.47,71.94) v1(79.78,71.38) v1(80.01,72.27) v1(115.76,120.61) v1(120.79,120.61) v1(120.82,86.01) v1(121.79,124.54) v1(122.47,120.61) v1(152.17,72.67) v1(152.17,72.09) v1(152.8,72.67) v2(111.71,72.39) v2(126.29,72.44) v5(77.54,70.23) v5(77.54,69.5) v5(77.57,71.02) v5(78.25,70.56) v5(79.02,70.56) v5(79.8,70.56)
P1V05A: length 39
  TOP w0.254: v1(249.86,63) 249.98,63.11 R4891.1
  TOP w0.381: C4892.1 239.45,64.67 239.07,65.05 ; 237.26,66.52 C4858.1 ; 238.15,66.52 C4847.1 ; 226.5,52.31 C7037.1 ; 244.79,56.8 C4854.1 C4891.1 ; 244.39,55.54 C4860.1 ; 247.22,54.21 C4865.1 ; C4853.1 248.58,49.96 ; 241.5,53.92 C4855.1 ; 250.2,53.14 C4851.1 ; C4862.1 238.78,48.88 ; 240.61,53.92 C4850.1 ; 238.67,66.45 C4848.1 ; 240.87,52.58 C4890.1 ; C4843.1 247.01,56.96 ; 250.2,50.6 C4864.1 ; 245.22,56.96 C4844.1 ; 230.89,52.54 C7038.1 ; C4863.1 237.89,48.88 ; 247.43,56.96 C4866.1 ; 238.67,65.56 C4849.1 239.07,65.11
  BOTTOM w0.254: R4872.1 242.18,36.05 v1(242.18,35.41) ; U4710.W31 v1(246.9,50.46) ; U4710.V27 v1(245.37,52.02) U4710.U26 ; U4710.AA23 v1(247.7,53.55) ; U4710.B2 237.98,64.47 U4710.B3 ; v1(249.97,51.25) U4710.AF30 v1(249.97,50.47) U4710.AG31 ; U4710.AA22 v1(246.92,54.37) U4710.W22 ; U4710.AD30 v1(248.51,50.51) ; U4710.W20 v1(246.92,55.07) ; U4710.AF23 v1(250.02,53.55) ; U4710.AD31 v1(249.24,50.47) U4710.AF31 ; v1(241.65,73.74) 241.65,73.66 241.26,73.27 R4864.2 ; U4710.U29 245.28,50.49 v1(245.26,50.47) ; v1(248.47,52.8) U4710.AB27 v1(248.47,52.02) ; U4710.AE17 249.11,56.9 v1(248.69,56.9) ; U4710.V25 v1(246.15,52.8) ; U4710.W23 v1(246.92,53.55) ; U4710.AB23 v1(248.47,53.55) ; U4710.V31 v1(246.11,50.44) ; R4879.2 R4890.2 252.07,72.05 252.12,72.1 R4876.2 251.98,72.12 251.47,72.63 v1(251.47,73.13) 251.47,73.73 251.74,73.99 R4880.2 ; U4710.AD23 v1(249.24,53.55) ; U4710.W19 v1(246.92,55.9) ; U4710.AB22 v1(248.47,54.37) ; U4710.V28 v1(246.14,52.01) ; U4710.AD27 v1(249.24,52.02) ; U4710.AD20 v1(249.24,55.07) ; v1(246.13,51.23) U4710.V30 ; U4710.AF27 v1(250.02,52.8) ; U4710.V19 v1(246.15,55.9) ; U4710.AB20 v1(248.47,55.07) ; U4710.AB28 v1(248.47,51.25) U4710.AB30 ; U4710.AD28 v1(249.24,51.25)
  BOTTOM w0.381: 232.77,51.63 C7550.1 ; C3.1 233.15,37.19 ; C10.1 233.15,36.27
  vias: v1(227.33,49.79) v1(227.94,49.79) v5(230.35,51.06) v5(230.35,50.32) v5(231.09,51.06) v5(231.14,50.31) v5(231.83,51.08) v5(231.87,50.3) v5(232.61,51.08) v5(232.61,50.32) v5(233.45,36.12) v5(234.18,36.12) v5(236.57,66.2) v5(237.03,65.62)
P1V8_MAIN:
  vias: v2(195.91,166.3)
P1V8_MAIN_CT: length 1.9
  TOP w0.254: C55302.1 194.44,169.32 194.52,169.24 194.87,169.24 v2(194.94,169.17) 195.02,169.09 U55300.6
P1V8A: length 469.5
  TOP w0.254: v1(267.59,61.93) 267.59,56.05 268.6,55.04 v1(268.6,54.64) ; C4.1 249.52,59.29 R4924.2 ; C4.1 249.21,59.27 249.13,59.35 249.11,59.35 v1(248.82,59.64) ; C4.1 249.5,58.64 R4900.2 ; v1(73.67,57.84) 73.68,57.85 73.68,58.07 73.94,58.32 75.99,58.32 76.26,58.06 117.74,58.06 126.97,48.82 127.45,48.82 128.44,47.83 R67005.1 ; v5(280.64,64.32) 280.64,65.21 279.65,66.2 276.86,66.2 272.92,70.13 265.38,70.13 v1(264.97,70.54) 264.92,70.59 259.28,70.59 256.94,68.25 256.94,67.39 257.45,66.89 R4601.1 R4731.2
  L3 w0.254: v1(268.6,54.64) 267.81,53.85 266.04,53.85 265.71,53.52 263,53.52 262.26,52.78 260.44,52.78 258.7,54.53 258.7,54.79 257.99,55.49 257.59,55.49 257.43,55.32 253.57,55.32 253.29,55.61 253.29,55.89 249.54,59.64 v1(248.82,59.64)
  L5 w0.254: v1(68.48,50.75) 68.48,49.31 71.35,46.43 72.51,46.43 76.1,42.85 76.1,32.54 80.26,28.38 106.83,28.38 108.81,30.35 123.15,30.35 126.83,26.67 168.63,26.67 168.81,26.49 196.99,26.49 199.54,29.04 202.64,29.04 204.16,30.56 206.93,30.56 208.3,29.19 210.28,29.19 211.25,28.22 214.88,28.22 215.29,28.63 217.28,28.63 218.07,27.84 v5(218.07,27.82) ; 219.27,28.07 219.02,27.82 v5(218.81,27.82)
  L5 w0.762: v5(280.64,64.32) 280.64,63.27 283.88,60.03 283.88,59.58 285.51,57.95 285.51,46.33 272.13,32.95 267.74,32.95 263.93,29.14 251.63,29.14 250.39,27.89 242.72,27.89 241.8,28.81 238.17,28.81 236.93,27.56 224.71,27.56 224.18,27.03 222.63,27.03 221.59,28.07 219.27,28.07
  L8 w0.254: v1(66.24,89.28) 65.56,89.28 63.78,87.5 63.78,83.07 63.5,82.79 63.5,82.71 62.4,81.61 62.4,66.12 70.15,58.37 73.14,58.37 v1(73.67,57.84) ; v1(267.59,61.93) 268.73,63.07 279.4,63.07 v5(280.64,64.32)
  BOTTOM w0.254: R4732.2 R4724.2 260.14,72.6 260.63,73.08 261.57,73.08 262.7,71.94 R4725.2 264.51,71 v1(264.97,70.54) ; v1(268.6,54.64) 268.45,54.64 268.38,54.71 R4824.2 ; v1(68.48,50.75) 68.82,51.1 70.52,51.1 73.07,53.65 73.07,57.24 v1(73.67,57.84) ; R7066.2 v1(66.24,89.28)
  BOTTOM w0.381: 280.8,63.17 C7020.1 281.25,64.01 280.95,64.32 v5(280.64,64.32)
P1V8A_1P: length 10.7
  TOP w0.254: v1(253.68,57.88) 254.39,57.88 C4830.1 ; C5.1 252.34,58.44 252.36,58.47 v1(252.85,58.47) ; C5.1 R4920.1 ; C5.1 251.2,58.73 R4924.1
  L5 w0.254: v1(253.68,57.88) 254.85,57.88 v3(257.12,60.15)
  BOTTOM w0.254: v3(257.12,60.15) 257.22,60.05 U4710.BB11 ; U4710.AR15 254.14,57.94 253.77,57.94 253.7,57.88 v1(253.68,57.88) 253.44,57.88 U4710.AN15 v1(252.85,58.47)
P1V8S: length 354.3
  TOP w0.254: v1(26.77,49.96) R515.1
  L3 w0.254: v1(37.59,56.12) 35.18,53.7 29.33,53.7 26.77,51.13 v1(26.77,49.96)
  L3 w0.762: v5(280.64,60.73) 280.64,59.97 282.47,58.14 284.35,58.14 285.31,57.18 285.31,47.37 v5(287.27,45.42)
  L5 w0.762: v5(287.27,45.42) 287.27,42.19 299.51,29.95 299.51,26.52 295.75,22.76 295.75,20.3 294.94,19.49 291.64,19.49 291.16,19.97 261.85,19.97 261.05,20.77 259.58,20.77 259,20.2 259,19.74 258.62,19.36 208.48,19.36 206.91,20.93 206.91,21.71 203.14,25.48 185.11,25.48 184.29,24.65 127.95,24.65 122.89,29.72 110.05,29.72 108.07,27.74 78.18,27.74 v5(77.21,28.71)
  L8 w0.762: v5(77.21,28.71) 75.66,30.25 60.65,30.25 54.51,36.4 46.2,36.4 41.49,41.11 34.63,41.11 29.69,46.05 29.69,47.73 27.46,49.96 v1(26.77,49.96)
  BOTTOM w0.254: v5(280.64,60.73) 280.64,61.09 280.32,61.41 U7002.8 ; R3002.1 v1(37.59,56.12)
P1V8S_AON1: length 564.5
  TOP w0.2: C51047.1 199.82,118.54 v4(200.11,118.64)
  TOP w0.225: C51148.1 173.86,85.63 173.94,85.7 v4(173.94,86.16) ; C50649.1 165.66,174.93 v4(165.63,174.9) ; v4(213.66,121.6) 214.09,121.6 C51048.1 ; v4(173.6,99.16) 173.6,99.19 173.79,99.38 C51147.1 ; v4(185.32,99.86) 185.23,99.95 C51247.1 186.52,100.35 187.27,99.6 C51249.1 ; C50548.1 181.79,161.34 v4(181.66,161.47) ; v4(162.68,175) 162.68,175.41 C50648.1 ; v4(170.76,86.23) 170.4,85.87 C51149.1 ; v4(213.52,118.68) 213.54,118.7 C51049.1 ; v4(178.85,162.15) 178.85,161.8 C50547.1 ; v4(185.35,86.44) 185.48,86.31 C51248.1 ; C50949.1 213.92,106.46 v4(213.85,106.39) ; C51250.1 v4(188.42,86.19) ; C50550.1 182.02,175.29 v4(181.68,174.95) ; v4(170.76,99.84) 171.25,99.84
  TOP w0.254: C50748.1 214.1,141.75 v4(213.96,141.88) ; C50948.1 200.6,106.33 v4(200.81,106.12) ; R51500.2 R51501.2 ; R51501.2 149.55,99.25 149.81,99.5 149.81,101.53 v1(149.73,101.6) ; R51501.2 149.15,98.63 v1(149.5,98.28) 149.53,98.3 R51432.1 ; v1(153.41,105.21) 153.51,105.21 153.9,105.59 153.9,107.53 v1(153.36,108.07) 156.37,108.07 157.2,107.24 v1(157.2,107.06) ; R51562.2 159.72,90.31 R51569.2 ; C50549.1 178.58,175.49 178.55,175.47 178.55,175.44 178.71,175.28 v4(178.71,175.03) ; 154.65,90.76 R51436.1 R51440.1 154.63,93.04 154.63,94.01 R51565.2 ; 154.65,90.76 155.37,90.76 v1(155.51,90.61) ; 154.65,90.76 R51438.1 154.65,90.27 154.4,90.02 153.59,90.02 153.39,89.82 149.02,89.82 148.54,90.31 R51434.1 148.12,90.31 147.42,91.01 R51430.1 ; v4(186,86.22) 185.68,85.9 C51248.1 185.51,85.87 C51246.1 ; C50546.1 181.92,175.62 C50550.1 ; C50647.1 165.54,161.35 v4(165.64,161.45) ; v1(146.28,100.41) 146.28,101.07 146.88,101.68 146.88,102.75 145.01,104.63 145.01,107.85 147.73,110.57 147.73,121.64 147.27,122.1 144.75,122.1 144.4,122.46 v1(144.4,122.71) ; 171.25,99.84 C51150.1 173.69,99.83 C51147.1 ; v4(200.87,122.35) 200.74,122.22 C51050.1 ; R51569.2 159.84,90.31 160.99,89.16 162.2,89.16 162.51,89.46 R51568.2 163.42,90.31 163.5,90.23 L52110.1 164.67,90.23 164.77,90.33 v1(165.25,90.33) ; R51569.2 v1(159.79,89.34) ; C51249.1 188.82,99.6 v4(189.05,99.84) ; C50850.1 214.22,160.4 v1(214.01,160.19) ; C50846.1 214.92,157.5 v4(213.82,157.5) 213.73,157.41 213.73,157.02 C50849.1 ; C51148.1 173.44,85.63 173.39,85.68 172.92,85.68 172.18,84.94 170.59,84.94 C51146.1 170.4,85.13 C51149.1 ; C50847.1 200.48,160.97 v4(200.48,160.96) ; v4(200.48,141.91) 200.35,141.77 C50750.1 ; C50650.1 162.39,161.96 v4(161.91,161.47) ; C50749.1 201.04,144.79 v4(201.15,144.68) ; C50848.1 200.96,157.96 v4(200.51,157.5) ; C50746.1 214.53,145.35 C50747.1 214.52,145.15 v1(214.25,144.87) ; C51049.1 214.25,118.85 C51046.1 ; 199.31,168.49 C55301.2 ; v1(214.96,104.12) C50946.1 214.3,103.5 C50950.1 213.7,103.38 v4(213.61,103.29) ; C50646.1 165.51,175.62 C50649.1 ; C50947.1 200,103.18 v4(200.13,103.31)
  TOP w0.381: R51752.1 163.09,111.87 162.23,111 162.23,108.82 163.09,107.95 v1(163.22,107.95)
  L3 w0.3: v4(180.25,169.22) 180.25,166.75 180.73,166.28 180.73,162.4 181.11,162.02 v4(181.66,161.47) ; v1(178.8,89.03) 178.93,89.03 179.87,89.97 179.87,96.46 v1(180.42,97.01) ; v4(207.59,143.31) 205.2,143.31 204.36,142.47 201.05,142.47 v4(200.48,141.91) ; v4(200.13,103.31) 200.87,104.05 207.47,104.05 207.88,104.46 v4(207.88,104.71)
  L3 w0.305: v4(170.76,86.23) 170.26,85.72 166.5,85.72 164.41,87.81 164.41,89.64 165.1,90.33 v1(165.25,90.33) 165.16,90.42 165.16,95.72 165.46,96.02 v1(165.76,96.02) 165.48,96.3 165.48,99.01 163.6,100.89 163.6,107.57 v1(163.22,107.95) 158.08,107.95 v1(157.2,107.06)
  L5 w0.254: v5(219.81,97.56) 219.81,96.9 217.27,94.36 217.27,87.81 220.51,84.57 229.52,84.57 230.28,85.33 230.99,85.33 231.27,85.05 231.27,84.69 234.75,81.21 240.26,81.21 243.69,77.78 255.51,77.78 v1(259.03,81.3)
  L8 w0.254: v1(144.84,41.86) 145.92,42.94 148.62,42.94 151.91,46.23 151.91,50.35 152.98,51.41 152.98,59.33 155.58,61.93 155.58,74.8 154.97,75.4 154.97,90.08 v1(155.51,90.61)
  L8 w0.3: v4(200.51,157.5) 201.22,158.21 203.74,158.21 204.62,159.09 v4(208.71,159.09) ; v4(200.87,122.35) 201.34,121.88 202.44,121.88 202.85,121.46 ; v4(170.76,99.84) 170.29,100.3 167.56,100.3 166.39,99.13 166.39,96.57 165.84,96.02 v1(165.76,96.02) ; v4(161.91,161.47) 162.76,162.33 162.76,162.71 163.69,163.64 163.69,170.82 v4(163.76,170.89) ; 202.85,121.46 204.04,121.46 204.75,120.76 212.82,120.76 v4(213.66,121.6) ; 202.85,121.46 202.85,120.59 202.01,119.75 201.22,119.75 v4(200.11,118.64) ; v4(178.85,162.15) 179.02,162.15 179.45,162.57 179.45,165.47 180.25,166.28 v4(180.25,169.22)
  L10 w0.25: v4(201.15,144.68) 201.63,144.2 204.63,144.2 205.7,143.14 207.42,143.14 v4(207.59,143.31) 207.65,143.37 212.64,143.37 213.96,142.05 v4(213.96,141.88) ; v4(177.55,99.87) 178.08,99.34 178.08,89.63 178.68,89.03 v1(178.8,89.03)
  L10 w0.254: v1(259.03,81.3) 285.28,81.3 286.08,80.5 294.71,80.5 297.94,77.27 v1(297.94,75.9)
  L10 w0.3: v4(200.81,106.12) 200.81,105.93 201.39,105.35 204.84,105.35 205.44,104.75 206.67,104.75 206.99,105.07 207.58,105.07 207.88,104.77 v4(207.88,104.71) ; v4(200.48,160.96) 201.06,160.39 201.83,160.39 202.76,159.46 207.3,159.46 207.68,159.09 v4(208.71,159.09) 209.56,158.24 213.08,158.24 v4(213.82,157.5) 214.92,158.6 v1(215.07,158.6) ; v4(189.05,99.84) 189.54,100.33
  BOTTOM w0.2: v4(185.35,86.44) 185.35,86.51 185.14,86.71 U51200.V10
  BOTTOM w0.25: U50800.V5 v1(214.01,160.19) ; U51200.V5 188.42,86.45 v4(188.42,86.19) ; U51000.V5 v4(213.66,121.6) ; v4(162.68,175) U50600.V5
  BOTTOM w0.254: R56691.2 301.37,72.16 301.62,72.42 ; R51564.2 v1(153.36,108.07) 153.76,107.67 R51566.2 ; U50700.V10 v4(201.15,144.68) ; 139.98,43.92 139.98,45.22 139.98,45.22 139.98,46.03 139.44,46.57 135.6,46.57 135.6,46.56 R51524.2 133.59,46.56 R51523.2 ; 139.98,43.92 139.96,43.95 R51533.2 138.95,43.61 138.4,43.06 R51534.2 ; 139.98,43.92 140.52,43.39 143.31,43.39 v1(144.84,41.86) C50020.1 145.42,41.73 145.84,41.31 U50020.5 ; C52100.2 159.03,90.85 159.79,90.1 v1(159.79,89.34) 159.44,88.98 UU52100.A2 UU52100.B2 ; C52100.2 158.85,91.95 C51400.1 158.85,93.68 R51550.2 158.13,93.97 158.04,94.06 158.04,95.15 158.51,95.62 Q51550.G ; C52100.2 U51400.8 ; v1(163.22,107.95) 164.09,107.95 164.72,107.32 166.52,107.32 166.74,107.1 166.74,105.36 166.16,104.78 165.34,104.78 R51583.2 165.27,105.82 R51586.2 ; U50700.V5 v4(200.48,141.91) ; v1(146.28,100.41) 146.38,100.31 150.31,100.31 ; v1(149.5,98.28) 150.31,99.09 150.31,100.31 ; R50011.2 143.94,123.17 v1(144.4,122.71) 143.96,122.27 R51510.2 ; U50700.A5 v4(213.96,141.88) ; U51400.8 157.45,93.56 R51424.2 ; U51400.8 U51400.7 156.18,91.28 v1(155.51,90.61) 155.21,90.31 155.21,88.62 154.91,88.32 U51400.3 154.91,85.96 154.25,85.3 R51400.2 ; v1(153.41,105.21) 152.83,104.63 151.96,104.63 151.49,105.1 R51567.2 ; U50700.A10 213.61,145.27 214,144.87 v1(214.25,144.87) ; R51560.2 R51561.2 152.26,108.5 R51563.2 152.26,106.68 151.49,105.9 R51567.2 ; R56692.2 R56690.2 301.62,72.42 ; 150.31,100.31 151.32,100.31 Q51545.G ; R51567.2 151.32,105.04 R51540.2 150.39,104.78 150.39,102.95 149.73,102.29 v1(149.73,101.6) ; v1(297.94,75.9) 298.8,75.04 300.14,75.04 301.62,73.56 301.62,72.42 ; R51545.2 157.6,107.46 v1(157.2,107.06)
  BOTTOM w0.3: U50600.A10 v4(165.64,161.45) 166.23,160.86 169.32,160.86 170.45,162 v4(170.45,164.3) ; v4(200.81,106.12) 200.81,106.39 U50900.V10 ; v4(213.82,157.5) 213.82,157.05 U50800.V10 ; v4(200.51,157.5) 200.51,157.19 U50800.A10 ; U51100.A10 174.13,86.62 173.94,86.42 v4(173.94,86.16) ; v4(170.76,99.84) U51100.V5 ; v1(180.42,97.01) 180.42,97.03 180.97,97.58 180.97,99.41 181.93,100.37 184.69,100.37 185.21,99.86 v4(185.32,99.86) U51200.A10 ; v4(165.63,174.9) 165.73,174.9 U50600.V10 ; v4(177.55,99.87) 176.98,100.44 175.1,100.44 U51100.V10 174.12,99.46 173.82,99.16 v4(173.6,99.16) ; v4(181.66,161.47) U50500.V5 ; v4(200.13,103.31) U50900.V5 ; U50900.A10 213.32,106.69 213.62,106.39 v4(213.85,106.39) ; v4(213.52,118.68) 213.52,118.51 U51000.V10 ; v4(181.68,174.95) U50500.A5 ; v4(200.11,118.64) U51000.A10 ; v4(178.71,175.03) U50500.A10 ; v4(178.85,162.15) 178.58,162.15 178.28,161.85 U50500.V10
  BOTTOM w0.4: v4(200.48,160.96) U50800.A5 ; v4(213.61,103.29) U50900.A5 ; v4(200.87,122.35) 200.86,122.35 U51000.A5 ; v4(189.05,99.84) U51200.A5 ; U50600.A5 v4(161.91,161.47) ; U51100.A5 170.76,86.33 v4(170.76,86.23)
  vias: v5(198.19,167.39) v5(198.19,166.65) v5(198.93,167.39) v5(198.93,166.65) v5(209.45,174.04) v5(209.47,173.26) v5(210.18,174.02) v5(210.21,173.23) v5(219.81,98.33) v5(220.55,98.33) v5(220.55,97.56)
P1V8S_AON2: length 31.7
  TOP w0.254: C52321.1 159.64,120.27 ; 159.46,120.83 C52302.1 ; 159.09,121.92 C52301.1 ; C52320.1 158.46,120.02 ; 158.41,120.71 C52300.1 ; 159.59,118.6 C52322.1
  TOP w0.381: 160.44,120.6 C52311.1 C52312.1 ; C52310.1 159.05,118.03
  TOP w0.508: 159.78,117.8 161.01,116.57 C52001.1 161.01,114.97 161.51,114.47 161.51,108.62 163.68,106.45 v2(163.68,92.43) 163.68,91.6 163.52,91.44 L52110.2
  vias: v4(158.92,122) v4(158.9,121.31) v4(158.85,120.68) v4(158.9,119.49) v4(159.56,120.65)
P1V8S_AUDIO: length 6.9
  TOP w0.254: R515.2 26.46,51.87 25.74,51.87 25.7,51.91 C513.1 25.68,52.65 v2(25.42,52.91) 24.99,52.91 23.97,53.93 23.97,54.57 23.03,55.52 U500.40
P1V8S_MAIN1: length 25.2
  TOP w0.254: C50080.1 157.07,130.23 v4(157.48,130.63) 157.13,130.98 C50070.1 157.4,131.3 ; L50100.1 190.89,158.26 L51300.1 ; 159.03,129.66 C50081.1 ; C50072.1 158.37,130.5 ; C50073.1 158.7,129.9 ; C50074.1 157.4,131.58 ; 159.03,130.26 C50082.1 ; 158.95,131.46 C50084.1 ; 158.95,132.07 C50071.1 ; 159.03,130.86 C50083.1
  TOP w0.381: 157.47,132.93 C50075.1
  L5 w0.254: 140.71,141.38 140.71,135.23 143.46,132.49 143.46,127.64 v1(144.18,126.91)
  BOTTOM w0.254: R51525.2 144.22,126.95 v1(144.18,126.91) R50010.2
  BOTTOM w0.381: 144.74,141.92 C50085.1 ; 142.81,140.1 C50076.1
  vias: v1(141.35,141.15) v1(142.24,141.5) v1(142.97,141.5) v1(143.71,141.12) v1(144.01,141.91) v1(144.29,141.12) v1(144.93,141.13) v1(191.74,158.5) v1(191.74,157.92) v2(158.29,132.44) v2(192.3,166.04) v4(157.48,132.64) v4(158.14,133.43) v4(158.19,131.37) v4(158.16,130.61) v4(158.8,130.64) v4(158.81,129.92) v5(192.16,168.3) v5(192.16,167.54) v5(192.9,168.3) v5(192.9,167.57)
P1V35S_FBVDDQ: length 510.7
  TOP w0.102: v4(170.01,97.59) 170.39,97.97 170.39,98.6 ; 191.69,89.89 191.69,91.19 ; 170.56,97.21 170.96,97.21
  TOP w0.127: 191.7,88.92 191.7,88.35 191.69,88.34
  TOP w0.15: v4(203.14,114.83) 203.4,114.83 C51057.1
  TOP w0.225: v4(189.05,96.09) 189.05,96.09 C51236.1 ; 208.38,114.78 v4(208.38,114.87) ; C50842.1 206.8,163.97 v4(206.48,163.97)
  TOP w0.254: 200.31,98.67 C50928.1 ; 180.34,122.26 C53026.1 ; C51253.1 189.28,91.06 v4(189.05,90.84) 188.64,91.25 C51241.1 188.32,91.51 ; C51257.1 192.1,97.55 v4(192.08,97.58) ; C51257.1 C51215.2 ; C51257.1 193.01,97.55 ; C53039.1 176.08,140.46 ; 210.64,113.85 C51043.1 ; C53010.1 168.06,141.69 ; 166.7,89.77 C51123.1 ; 166.12,170.16 C50652.1 166.12,170.93 v4(166.41,171.22) ; v4(213.28,141.96) 213.12,142.12 C50740.1 213.12,142.77 ; 204.67,145.35 C50733.1 ; 206.22,154.56 C50840.1 ; C51236.1 188.43,97.03 ; v4(158.91,171.97) 158.79,171.85 C50654.1 157.89,171.85 ; 210.86,164.24 C50858.1 ; v4(175.66,167.47) 175.92,167.21 C50526.1 176.15,167.54 ; 211.98,125.69 C51060.1 211.98,126.45 ; 212.6,137.26 C50732.1 ; v4(204.24,141.94) 203.74,142.43 C50738.1 203.52,142.76 ; v4(177.52,99.09) 177.71,98.9 C51127.1 178.45,98.9 ; 192.35,89.44 C51242.1 192.62,89.38 192.1,89.38 v4(192.05,89.34) ; 182.15,165.61 C50554.1 ; v4(209.64,118.77) 209.12,118.25 C51062.1 208.79,118.24 ; 166.12,87.94 C51144.1 166.9,87.94 v4(167.01,87.84) ; 203.55,152.48 C50828.1 ; C51038.1 208.98,126.9 ; C51045.1 205.46,115.14 ; v4(181.51,96.83) 181.78,96.56 C51229.1 181.45,96.33 ; 193.06,86.41 C51227.1 192.12,86.41 v4(192.05,86.34) 191.97,86.26 C51222.1 191.97,85.32 ; 204.19,106.69 C50934.1 ; 180.88,137.75 C53034.1 ; v4(192.17,91.56) 192.28,91.45 192.67,91.45 C51261.1 192.38,91.41 ; 166.74,94.43 C51142.1 166.3,94.43 166.03,94.7 ; C53033.1 175.81,142.93 ; 193.01,99.18 C51238.1 192.19,99.18 v4(192.08,99.07) ; C51025.1 209.67,121.81 ; C53042.1 173.31,140.99 ; v4(182.22,99.86) 181.99,99.63 C51258.1 181.2,99.63 ; C53021.1 167.66,119.31 ; v4(174.91,169.72) 174.91,169.77 174.27,170.41 C50522.1 173.94,170.47 ; 157.96,174.83 C50628.1 158.76,174.83 v4(158.91,174.97) 159.05,175.11 C50660.1 159.05,175.92 ; v4(184.55,90.09) 184.85,90.39 C51232.1 184.85,91.18 ; 213.22,143.95 C50757.1 ; 185.11,169.21 C50556.1 185.46,169.23 185.46,169.67 v4(185.41,169.72) ; 180.84,89.03 C51243.1 181.51,89.36 v4(181.52,89.34) ; C53009.1 168.66,141.69 ; 212.34,148.94 C50742.1 ; 166.09,97.14 C51137.1 166.56,97.14 v4(167.01,97.59) 166.85,97.75 C51128.1 166.09,97.75 ; 173.73,141.49 C53029.1 ; C51042.1 208.96,122.29 ; 204.17,152.48 C50862.1 ; v4(169.45,164.48) 169.19,164.75 C50653.1 169.51,164.98 ; 205.71,144.64 C50727.1 ; C51230.1 183.16,93.92 ; 203.66,114.76 C51057.1 ; 212.21,119.23 C51054.1 ; 188.87,95.2 C51228.1 ; 199.22,109.99 C50933.1 ; 185.7,98.87 C51225.1 185.81,99.09 v4(185.3,99.09) ; v4(181.56,87.81) 181.41,87.96 C51259.1 180.51,87.96 ; v4(171.02,89.37) 170.79,89.6 C51145.1 170.5,89.93 ; 188.16,90.4 C51256.1 188.75,90.4 v4(189.05,90.09) ; C53030.1 164.32,142.02 ; C53046.1 178.6,140.12 ; C53001.1 180.27,132.41 180.54,132.68 v4(180.54,132.8) 180.28,133.06 C53002.1 180.28,133.64 ; C53001.1 180.27,132.21 C53020.1 ; C53001.1 180.27,131.88 ; C50656.1 165.91,173.38 ; v4(185.76,87.46) 185.73,87.49 C51260.1 184.81,87.49 ; C53032.1 180.4,137.06 ; 193.08,87.96 C51255.1 192.17,87.96 v4(192.05,87.84) ; C51125.1 174.38,88.12 ; 203.64,148.92 C50729.1 ; 212.9,103.66 C50957.1 ; 173.99,166.62 C50560.1 174.8,166.62 v4(174.9,166.72) ; 185.65,173.59 C50557.1 ; 204.67,156.84 C50852.1 ; 187.38,87.08 C51224.1 188.08,87.08 v4(188.23,86.93) ; 212.49,156.67 C50843.1 ; 213.83,164.24 C50824.1 ; v4(174.91,171.97) 174.8,172.08 C50544.1 173.94,172.08 ; 158.49,169.62 C50657.1 158.74,169.78 v4(158.77,169.75) ; 191.99,100.08 C51240.1 ; 174.08,94.93 C51151.1 ; 213.53,98.63 C50954.1 ; v4(185.41,171.97) 185.55,172.12 C50541.1 186.28,172.12 ; 176.6,120.23 C53016.1 ; 184.9,94.89 C51251.1 184.9,95.74 v4(184.55,96.09) ; v4(167.01,91.59) 166.96,91.64 C51131.1 166.09,91.64 ; 212.06,98.66 C50953.1 ; 211.95,118.09 C51022.1 ; 214.66,115.08 C51041.1 214,115.08 v4(213.79,114.86) ; v4(185.4,171.2) 185.48,171.12 C50539.1 186.25,171.12 ; 199.97,114.49 C51044.1 ; 207.34,100.68 C50936.1 ; C51130.1 174.19,90.41 v4(174.51,90.09) ; C51130.1 174.51,90.58 ; C51130.1 174.02,90.58 173.84,90.76 ; 210.31,143.1 C50744.1 210.31,142.32 v4(210.29,142.29) ; 181.78,94.23 C51262.1 ; 163.6,174.06 C50641.1 162.82,174.06 v4(162.66,174.22) ; v4(168.66,166.72) 168.7,166.68 C50629.1 169.17,167.01 ; v4(162.95,171.6) 162.94,171.59 C50645.1 162.43,171.26 ; C51030.1 203.84,126.35 ; 210.13,137.31 C50725.1 ; 161.97,169.95 C50633.1 161.64,170.21 v4(161.91,170.47) ; 205.87,115.97 C51058.1 ; 179.55,174.06 C50530.1 178.85,174.06 v4(178.67,174.24) ; 201.7,160 C50859.1 ; v4(177.89,171.2) 178.23,170.86 C50525.1 177.9,170.74 ; 202.06,118.38 C51052.1 ; C53004.1 167.46,141.69 ; v4(185.32,96.81) 185.62,96.51 C51235.1 186.27,96.51 ; v4(170.88,95.84) 170.85,95.84 170.4,95.39 C51135.1 170.4,95.05 ; 185.62,164.55 C50536.1 ; v4(175.26,97.59) 175.26,97.59 C51129.1 174.69,97.92 ; C53022.1 179.87,127.78 ; 158.04,162.94 C50662.1 ; 203.14,113.92 C51055.1 ; 204,143.82 C50723.1 ; 201.76,98.69 C50932.1 ; 158.57,167.03 158.29,166.75 C50627.1 158.23,166.43 ; 203.71,157.55 C50853.1 ; C50753.1 211.13,137.94 ; 200.21,110.35 C50944.1 ; C50860.1 205.6,164.87 ; 210.84,148.92 C50751.1 ; 184.55,166.58 C50551.1 184.55,167.37 v4(184.66,167.47) ; 177.36,85.44 C51161.1 177.36,86.19 v4(177.51,86.34) 177.66,86.49 C51154.1 178.45,86.49 ; v4(181.55,86.19) 181.32,86.42 C51234.1 180.53,86.42 ; v4(213.98,138.16) 214.12,138.29 C50754.1 214.46,137.96 ; 179.44,122.72 C53031.1 ; 163.06,142.02 C53005.1 ; C53043.1 173.91,140.99 ; C51040.1 203.35,119.51 ; 210.58,98.66 C50937.1 ; 210.14,121.55 C51031.1 ; C50836.1 209.22,164.8 ; 170.3,91.15 C51153.1 170.3,90.38 v4(170.01,90.09) ; 171.2,120 C53011.1 ; 206.68,163.76 C50842.1 ; C53012.1 174.42,119.93 v4(174.44,119.91) ; 204.27,102.82 C50940.1 ; 174.39,95.89 C51156.1 173.86,95.89 v4(173.62,96.14) ; 181.61,85.91 C51226.1 181.61,85.22 ; v4(174.91,173.47) 174.76,173.33 C50529.1 173.96,173.33 ; 213.48,125.71 C51024.1 213.48,126.49 ; v4(177.51,89.34) 177.56,89.29 C51124.1 178.1,88.96 ; C50813.2 206.41,159.23 ; 210.53,125.71 C51034.1 210.53,126.52 ; 205.45,126.35 C51027.1 205.45,126 205.74,125.71 ; 162.43,164.88 C50655.1 ; 208.94,98.66 C50958.1 ; 210.01,103.05 C50926.1 ; v4(185.41,174.97) 185.28,175.1 C50555.1 185.28,175.84 ; 214.25,163.91 C50826.1 ; 188.19,98.16 C51244.1 ; 192.68,95.95 C51233.1 192.24,96.27 v4(192.05,96.09) ; 170.77,141.16 C53007.1 ; 182.12,170.16 C50533.1 ; v4(168.88,161.37) 168.73,161.23 C50643.1 168.73,160.5 ; 171.75,97.39 C51155.1 171.29,97.06 ; 173.21,89.84 C51159.1 173.53,89.56 v4(173.76,89.34) ; 161.37,166.22 C50636.1 162.05,166.22 ; 205.63,148.92 C50756.1 ; 201.86,143.77 C50743.1 ; 203.21,98.69 C50962.1 ; C53024.1 167.13,120.18 ; 178.93,171.58 C50545.1 ; 202.13,164.22 C50854.1 ; 213.49,110.35 C50941.1 ; 212.26,152.45 C50833.1 ; 177.77,119.92 C53015.1 ; 169.28,175.37 C50661.1 ; 185.65,161.65 C50523.1 ; C50927.1 209.4,107.07 ; 201.74,110.35 C50961.1 ; 167.13,85.47 C51157.1 167.13,86.25 v4(167.06,86.33) 166.89,86.5 C51141.1 166.12,86.5 ; 157.99,165.34 C50640.1 ; 210.68,105.29 C50924.1 ; 168.39,167.24 C50634.1 168.39,167.96 v4(168.66,168.22) ; C50761.1 208.68,137.89 ; 178.45,95.9 C51140.1 177.69,95.9 v4(177.57,96.02) ; C50752.1 209.75,145.66 ; v4(206.01,99.47) C50943.1 205.56,99.48 ; C53045.1 174.51,140.99 ; 214.88,148.5 C50762.1 214.13,148.5 v4(213.98,148.66) ; 166.19,96.27 166.42,96.04 C51143.1 166.74,96.04 ; C53003.1 180.12,134.95 ; 180.08,129.29 C53038.1 ; 173.96,174.83 C50524.1 174.76,174.83 v4(174.91,174.97) 175.06,175.13 C50561.1 175.06,175.87 ; 210.67,160.1 C50831.1 ; C50945.1 208.74,111 ; 180.08,136.12 C53000.1 ; 185.62,163.1 C50553.1 ; C53023.1 179.82,124.91 ; C50538.1 179.7,164.59 ; 209.91,158.29 C50851.1 209.91,157.56 ; C50834.1 209.8,156.84 ; 178.45,97.42 C51133.1 177.68,97.42 v4(177.52,97.59) ; 205.41,160.66 C50857.1 ; C53017.1 171.7,141.48 ; 213.05,159.36 C50844.1 ; 202.09,148.94 C50731.1 ; 166.12,165.69 C50659.1 ; 209.17,141.44 C50734.1 209.5,141.91 ; 158.03,164.55 C50644.1 ; 208.98,148.95 C50737.1 ; v4(174.88,164.47) 174.72,164.63 C50531.1 173.99,164.63 ; C51056.1 208.97,122.6 ; 201.42,121.52 C51061.1 ; C53027.1 180.98,125.23 ; 213.85,99.68 C50952.1 ; 202.95,106.53 C50929.1 ; 172.65,98.5 C51152.1 173.47,98.5 173.55,98.58 v4(173.6,98.58) ; 203.25,160.93 C50861.1 ; 173.96,163.08 C50527.1 174.79,163.08 v4(174.9,162.97) ; v4(181.66,162.22) 181.57,162.31 C50552.1 180.77,162.31 ; 200.33,153.15 C50830.1 ; C53013.1 176.33,120.23 ; 200.97,103.54 C50930.1 ; 203.97,121.47 C51035.1 ; 213.84,148.94 C50722.1 ; C53040.1 176.68,140.46 ; 210.49,110.33 C50935.1 ; 213.89,125.27 C51051.1 214.65,125.27 ; C50739.1 205.86,138.92 ; 205.13,122.26 C51039.1 ; 170.43,163.1 C50626.1 169.57,163.1 v4(169.45,162.98) ; C53006.1 162.95,141.73 ; 180.46,127.46 C53044.1 ; 162.22,166.53 C50658.1 ; 213.92,110.01 C50942.1 ; 210.94,143.95 C50726.1 ; 209.01,160.89 C50829.1 ; 180.51,91.02 C51254.1 180.99,91.02 v4(181.55,91.59) ; 170.27,87 C51162.1 170.27,87.57 v4(170.01,87.84) ; 203.66,137.29 C50730.1 ; 167.87,94.73 C51132.1 167.87,93.95 v4(167.76,93.84) ; C50735.1 205.86,138.3 ; 157.94,173.28 C50635.1 158.71,173.28 v4(158.91,173.47) ; 208.67,114.55 C51033.1 ; 169.85,173.28 C50625.1 ; v4(178.85,162.75) 179.07,162.98 C50537.1 179.7,162.98 ; v4(192.05,93.84) 192.26,94.04 C51223.1 192.68,93.71 ; 201.52,113.92 C51032.1 ; 179.89,133.65 C53019.1 ; C53028.1 181.04,130.69 ; 172.83,87.03 C51122.1 ; 203.61,164.22 C50855.1 ; 204.62,141.48 C50759.1 ; 180.7,174.25 C50540.1 ; v4(177.51,87.84) 177.64,87.97 C51158.1 178.4,87.97 ; v4(165.66,171.22) 165.33,170.9 C50638.1 164.74,170.9 ; C53035.1 180.16,137.66 ; 201.93,152.48 C50835.1 ; 180.15,120.63 v4(180.08,120.63) ; 208.82,102.85 C50939.1 ; 212.77,120.66 C51029.1 ; C53041.1 177.28,140.46 ; 174.98,160.56 C50528.1 174.98,161.33 v4(174.87,161.44) 174.76,161.55 C50532.1 173.96,161.55 ; 212.36,164.24 C50827.1 ; 169.67,171.88 C50642.1 ; C51139.1 171.64,99 ; 213,105.29 C50925.1 ; 164.74,164.73 C50637.1 ; C53018.1 172.3,141.48 ; C51053.1 209.53,119.62 ; 180.92,98.46 C51245.1 181.31,98.13 v4(181.51,98.33) ; 200.56,148.94 C50758.1 ; 185.55,166.85 C50558.1 ; 180.09,125.22 C53036.1 ; 203.28,110.33 C50956.1 ; 181.67,138.77 C53025.1 ; 180.11,119.04 C53047.1 ; C53037.1 180.41,130.23 ; 204.32,118.18 C51036.1 ; 185.44,89.56 C51237.1 185.11,89.9 v4(185.3,90.09) ; 181.03,126.39 C53008.1 ; 211.99,110.35 C50951.1 ; 210.39,141.65 C50724.1 ; 200.59,164.19 C50837.1 ; 210.86,152.45 C50856.1 ; C50845.1 210,159.77 ; C51136.1 171.8,87.18 ; C50825.1 205.89,153.72 ; 162.18,163.08 C50651.1 ; 201.32,142.14 C50760.1 ; 205.24,100.42 C50923.1 ; 201.65,105.16 C50922.1 ; 171.42,89.09 C51126.1 ; C50639.1 165.42,162.47 ; 181.58,171.71 C50542.1 ; C53014.1 179.82,124.3
  TOP w0.305: v4(170.76,99.09) 170.85,99 C51139.1
  TOP w0.381: R51205.2 186.61,91.15 ; 208.19,143.77 R50705.2 ; 195.44,115.15 R50320.2 ; R50420.2 168.75,113.94 ; 164.34,170.18 R50605.2 ; 205.03,104.89 R50905.2 ; 178.68,140.69 R52210.2 ; 208.68,119.47 R51005.2 ; R50805.2 209.21,158.47 ; C7502.2 204.99,111.55 ; 172.21,94.97 R51105.2 ; 183.9,104.94 R50421.2 ; C7500.2 171.21,171.8 ; C7501.2 202.33,151.23 ; 191.77,148.43 R50221.2 ; 179.71,98.47 C7503.2 ; R50505.2 180.18,166.33
  L3 w0.127: v4(209.64,118.77) 209.64,118.46
  L3 w0.254: v4(201.98,163.96) 202,163.96 202.26,163.71 ; v4(203.13,99.56) 203.13,99.28 ; v4(182.3,93.09) v4(182.3,92.34) ; v4(181.37,171.36) 181.59,171.36 ; v4(202.38,107.81) 202.38,108.01 ; v4(212.48,138.16) 212.48,137.86 ; v4(185.4,171.2) 185.75,171.2 ; v4(158.92,164.46) 158.92,164.3 ; v4(177.51,91.59) 177.84,91.59 ; v4(210.98,138.16) 210.98,137.84 ; 210.08,161.12 v4(210.23,160.96) ; v4(168.66,168.22) 168.66,168.4 ; v4(203.48,148.69) 203.77,148.69 ; v4(203.47,163.95) 203.47,163.7 ; 202.13,161.19 201.98,161.04 v4(201.98,160.96) ; v4(206.13,124.62) 206.13,124.93 ; v4(206.42,138.05) 206.42,137.75 ; v4(212.93,103.36) 213.16,103.36 ; v4(208.38,99.56) 208.38,99.25 ; v4(210.63,99.56) 210.63,99.26 ; v4(208.73,138.16) 208.73,137.85 ; v4(203.12,125.38) 203.4,125.38 ; v4(207.63,124.62) 207.63,124.96 ; v4(185.41,171.97) 185.73,171.97 ; 212.34,163.96 v4(212.48,163.96) ; v4(185.41,169.72) 185.69,169.72 ; v4(174.87,161.44) 174.87,161.21 ; v4(206.48,163.97) 206.48,164.1 ; v4(161.91,171.22) 161.91,171.01 ; v4(185.41,173.47) 185.71,173.47 ; v4(201.63,99.56) 201.63,98.95 ; v4(191.3,93.84) 191.61,93.84 ; v4(158.91,161.47) 158.57,161.47 ; v4(191.3,92.34) 191.6,92.34 ; v4(212.13,99.56) 212.13,99.27 ; v4(169.45,162.98) 169.2,162.98 ; v4(169.45,164.48) 169.23,164.48 ; 209.6,161.22 209.48,161.1 v4(209.48,160.96) ; v4(206.01,99.47) 206.01,99.24 ; v1(157.3,167.87) 156.94,167.87 ; v4(181.26,171.94) 181.26,171.8 ; v4(158.91,173.47) 158.91,173.63 ; v4(185.5,167.35) 185.69,167.35 ; v4(185.3,90.09) 185.08,90.09
  L3 w0.381: v4(177.89,163.71) 177.77,163.71
  L8 w0.254: v4(209.64,118.77) 209.64,118.77 209.39,118.52 ; v4(176.76,93.84) 176.76,94.14 ; 208.99,153.72 208.73,153.47 v4(208.73,153.46) ; v4(210.98,157.18) 210.94,157.21 v4(210.23,157.21) ; v4(177.51,91.59) 177.51,91.36 ; v4(181.51,96.83) 181.81,96.83 ; v4(181.55,86.19) 181.55,85.79 ; v4(207.63,109.3) 207.79,109.3 ; v4(161.91,162.97) 162.22,162.97 ; v4(169.42,173.49) 169.42,173.69 ; v4(167.76,93.84) 167.76,94.03 ; v4(206.48,163.97) 206.33,163.97 ; v4(177.55,95.36) 177.37,95.36 ; v4(201.41,106.12) 201.41,105.89 ; 168.47,166.55 168.65,166.72 v4(168.66,166.72) ; v4(203.88,102.57) 203.76,102.57 ; v4(181.26,171.94) 180.9,171.94 ; v4(189.05,87.84) 189.05,87.83 189.28,87.61 ; v4(206.88,115.62) 206.88,115.63 207.11,115.85 ; v4(182.3,93.09) 182.54,93.09 ; v4(201.98,163.96) 201.98,164.26 ; v4(184.66,168.97) 184.66,168.67 ; 174.85,87.51 174.52,87.84 v4(174.51,87.84) ; v4(200.13,125.37) 200.13,125.72 ; v4(181.56,87.81) 181.56,87.48 ; 182.47,94.76 v4(182.3,94.59) ; v4(210.6,103.5) 210.6,103.9 ; v4(210.21,141.14) 210.5,141.14 ; v4(170.69,119.78) 170.69,119.97 ; v4(213.39,144.81) 213.74,144.81 ; v4(210.98,153.44) 210.78,153.44 ; v4(181.37,171.36) 181.13,171.36 ; v4(208.38,109.31) 208.16,109.31 ; v4(189.05,96.09) 189.38,96.09 ; v4(171.02,89.37) 171.41,89.37 ; v4(208.75,148.68) 208.75,148.38 ; v4(204.24,141.94) 204.14,141.94 ; v4(204.23,145.7) 204.23,145.7 204.09,145.85 ; v4(209.48,160.96) 209.79,160.96 ; 191.54,92.1 v4(191.3,92.34) ; v4(158.91,165.22) 158.91,164.93 ; 204.11,141.28 204.23,141.16 v4(204.23,141.16) ; v4(166.92,93.96) 166.92,94.04 166.75,94.21 ; v4(170.76,99.09) 170.48,99.09 ; 184.88,98.83 184.55,98.5 v4(184.55,98.35) ; v4(212.48,148.66) 212.48,148.4 ; v4(162.66,174.22) 162.66,173.94 ; v4(213.98,138.16) 214.24,138.16 ; v4(203.89,103.35) 203.77,103.35 ; v4(158.91,167.47) v4(159.66,167.47) ; v4(161.91,170.47) 161.91,170.14 ; v4(192.05,93.84) 192.05,94.04 ; v4(185.5,167.35) 185.5,167.6 ; v4(207.23,138.91) 207,138.91 ; 212.75,145.93 v4(212.48,145.66) ; v4(181.53,165.52) 181.53,165.86 ; 177.49,96.02 v4(177.57,96.02) ; v4(172.14,119.44) 172.39,119.69 ; v4(202.73,145.69) 202.73,145.87 ; v4(191.3,93.84) 191.3,93.94 ; v4(185.41,173.47) 185.41,173.73 ; v4(162.95,171.6) 162.69,171.6 ; v4(185.41,164.47) 185.14,164.47 ; v4(181.51,98.33) 181.79,98.33 ; v4(210.23,160.03) 210.09,160.03 ; v4(206.48,163.21) 206.39,163.21 ; v4(210.96,148.71) 210.96,148.41 ; v4(200.48,163.96) 200.48,164.26 ; v4(201.98,160.96) 201.98,160.73 ; v4(208.38,110.06) 208.15,110.06 ; v4(182.3,92.34) 182.54,92.34 ; v4(166.41,171.22) 166.11,171.22 ; v4(210.29,142.29) 210.42,142.15 ; v4(182.43,171.2) 182.65,171.2 ; v4(185.3,99.09) 185.06,99.09 ; v4(173.62,96.14) 173.98,96.14 ; v4(161.91,171.22) 161.91,171.46 ; v4(189.8,97.59) 189.8,97.29 ; v4(176.76,91.59) 176.76,91.41
  L10 w0.254: v4(210.63,110.06) 210.92,110.06 ; v4(168.88,161.37) 168.88,161.37 168.7,161.55 ; 210.72,157.48 210.98,157.22 v4(210.98,157.18) 210.27,157.18 v4(210.23,157.21) ; v4(169.45,162.98) 169.15,162.98 ; v4(177.86,165.23) 177.6,165.23 ; v4(161.91,165.22) 161.9,165.22 161.69,165.43 ; v4(175.66,168.22) 175.94,168.22 ; v4(210.29,142.29) 210.29,142.58 ; v4(207.79,142.17) 207.79,142.42 ; v4(177.89,163.71) 177.58,163.71 ; v4(213.98,138.16) 214.22,138.16 ; v4(168.66,168.22) 167.84,168.22 ; v4(212.48,141.16) 212.48,141.31 212.78,141.61 ; 212.14,157.71 212.17,157.68 v4(212.66,157.68) ; v4(212.13,122.37) 212.13,122.13 ; v4(168.66,166.72) 168.66,166.45 ; v4(185.4,171.2) 185.4,170.95 ; 177.75,171.4 177.89,171.26 v4(177.89,171.2) ; v4(203.12,125.38) 202.9,125.38 ; v4(175.66,169.73) 175.92,169.73 ; v4(165.66,162.22) 165.9,162.22 ; v4(206.48,138.91) v4(207.23,138.91) ; v4(208.38,125.37) 208.25,125.37 ; v4(210.96,148.71) 211.29,148.71 ; v4(206.13,125.37) 205.97,125.37 ; v4(169.45,164.48) 169.15,164.48 ; v4(162.95,171.6) 162.95,171.24 ; 207.74,139.14 v4(207.98,138.91) ; v4(175.69,168.98) 175.98,168.98 ; v4(175.66,167.47) 175.95,167.47
  BOTTOM w0.225: v4(181.37,171.36) 181.79,171.36 U50500.E5 ; v4(185.4,171.2) 185.03,171.57 U50500.E1
  BOTTOM w0.25: U50800.E14 204.22,153.48 v4(204.22,153.41) ; v4(177.15,165.97) 177.16,165.97 177.53,165.6 ; v4(201.99,153.42) 201.86,153.29 201.37,153.29 v4(201.24,153.42) ; v4(204.98,160.96) U50800.F4
  BOTTOM w0.254: 213.82,111.8 C50960.1 ; 210.84,150.45 C50741.1 ; 163.63,87.6 C51134.1 ; 213.91,166.7 C50823.1 ; R50321.2 192.95,133.75 192.26,133.75 R50220.2 192.22,133.21 v1(192.48,132.95) ; v4(213.63,99.56) 214.04,99.16 C50959.1 214.04,96.2 ; C50918.1 v1(216.08,100.44) ; C50745.1 211.13,135.41 ; 188.17,173.71 C50543.1 ; 195.44,89.36 C51252.1 192.07,89.36 v4(192.05,89.34) ; 155.5,174.95 C50622.1 156.87,174.95 156.89,174.97 v4(158.91,174.97) ; 171.25,175.18 C50632.1 ; 212.04,128.11 C51026.1 ; 163.6,86.86 C51138.1 ; C51116.1 v1(216.08,99.06) ; v4(192.05,87.84) 192.06,87.83 ; 172.47,171.83 C50535.1 ; 195.44,86.31 C51231.1 192.08,86.31 v4(192.05,86.34) ; 171.25,171.88 C50631.1 ; 210.49,111.85 C50931.1 ; 172.52,175.16 C50559.1 ; v4(158.91,173.47) 156.4,173.47 v1(156.38,173.46) ; v1(194.61,87.81) 194.63,87.83 C51239.1 195.44,87.83 ; C51059.1 213.82,113.11 ; v1(209.54,97.06) 209.18,96.7 C51019.1 ; v1(160.95,152.2) 160.83,152.2 160.41,152.62 R50121.2 ; 188.49,175.28 C50534.1 188.06,174.95 v1(187.97,175.05) ; v4(167.01,89.34) 166.92,89.25 C51160.1 163.63,89.25 ; C51023.1 212.04,113.11 ; 213.56,128.11 C51037.1 ; 155.5,171.88 C50623.1 156.84,171.88 156.94,171.97 v4(158.91,171.97) ; 172.5,173.4 C50562.1 ; 155.5,173.43 C50630.1 ; 212.39,166.7 C50841.1 ; C50832.1 214.17,151.7 ; C50822.1 212.39,151.7 ; 171.25,173.4 C50624.1 ; C50921.1 v1(216.08,97.82) ; R50120.2 v1(181.02,151.84) ; 213.96,134.77 C50736.1 ; 210.86,166.7 C50838.1 ; C50938.1 210.51,113.11 ; C50955.1 212.39,112.47 ; C50728.1 212.74,150.74 ; C50839.1 210.86,151.7 ; 214.17,150.4 C50755.1 ; 210.51,128.11 C51028.1
  BOTTOM w0.28: v4(177.55,95.36) 177.57,95.38 v4(177.57,96.02)
  BOTTOM w0.3: v4(169.41,169.72) U50600.L14 v4(168.66,168.97) ; v4(185.42,161.46) U50500.V1 ; v4(174.91,174.97) U50500.A14 ; v4(203.89,103.35) 203.51,102.97 U50900.P5 v4(203.88,102.57) U50900.N4 ; v4(169.44,171.97) 169.06,171.6 U50600.P14 ; v4(206.13,109.31) U50900.K13 v4(206.88,109.31) U50900.J13 207.26,108.94 v4(207.63,109.3) 207.65,109.3 U50900.H13 v4(208.38,109.31) U50900.H14 v4(208.38,110.06) ; v4(206.13,109.31) U50900.L13 205.76,108.9 v4(205.41,108.56) ; v4(206.13,109.31) U50900.L14 ; v4(201.41,106.12) 201.41,106.53 U50900.U10 ; v4(209.64,118.77) 209.74,118.77 U51000.P10 v4(209.88,117.87) U51000.N11 ; v4(167.76,93.84) U51100.L1 167.17,94.21 v4(166.92,93.96) ; v4(167.76,93.84) U51100.L2 ; v4(167.76,93.84) U51100.K2 v4(167.76,93.09) U51100.J2 v4(167.76,92.34) ; U50900.C4 v4(212.13,102.56) U50900.B5 v4(212.93,103.36) ; U50800.F4 v4(204.23,160.96) U50800.E5 ; U51100.N11 174.88,95.76 174.54,96.1 v4(174.54,96.1) 174.18,96.46 U51100.P10 173.81,96.14 v4(173.62,96.14) ; v4(210.23,157.21) U50800.P10 v4(210.23,156.46) U50800.N11 ; v4(208.73,138.16) 208.55,138.34 ; U51200.T11 v4(184.55,87.84) ; v4(184.55,87.84) 184.58,87.84 ; v4(184.55,87.84) U51200.U10 v4(185.76,87.46) ; v4(192.05,93.84) 192.01,93.89 U51200.H1 v4(191.3,93.84) ; U50800.C14 201.99,153.47 v4(201.99,153.42) ; U50600.A1 v4(158.91,161.47) ; U50700.E1 210.81,138.33 v4(210.98,138.16) ; 176.06,167.1 U50500.L13 v4(175.66,167.47) ; U51200.V1 v4(192.05,86.34) ; v4(171.02,89.37) 170.72,89.37 U51100.E5 v4(170.01,90.09) U51100.F4 ; v4(167.01,97.59) U51100.T1 ; U50500.C11 177.53,173.1 177.9,173.47 v4(177.9,173.47) 177.91,173.47 178.28,173.85 ; U51100.P14 177.13,96.45 v4(177.57,96.02) ; U50500.N4 v4(182.4,165.21) U50500.P5 181.53,165.35 v4(181.53,165.52) ; U51200.T1 v4(192.05,87.84) ; U50900.V1 v4(200.15,100.3) ; v4(200.88,103.31) U50900.U5 v4(200.88,102.56) ; v4(167.01,96.09) U51100.P1 ; U50900.F4 v4(209.86,102.54) U50900.E5 210.6,103.28 v4(210.6,103.5) ; U50900.C11 212.13,107.07 v4(212.13,107.07) 212.13,107.06 U50900.B10 212.6,106.69 v4(213.12,106.17) ; v4(200.89,114.83) 200.89,114.86 U51000.A14 200.25,115.5 200.19,115.5 v4(200.12,115.56) ; U50900.A14 v4(213.63,110.06) ; v4(208.38,125.37) U51000.L1 v4(207.63,124.62) ; U50700.T4 v4(202.73,141.16) ; v4(182.22,99.86) 182.21,99.85 182.21,99.84 181.93,99.56 U51200.A14 ; U51000.P1 v4(210.63,125.37) ; v4(189.8,97.59) U51200.C4 v4(189.05,98.34) U51200.B5 ; U50800.L13 v4(207.98,154.21) ; v4(207.98,154.21) U50800.K13 v4(207.23,154.21) U50800.J13 U50800.H13 v4(205.73,154.21) U50800.H14 ; v4(207.98,154.21) U50800.L14 v4(208.73,153.46) ; U50800.E1 203.83,163.59 v4(203.47,163.95) ; U50700.A1 213.79,138.34 v4(213.98,138.16) ; v4(200.13,125.37) U51000.A1 ; v4(192.08,97.58) 191.69,97.96 U51200.C1 ; v4(189.05,90.84) U51200.N4 v4(189.05,90.09) U51200.P5 v4(188.3,89.34) ; v4(174.91,169.72) U50500.H14 v4(175.66,169.73) 176.03,169.36 U50500.H13 175.69,169 v4(175.69,168.98) 175.69,168.95 U50500.J13 v4(175.66,168.22) U50500.K13 ; U50800.P14 210.61,153.81 v4(210.98,153.44) ; 161.53,170.85 U50600.N4 ; v4(213.28,141.96) U50700.B5 v4(212.48,141.16) U50700.C4 ; U51000.L2 v4(207.63,124.62) ; v4(207.63,124.62) U51000.K2 ; v4(176.76,91.59) U51100.H14 v4(177.51,91.59) ; U51200.N11 v4(184.55,90.09) U51200.P10 v4(185.3,90.09) ; v4(165.66,171.22) U50600.P10 v4(166.41,171.22) U50600.N11 ; v4(158.92,164.46) 159.28,164.82 U50600.E1 v4(158.91,165.22) ; U51100.L14 v4(176.76,93.84) ; v4(176.76,93.84) U51100.L13 176.02,94.58 v4(176.02,94.58) ; v4(176.76,93.84) U51100.K13 v4(176.76,93.09) U51100.J13 176.72,92.32 v4(176.75,92.32) 176.74,92.26 U51100.H13 ; U51200.L13 v4(182.3,92.34) ; v4(182.3,92.34) U51200.L14 v4(181.55,91.59) ; v4(182.3,92.34) U51200.K13 v4(182.3,93.09) U51200.J13 ; U50600.T14 169.42,173.48 v4(169.42,173.49) ; v4(169.45,164.48) 169.4,164.48 U50600.E14 ; U51100.H2 v4(167.76,92.34) ; v4(167.76,92.34) U51100.H1 v4(167.01,91.59) ; U50800.J2 v4(206.48,163.21) ; v4(206.48,163.21) U50800.H1 206.43,163.92 v4(206.48,163.97) ; v4(206.48,163.21) U50800.H2 ; v4(203.13,99.56) U50900.P1 ; v4(213.38,144.81) 212.91,145.28 U50700.B10 212.86,145.28 212.48,145.66 v4(212.48,145.66) ; U51000.E5 v4(203.88,122.37) U51000.F4 v4(204.63,123.12) ; U51200.T4 v4(189.05,87.84) U51200.U5 188.23,87.02 v4(188.23,86.93) ; 161.53,165.6 v4(161.91,165.22) U50600.E5 ; 161.53,165.6 U50600.F4 ; 161.53,165.6 v4(161.16,165.97) ; U50700.F11 v4(210.23,145.66) U50700.E10 ; v4(206.13,125.37) 206.08,125.32 206.08,125.32 U51000.H1 v4(206.13,124.62) ; v4(181.66,162.22) U50500.U5 ; U51100.C4 v4(170.01,87.84) U51100.B5 ; U50900.E14 v4(210.63,110.06) ; U50800.T4 v4(212.48,160.96) U50800.U5 v4(213.23,160.21) ; v4(206.13,100.31) U50900.L1 205.76,99.73 v4(206.01,99.47) ; v4(206.13,100.31) U50900.K2 v4(206.88,100.31) U50900.J2 ; v4(206.13,100.31) U50900.L2 ; U50600.F11 v4(166.41,165.22) U50600.E10 v4(165.65,164.47) ; U50800.T11 v4(212.48,156.46) ; v4(212.48,156.46) 212.48,156.49 ; v4(212.48,156.46) U50800.U10 212.86,157.48 v4(212.66,157.68) ; U51200.P14 181.9,89.71 v4(181.52,89.34) ; v4(208.77,164.07) 208.77,164.01 U50800.L1 v4(207.98,163.21) ; U51200.L2 v4(191.3,92.34) ; v4(191.3,92.34) U51200.K2 ; v4(191.3,92.34) U51200.L1 192.08,91.56 v4(192.17,91.56) ; U50900.P10 v4(203.9,107.08) U50900.N11 ; v4(212.38,119.01) 212.51,118.89 U51000.U10 v4(212.13,117.87) ; v4(177.52,97.59) 177.14,97.96 U51100.T14 ; U50500.P10 178.24,164.85 v4(177.86,165.23) 177.53,165.55 177.53,165.6 U50500.N11 ; U50800.B5 v4(201.98,160.96) U50800.C4 v4(202.75,161.73) ; 178.28,173.85 U50500.B10 ; 178.28,173.85 v4(178.67,174.24) ; U50500.P1 v4(185.41,164.47) ; v4(209.48,160.96) U50800.N4 v4(210.23,160.96) U50800.P5 210.23,160.21 v4(210.23,160.03) ; U50700.T1 v4(201.98,138.16) ; U51000.C11 v4(201.64,117.87) U51000.B10 v4(200.88,118.62) ; v4(191.3,93.84) U51200.H2 ; v4(191.3,93.84) U51200.J2 ; v4(158.91,167.47) 158.95,167.43 U50600.H1 v4(159.66,167.47) ; U50600.T1 v4(158.91,173.47) ; v4(169.45,162.98) 169.4,162.98 U50600.C14 ; U50500.B5 v4(182.41,173.47) U50500.C4 ; U51200.F11 v4(184.55,96.09) ; U50900.C14 v4(212.13,110.06) ; U50700.U10 201.75,145.13 v4(201.75,144.68) ; v4(174.9,162.97) 175.27,163.35 U50500.T14 ; v4(185.5,167.35) 185.29,167.35 U50500.L1 v4(184.66,167.47) 184.28,167.1 U50500.L2 ; U51000.V1 v4(213.63,125.37) ; v4(175.66,167.47) U50500.K13 ; v4(175.66,167.47) U50500.L14 175.27,167.1 v4(174.9,166.72) ; U50900.H1 v4(208.38,99.56) ; U51100.C1 v4(167.01,87.84) ; v4(207.98,138.91) U50700.H2 ; U50600.C1 v4(158.91,162.97) ; v4(168.66,168.97) U50600.L13 ; v4(168.66,168.97) U50600.K13 v4(168.66,168.22) U50600.J13 ; v4(207.98,163.21) U50800.K2 ; v4(207.98,163.21) U50800.L2 ; U50800.C1 v4(201.98,163.96) ; v4(209.13,122.37) U51000.N4 v4(209.88,122.37) U51000.P5 210.26,121.47 210.31,121.42 v4(210.31,121.39) ; v4(177.89,163.71) 177.53,163.35 U50500.T11 ; U51200.E5 v4(189.05,96.09) U51200.F4 v4(189.8,95.34) ; v4(203.45,153.41) 203.45,153.43 U50800.E14 ; U50900.P14 203.13,110.07 v4(203.13,110.09) ; v4(212.13,99.56) U50900.C1 ; U51000.T4 v4(212.13,122.37) U51000.U5 v4(212.88,121.62) ; U50600.V1 v4(158.91,174.97) ; U50800.A1 v4(200.48,163.96) ; v4(206.42,138.05) 206.11,138.37 U50700.L1 ; U51000.F11 v4(203.89,117.86) U51000.E10 ; U50500.K13 176.04,167.85 ; v4(203.12,125.38) 203.12,125.37 203.12,125.37 203.12,125.37 203.13,125.37 U51000.E1 ; v4(182.41,163.72) U50500.T4 ; v4(206.13,124.62) U51000.J2 ; v4(206.13,124.62) U51000.H2 ; v4(167.01,99.09) 167.38,99.46 U51100.V1 ; v4(158.91,171.97) U50600.P1 ; U50900.A1 v4(213.63,99.56) ; U51000.E14 203.14,114.88 v4(203.14,114.83) ; U51200.H13 v4(182.3,94.59) U51200.H14 ; v4(169.41,175.13) 169.03,174.74 U50600.V14 ; U50500.E10 v4(177.89,171.2) 177.53,170.85 U50500.F11 ; U50900.V14 200.51,109.7 v4(200.1,110.1) ; U51000.V14 213.4,115.25 v4(213.79,114.86) ; U50800.P1 v4(210.98,163.96) ; v4(201.64,114.83) 201.64,114.88 U51000.C14 ; U51100.E1 v4(167.01,89.34) ; v4(170.01,99.09) U51100.U5 v4(170.76,99.09) ; U50600.A14 168.88,161.7 v4(168.88,161.37) ; v4(207.98,147.9) 208.03,147.9 208.36,147.57 208.36,147.53 U50700.H13 208.38,147.53 v4(208.76,147.91) 208.38,148.28 U50700.H14 208.36,148.28 v4(208.75,148.68) ; 161.53,163.35 v4(161.91,162.97) U50600.B5 ; 161.53,163.35 v4(161.16,163.72) ; 161.53,163.35 U50600.C4 ; v4(174.88,164.47) 174.9,164.47 U50500.P14 ; U51000.B5 v4(201.63,122.37) U51000.C4 v4(202.38,123.12) ; v4(166.41,173.47) U50600.T11 ; v4(166.41,173.47) 166.38,173.47 ; v4(166.41,173.47) U50600.U10 166.01,173.83 v4(164.97,173.83) ; v4(159.66,167.47) U50600.J2 ; v4(159.66,167.47) U50600.H2 ; v4(203.48,157.19) 203.84,156.84 U50800.E10 v4(204.23,156.46) U50800.F11 ; v1(214.3,153.49) 213.96,153.49 U50800.V14 ; v4(177.52,99.09) 177.14,99.46 U51100.V14 ; v4(185.41,169.72) U50500.H1 v4(184.66,168.97) 184.28,169.35 U50500.H2 ; U51000.P14 v4(210.67,114.84) ; v4(212.16,114.88) 211.79,115.25 U51000.T14 ; v4(212.48,138.16) 212.28,138.36 U50700.C1 ; U50700.L2 206.32,139.07 206.32,139.07 v4(206.48,138.91) 206.86,139.28 U50700.K2 v4(207.23,138.91) U50700.J2 ; v4(201.63,110.07) 202.01,109.7 U50900.T14 ; U50800.T14 212.14,153.84 v4(212.51,153.47) ; U50700.A14 v4(213.98,148.66) ; v4(185.41,171.97) U50500.E1 ; U51100.F11 v4(174.51,90.09) U51100.E10 v4(173.76,89.34) ; U51000.H14 v4(205.39,115.61) 205.39,115.63 U51000.H13 U51000.J13 v4(206.88,115.62) U51000.K13 v4(207.63,115.62) ; v4(201.63,99.56) U50900.T1 ; v4(212.13,117.87) 212.13,117.9 ; v4(212.13,117.87) U51000.T11 ; v4(178.85,162.75) 178.44,162.75 U50500.U10 ; v4(185.3,99.09) U51200.B10 ; U50500.V14 175.27,161.85 v4(174.87,161.44) ; v4(170.01,97.59) U51100.T4 ; U50600.T4 161.53,173.1 v4(161.91,173.47) U50600.U5 v4(162.66,174.22) ; U51100.E14 v4(177.51,89.34) ; v4(210.66,106.29) U50900.E10 v4(209.88,107.06) U50900.F11 ; U50600.H13 v4(168.66,166.72) U50600.H14 ; v4(159.66,168.97) U50600.L1 159.25,169.35 158.85,169.75 v4(158.77,169.75) ; v4(159.66,168.97) U50600.K2 ; v4(159.66,168.97) U50600.L2 ; U50500.T1 v4(185.41,162.97) ; v4(185.41,174.97) U50500.A1 ; v4(167.06,86.33) 167.06,86.39 U51100.A1 ; U50500.C1 v4(185.41,173.47) ; U51000.L13 v4(207.63,115.62) ; v4(207.63,115.62) U51000.L14 v4(208.38,114.87) ; v4(202.73,145.69) 202.39,146.03 U50700.T11 ; v4(192.05,96.09) U51200.E1 ; U50800.T1 v4(212.48,163.96) ; U51000.C1 v4(201.63,125.37) ; U50500.C14 v4(174.91,173.47) ; U50700.F4 v4(210.21,141.14) 210.22,141.14 210.61,141.53 U50700.E5 210.29,141.85 v4(210.29,142.29) ; v4(165.66,162.22) U50600.B10 166.41,162.97 v4(166.41,163.02) 166.41,163.03 166.73,163.35 U50600.C11 ; v4(204.18,144.7) 203.86,145.02 U50700.P10 203.86,145.32 v4(204.23,145.7) 204.57,146.03 U50700.N11 ; U50700.V1 v4(200.5,138.17) ; U50500.F4 v4(182.43,171.2) U50500.E5 181.69,171.94 v4(181.26,171.94) ; v4(210.96,148.71) 210.96,148.64 U50700.E14 ; U51100.A14 v4(177.51,86.34) ; U51100.C14 v4(177.51,87.84) ; v4(202.38,107.81) U50900.T11 ; v4(173.6,98.58) 174,98.58 U51100.U10 ; U50800.V1 v1(213.98,163.96) ; U51000.T1 v4(212.13,125.37) ; v4(192.08,99.07) 191.69,99.46 U51200.A1 ; v4(174.91,171.97) U50500.E14 ; v4(202.38,102.56) U50900.T4 ; v4(201.24,153.42) 201.24,153.45 U50800.A14 200.53,154.17 200.5,154.17 v4(200.48,154.19) ; v4(201.11,157.42) 201.11,157.38 201.61,156.89 U50800.B10 201.61,156.82 201.96,156.46 v4(202.02,156.46) 202.36,156.12 U50800.C11 ; U50700.C14 v4(212.48,148.66) ; U51100.N4 v4(170.01,96.09) U51100.P5 170.88,95.97 v4(170.88,95.84) ; v4(175.26,97.59) U51100.T11 ; v4(192.05,89.34) U51200.P1 ; v4(210.63,99.56) U50900.E1
  BOTTOM w0.305: v4(206.48,147.91) U50700.L13 ; v4(206.48,147.91) 206.86,147.53 U50700.K13 v4(207.23,147.91) U50700.J13 v4(207.98,147.9) ; v4(206.48,147.91) U50700.L14 206.11,148.29 v4(205.73,148.67) ; U51200.C11 v4(184.55,98.35) U51200.B10 ; U50700.C11 212.11,146.03 v4(212.48,145.66) ; U50700.L1 v4(206.48,138.91) ; v4(204.24,141.94) 203.86,141.56 U50700.P5 203.86,141.53 v4(204.23,141.16) U50700.N4 ; U50700.P1 203.86,138.53 v4(203.48,138.16) ; U50700.J2 v4(207.98,138.91) 208.36,138.53 U50700.H1 208.36,138.53 208.55,138.34 ; v4(167.01,87.84) 166.77,87.6 C51134.1 ; v4(184.55,96.09) U51200.E10 v4(185.32,96.81) ; U51200.C14 v4(181.51,98.33) ; U51200.T14 v4(181.56,87.81) ; U51100.C11 v4(174.51,87.84) U51100.B10 v4(173.62,86.89) ; v4(201.23,141.16) U50700.U5 v4(201.23,141.91) ; U51200.E14 v4(181.51,96.83) ; v4(167.06,86.33) 167.03,86.36 ; v4(181.55,86.19) U51200.V14
  BOTTOM w0.381: v4(201.98,148.67) 202.36,148.29 U50700.T14 ; U50700.V14 200.86,148.29 v4(200.45,148.7) ; v4(203.48,148.69) 203.86,148.31 U50700.P14 ; 187.42,83.2 C7508.2 ; 230.68,83.04 R67200.1 ; 177.5,177.23 C7506.2 ; 210.6,132.63 C7507.2
  vias: v1(157.03,165.08) v1(157.5,177.6) v1(157.9,175.86) v1(158.42,177.65) v1(159.1,176.33) v1(161.13,176.51) v1(163.57,177.65) v1(165.76,177.65) v1(170.18,177.65) v1(170.74,174.21) v1(173.25,177.65) v1(173.25,175.54) v1(175.13,177.65) v1(177.19,176.36) v1(180.67,177.65) v1(181.51,177.65) v1(185.98,177.65) v1(187.08,171.06) v1(196.64,89.82) v1(196.67,92.82) v1(206.96,129.37) v1(207.95,89.69) v1(207.95,89.11) v1(207.95,88.52) v1(207.95,87.94) v1(208.33,129.46) v1(208.53,89.69) v1(208.53,89.11) v1(208.53,88.52) v1(208.53,87.94) v1(208.58,133.38) v1(209.11,89.69) v1(209.11,89.11) v1(209.11,88.52) v1(209.11,87.94) v1(209.7,89.69) v1(209.7,89.11) v1(209.7,88.52) v1(209.7,87.94) v1(209.98,133.38) v1(210.03,129.48) v1(210.28,89.69) v1(210.28,89.11) v1(210.28,88.52) v1(210.28,87.94) v1(210.87,166.5) v1(211.81,129.48) v1(212.39,166.48) v1(213.53,129.48) v1(213.92,166.5) v1(213.94,111.51) v1(214.39,150.12) v1(214.6,134.06) v1(214.68,149.36) v1(215.03,168.13) v1(215.29,129.46) v1(216.63,103.46) v4(162.98,141.86) v4(164.48,141.85) v4(165.16,141.82) v4(166.54,141.79) v4(166.95,84.93) v4(167.26,141.84) v4(167.29,120.06) v4(167.28,119.51) v4(168.13,120.08) v4(168.58,141.81) v4(169.29,120.09) v4(169.36,141.88) v4(170.66,141.74) v4(170.84,83.82) v4(171.46,141.88) v4(171.45,118.7) v4(172.74,141.37) v4(172.78,120.09) v4(172.8,119.48) v4(172.89,83.82) v4(173.54,142.47) v4(173.55,141.15) v4(173.62,119.44) v4(174.87,141.18) v4(175,141.83) v4(175.63,119.35) v4(175.71,120.09) v4(176.39,120.1) v4(176.35,119.45) v4(177.31,83.82) v4(177.74,119.42) v4(178.57,119.55) v4(178.68,140.59) v4(179.42,119.54) v4(179.91,139.81) v4(180.12,121.19) v4(180.23,123.07) v4(180.2,119.93) v4(180.36,137.91) v4(180.52,139.8) v4(180.54,134.15) v4(180.51,127.26) v4(180.54,125.73) v4(180.48,125.02) v4(180.62,139.04) v4(180.57,135.52) v4(180.62,134.83) v4(180.6,131.31) v4(180.6,130.58) v4(180.57,129.97) v4(180.62,128.53) v4(180.55,126.53) v4(180.57,124.29) v4(180.55,122.14) v4(180.73,119.62) v4(180.92,141.19) v4(181.08,120.03) v4(181.27,128.53) v4(183.21,84.94) v4(184.66,168.22) v4(184.96,83.82) v4(188.21,83.82) v4(190.67,85.12) v4(192.6,83.82) v5(209.6,87.1) v5(209.6,86.36) v5(210.33,87.1) v5(210.33,86.36) v5(211.07,88.62) v5(211.07,87.89) v5(211.09,87.1) v5(211.09,86.36) v5(211.12,85.6) v5(211.81,88.62) v5(211.81,87.89) v5(211.86,87.1) v5(211.86,86.36) v5(211.86,85.6) v5(212.62,87.86) v5(212.62,87.1) v5(212.62,86.36) v5(212.59,85.6) v5(213.33,85.6) v5(213.36,87.86) v5(213.36,87.1) v5(213.35,86.36) v5(214.12,87.86) v5(214.12,87.1) v5(214.11,86.36) v5(214.09,85.6) v5(214.83,85.6) v5(214.86,87.86) v5(214.86,87.1) v5(214.85,86.36) v5(215.62,87.86) v5(215.62,87.1) v5(215.61,86.36) v5(215.59,85.6) v5(216.33,85.6) v5(216.35,87.86) v5(216.35,87.1) v5(216.35,86.36)
