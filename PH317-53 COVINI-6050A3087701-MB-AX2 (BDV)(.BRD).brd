# Allegro board PH317-53 COVINI-6050A3087701-MB-AX2 (BDV)(.BRD).brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
USB2_M2_BT_DN_L: length 9.4
  BOTTOM w0.107: L1300.3 269.06,26.26 269.06,25.58 268.96,25.48 268.96,24.81 v2(269.46,24.31) 269.03,23.88 269.03,23.77 269.33,23.47 270.99,23.47 272.74,21.72 272.74,21.24 272.95,21.03 CN1300.5
USB2_M2_BT_DP_L: length 9.5
  BOTTOM w0.107: L1300.4 268.8,26.26 268.8,26.02 268.85,25.97 268.85,25.67 268.75,25.57 268.75,24.87 v2(268.19,24.31) 269.24,23.26 270.9,23.26 272.53,21.63 272.53,21.21 272.45,21.13 272.45,20.08 CN1300.3
USB2_OC0#: length 3.2
  TOP w0.102: C4705.1 250.75,46.39 v2(250.75,47.15) 250.75,47.51 v1(251.22,47.98) 251.22,48.55 R4783.1
  BOTTOM w0.089: U4710.AH36 251.22,47.97 v1(251.22,47.98)
USB2_OC1#: length 9.9
  TOP w0.102: v1(251.33,38.26) 251.56,38.48 251.56,44.94 v1(251.71,45.09)
  BOTTOM w0.102: v1(251.71,45.09) 251.71,45.6 U4710.AL40 ; R4774.1 251.53,36.75 251.53,38.05 v1(251.33,38.26)
USB2_OC2#: length 12
  BOTTOM w0.089: 247.37,39.09 247.37,39.18 249.42,41.23 249.42,41.74 249.81,42.12 249.81,42.37 249.8,42.37 249.8,42.63 249.81,42.63 249.81,43.16 250.62,43.97 251.26,43.97 U4710.AJ44
  BOTTOM w0.102: C4707.1 v2(247.93,35.44) 248.23,35.74 248.23,37.34 R4767.1 247.37,38.19 247.37,39.09
USB2_OC3#: length 9.2
  TOP w0.102: v1(252.02,38.26) 251.79,38.48 251.79,44.07 v1(252.17,44.45)
  BOTTOM w0.102: v1(252.02,38.26) 251.94,38.18 251.94,36.88 R4760.1 ; U4710.AL41 252.35,44.64 v1(252.17,44.45)
USB2_REAR_1N: length 105.4
  L3 w0.084: v3(304.17,13.35) 303.95,13.56 303.75,13.56 303.49,13.81 303.49,21.02 299.71,24.81 298.91,24.81 298.74,24.81 295.26,28.28 295.26,29.15 293.9,30.51 293.9,30.69 293.9,34.54 278.16,50.28 278.16,57.96 278.16,58.9 269.44,67.63 262.85,67.63 260.68,69.8 252.87,69.8 251.15,68.08 249.73,68.08 249.48,67.83 249.48,67.19 248.94,66.64 244.4,66.64 243.63,67.42 241.75,67.42 241.46,67.13 241.46,66.95 241.65,66.76 241.65,66.43 241.24,66.03 v1(241.24,66.01)
  BOTTOM w0.089: U4710.J3 241.41,64.46 240.96,64.91 240.96,65.49 241.24,65.78 v1(241.24,66.01)
  BOTTOM w0.107: L2500.1 304.83,13.46 304.74,13.54 304.38,13.54 304.19,13.35 v3(304.17,13.35)
USB2_REAR_1P: length 105.5
  L3 w0.084: v1(304.16,14.01) 304.16,13.9 304.03,13.77 303.83,13.77 303.7,13.9 303.7,21.11 299.79,25.02 298.82,25.02 295.47,28.37 295.47,29.24 294.11,30.6 294.11,34.63 278.37,50.37 278.37,57.87 278.37,58.99 269.52,67.84 262.94,67.84 260.89,69.89 260.89,69.89 260.77,70.01 252.79,70.01 251.06,68.29 249.64,68.29 249.27,67.92 249.27,67.27 248.85,66.86 244.49,66.86 243.72,67.63 241.67,67.63 241.25,67.21 241.25,66.7 v1(241.25,66.6)
  BOTTOM w0.089: v1(241.25,66.6) 241.25,66.58 241.66,66.17 241.66,65.88 241.41,65.63 241.34,65.63 241.13,65.42 241.13,64.99 241.73,64.39 U4710.J2
  BOTTOM w0.107: L2500.2 304.83,14.01 304.57,13.75 304.42,13.75 v1(304.16,14.01)
USB2_REAR_3N: length 80.9
  TOP w0.107: U2501.2 283.08,31.93 283.01,31.86 280.05,31.86 278.9,33.01 278.9,36.24 283.69,41.02 v1(284.38,41.02)
  L3 w0.084: v1(284.38,41.02) 276.81,48.59 276.81,58.34 269.72,65.43 261.18,65.43 258.42,68.2 256.79,68.2 256,67.42 253.18,67.42 249.69,63.93 249.57,63.81 242.47,63.81 242.29,63.81 241.72,64.38 241.72,65.14 v1(241.58,65.27)
  BOTTOM w0.089: v1(241.58,65.27) 241.73,65.12 241.73,64.73 241.98,64.48 241.98,64.13 241.85,64 241.85,63.65 U4710.K4
USB2_REAR_3P: length 81
  TOP w0.107: U2501.3 283.08,31.43 282.86,31.65 279.97,31.65 278.69,32.93 278.69,36.32 283.6,41.23 284.01,41.23 284.21,41.43 284.51,41.43 v1(284.76,41.67)
  L3 w0.084: v1(284.76,41.67) 284.76,41.53 284.65,41.43 284.27,41.43 277.02,48.68 277.02,58.43 269.81,65.64 261.27,65.64 258.5,68.41 256.7,68.41 255.92,67.63 253.09,67.63 249.48,64.02 242.38,64.02 241.93,64.47 241.93,64.7 v3(242.12,64.89)
  BOTTOM w0.089: U4710.K3 242.1,63.79 242.23,63.79 242.31,63.88 242.31,64.04 242.16,64.19 242.16,64.55 242.12,64.59 v3(242.12,64.89)
USB2_VBUSSENSE: length 6.5
  BOTTOM w0.102: U4710.F3 239.54,64.65 239.7,64.8 239.7,66.86 238.73,67.82 237.68,67.82 v2(237.18,68.32) 237.41,68.54 R4758.1
USB3_C_TX1N: length 1.3
  BOTTOM w0.107: R2515.1 306.28,21.19 306.28,21.43 C2502.1
USB3_C_TX1P: length 1.4
  BOTTOM w0.107: C2503.1 306.49,21.39 306.49,21.24 R2514.1
USB3_C_TX2N: length 1
  TOP w0.107: R2502.1 302.99,23.68 C2504.1
USB3_C_TX2P: length 1
  TOP w0.107: C2501.1 301.85,23.68 R2503.1
USB3_C_TX3N: length 1.3
  TOP w0.107: R2531.1 298.49,29.01 298.34,29.01 C2518.1
USB3_C_TX3P: length 1.2
  TOP w0.107: R2532.1 298.58,28.73 298.24,28.73 C2519.1
USB3_L_RX1N: length 12.9
  TOP w0.107: R2512.2 305.1,19.82 305.1,19.22 305.09,19.21 D7505.7 D7505.4 305.09,17.27 305.2,17.16 305.2,16.85 305.47,16.58 306.77,16.58 307.18,17 310.69,17 311.1,16.58 313.16,16.58 CN2500.B10
USB3_L_RX1P: length 12.8
  TOP w0.107: CN2500.B11 313.45,17.01 313.23,16.79 311.19,16.79 310.78,17.2 307.1,17.2 306.69,16.79 305.56,16.79 305.41,16.94 305.41,17.09 305.59,17.27 D7505.5 D7505.6 305.59,19.21 305.31,19.49 305.31,20.26 R2513.2
USB3_L_RX2N: length 16.7
  BOTTOM w0.107: R2504.2 303.95,20.12 303.95,19.59 304.57,18.97 304.57,18.4 304.8,18.17 D7504.2 D7504.9 304.8,16.23 303.63,15.06 303.63,13.16 304.23,12.56 310.71,12.56 311.01,12.85 CN2500.A10
USB3_L_RX2P: length 16.7
  BOTTOM w0.107: CN2500.A11 304.14,12.35 303.42,13.07 303.42,15.14 304.3,16.03 D7504.10 D7504.1 304.3,18.17 304.36,18.22 304.36,18.88 303.74,19.5 303.74,20.12 R2505.2
USB3_L_RX3N: length 17.4
  TOP w0.107: CN2501.5 307.02,35.96 306.58,35.52 306.15,35.52 305.71,35.08 303.22,35.08 302.74,34.6 302.74,34.19 302.31,33.76 301.05,33.76 D7500.1 300.56,33.86 300.45,33.96 295.23,33.96 294.7,33.44 294.14,33.44 v2(293.65,33.93) 293.15,33.42 292.88,33.42 R2529.2
USB3_L_RX3P: length 17.4
  TOP w0.107: R2530.2 292.88,33.21 293.1,33.21 v2(293.65,32.66) 294.23,33.23 294.79,33.23 295.32,33.76 300.37,33.76 300.57,33.55 302.72,33.55 302.81,33.46 D7500.10 302.95,34.52 303.31,34.87 305.8,34.87 306.23,35.31 306.73,35.31 307.02,35.02 CN2501.6
USB3_L_TX1N: length 10.2
  BOTTOM w0.107: CN2500.A3 309.92,16.35 309.63,16.64 307.73,16.64 306.79,15.7 306.18,15.7 305.93,15.94 305.93,16.21 305.81,16.34 D7504.7 D7504.4 305.81,18.5 306.29,18.99 306.29,19.09 R2515.2
USB3_L_TX1P: length 10.2
  BOTTOM w0.107: R2514.2 306.91,19.55 306.5,19.13 306.5,18.9 306.01,18.42 306.01,18.29 306.31,18 D7504.5 D7504.6 306.31,16.32 306.14,16.16 306.14,16.03 306.26,15.91 306.71,15.91 307.65,16.85 309.72,16.85 310.01,16.56 310.81,16.56 311.1,16.85 CN2500.A2
USB3_L_TX2N: length 17.8
  TOP w0.107: R2502.2 302.51,21.17 302.51,20.69 302.78,20.43 303.27,20.43 303.95,19.75 303.95,19.35 304.09,19.21 D7505.9 D7505.2 304.09,17.27 303.96,17.14 303.91,17.14 303.8,17.04 303.8,16.61 304.83,15.58 306.62,15.58 309.67,12.53 313.08,12.53 CN2500.B3
USB3_L_TX2P: length 17.9
  TOP w0.107: CN2500.B2 313.23,12.32 309.58,12.32 306.53,15.37 304.75,15.37 303.59,16.52 D7505.1 D7505.10 303.59,19.21 303.74,19.35 303.74,19.66 303.19,20.22 302.69,20.22 302.3,20.61 302.3,21.2 R2503.2
USB3_L_TX3N: length 9
  TOP w0.107: R2531.2 300.54,29.12 301.08,29.12 301.24,29.27 301.24,30.08 300.95,30.37 D7500.5 301.37,30.66 301.46,30.56 306.91,30.56 307.02,30.67 CN2501.8
USB3_L_TX3P: length 9
  TOP w0.107: R2532.2 300.72,28.91 301.16,28.91 301.44,29.19 301.44,29.9 301.8,30.26 D7500.6 303.05,30.36 305.71,30.36 307.02,29.05 CN2501.9
USB3_RX1N: length 121.3
  TOP w0.107: v3(305.89,26.62) 305.02,25.75 305.02,24.93 C2500.2
  L3 w0.084: v3(305.89,26.62) 305.61,26.62 305.07,27.16 303.61,27.16 302.74,28.04 302.74,30.65 298.44,34.95 298.44,36.76 291.39,43.82 291.39,46.96 288.87,49.48 288.87,58.58 284.54,62.91 283.39,62.91 280.22,66.08 280.22,67.74 280.01,67.95 278.53,67.95 272.51,73.97 251.78,73.97 251.22,73.97 250,73.97 249.54,74.43 243.19,74.43 242.89,74.13 242.89,72.71 242.18,72 238.44,72 237.61,71.17 237.61,60.92 236.81,60.13 235.89,60.13 235.45,59.69 235.45,59.51 v1(235.25,59.31)
  BOTTOM w0.089: v1(235.25,59.31) 235.89,59.95 238.33,59.95 238.58,60.2 238.86,60.2 239.21,59.85 U4710.D11
USB3_RX1P: length 121.3
  TOP w0.107: C2511.2 305.54,24.68 305.23,25 305.23,25.67 305.68,26.11 305.98,26.11 306.08,26.01 v1(306.08,25.82)
  L3 w0.084: v1(306.08,25.82) 306.08,26.14 305.99,26.23 305.72,26.23 305.54,26.41 305.52,26.41 304.98,26.95 303.53,26.95 303.4,27.08 303.4,27.08 302.53,27.95 302.53,30.57 298.23,34.86 298.23,36.68 291.17,43.73 291.17,46.87 288.66,49.39 288.66,58.49 284.45,62.7 283.3,62.7 280.01,65.99 280.01,67.65 279.92,67.74 278.44,67.74 272.42,73.76 251.78,73.76 251.22,73.76 249.92,73.76 249.45,74.22 243.28,74.22 243.1,74.04 243.1,72.62 242.27,71.79 238.53,71.79 237.82,71.08 237.82,60.84 236.89,59.91 235.97,59.91 235.66,59.6 235.66,59.21 235.79,59.08 v3(235.9,59.08)
  BOTTOM w0.089: v3(235.9,59.08) 235.79,59.08 235.64,59.23 235.64,59.45 235.96,59.77 238.4,59.77 238.58,59.94 U4710.C11
USB3_RX2N: length 119.5
  L3 w0.084: v3(235.91,60.89) 235.96,60.94 235.96,61.67 237,62.72 237,64.47 235.68,65.8 235.68,70.12 238.16,72.6 241.93,72.6 242.28,72.94 242.28,74.46 242.28,74.71 243.41,75.84 249.31,75.84 250.56,74.59 272.84,74.59 276.77,70.65 278.93,70.65 282.46,67.11 283.16,67.11 285.66,64.6 286.02,64.6 290.6,60.02 290.6,57.24 290.6,57.15 290.6,50.54 291.39,49.76 291.39,48.42 292.25,47.55 292.25,43.81 299.04,37.01 299.04,35.24 304.65,29.63 304.65,28.12 v1(304.81,27.97)
  BOTTOM w0.089: v3(235.91,60.89) 236.32,60.89 236.38,60.83 236.39,60.83 236.56,60.66 237.53,60.66 237.84,60.97 U4710.B9
  BOTTOM w0.107: v1(304.81,27.97) 304.62,27.78 304.62,27.35 303.94,26.66 303.94,24.88 C2510.2
USB3_RX2P: length 119.4
  L3 w0.084: v3(304.15,27.97) 304.24,27.97 304.44,28.17 304.44,29.54 298.83,35.15 298.83,36.92 292.04,43.72 292.04,47.46 291.17,48.33 291.17,49.67 290.39,50.46 290.39,57.15 290.39,57.24 290.39,59.94 285.93,64.39 285.58,64.39 283.07,66.9 282.38,66.9 278.84,70.44 276.69,70.44 272.75,74.37 250.47,74.37 249.22,75.63 243.5,75.63 242.49,74.62 242.49,72.86 242.02,72.39 238.25,72.39 235.89,70.03 235.89,65.88 237.21,64.56 237.21,62.8 237.22,62.63 236.17,61.59 236.17,61.24 236.3,61.11 236.45,61.11 236.54,61.2 v1(236.54,61.22)
  BOTTOM w0.089: v1(236.54,61.22) 236.54,60.93 236.63,60.84 237.46,60.84 237.84,61.22 238.32,61.22 238.57,60.97 U4710.C9
  BOTTOM w0.107: v3(304.15,27.97) 304.26,27.97 304.42,27.82 304.42,27.44 303.73,26.75 303.73,24.72 303.54,24.53 C2509.2
USB3_RX3N: length 112.1
  TOP w0.107: R2529.1 290.84,33.51 290.47,33.51 290.34,33.63 290.34,37.24 294.1,41 294.1,46.32 v1(294.33,46.54)
  L3 w0.084: v1(294.33,46.54) 294.13,46.74 294.13,48.67 291.22,51.58 291.22,60.27 284.98,66.5 284.98,67.21 283.01,69.18 281.3,69.18 278.59,71.89 276.38,71.89 273.06,75.21 250.99,75.21 249.77,76.44 243.17,76.44 241.18,74.45 239.17,74.45 235.08,70.36 235.08,65.55 236.4,64.22 236.4,63.03 235.26,61.89 234.81,61.89 234.36,61.44 234.36,61.04 v1(234.21,60.89)
  BOTTOM w0.089: 235.18,60.2 235.26,60.2 235.28,60.21 237.7,60.21 237.8,60.31 U4710.B10
  BOTTOM w0.107: 235.18,60.2 234.8,60.2 234.21,60.79 v1(234.21,60.89)
USB3_RX3P: length 112
  TOP w0.107: R2530.1 290.66,33.3 290.38,33.3 290.14,33.55 290.14,37.33 293.9,41.09 293.9,46.32 v3(293.67,46.54)
  L3 w0.084: v1(234.79,60.86) 234.57,61.08 234.57,61.35 234.9,61.67 235.35,61.67 236.62,62.94 236.62,64.31 235.29,65.64 235.29,70.28 239.25,74.24 241.27,74.24 243.25,76.23 249.68,76.23 250.91,75 272.97,75 276.3,71.67 278.5,71.67 281.21,68.96 282.93,68.96 284.77,67.12 284.77,66.41 291,60.18 291,51.5 293.92,48.58 293.92,46.79 v3(293.67,46.54)
  BOTTOM w0.089: U4710.C10 238.71,60.56 238.13,60.56 238.06,60.49 237.72,60.49 237.63,60.39 235.28,60.39 235.26,60.41 235.18,60.41
  BOTTOM w0.107: 235.18,60.41 234.88,60.41 234.74,60.55 234.74,60.81 v1(234.79,60.86)
USB3_RX4_C_DN: length 4.3
  BOTTOM w0.107: C2413.2 281.76,113.26 282.01,113.01 282.31,113.01 282.79,113.49 284.43,113.49 284.65,113.72 284.65,113.87 284.36,114.16 U2401.23
USB3_RX4_C_DP: length 4.4
  BOTTOM w0.107: U2401.22 284.86,113.63 284.51,113.28 282.87,113.28 282.39,112.8 281.85,112.8 C2412.2
USB3_RX4_L_DN: length 24.5
  BOTTOM w0.107: L2402.3 284,124.77 284.3,125.06 284.3,125.97 285.46,127.14 287.04,127.14 288.05,128.14 288.63,128.14 288.7,128.07 289.14,128.07 D2401.10 D2401.1 290.51,128.18 290.62,128.08 291.16,128.08 291.46,128.38 291.46,129.23 291.93,129.69 299.81,129.69 300.34,129.17 302.22,129.17 303.47,130.42 CN2400.5
USB3_RX4_L_DP: length 24.4
  BOTTOM w0.107: L2402.4 284.8,124.77 284.5,125.06 284.5,125.89 285.54,126.93 287.13,126.93 288.14,127.93 288.54,127.93 288.67,127.8 289.13,127.8 D2401.9 D2401.2 290.43,127.68 290.62,127.87 291.25,127.87 291.67,128.29 291.67,129.14 292.01,129.49 299.72,129.49 300.25,128.96 302.31,128.96 303.11,129.76 303.36,129.76 303.47,129.65 CN2400.6
USB3_RX4N: length 217.5
  L10 w0.084: v3(241.58,57.56) 241.4,57.38 241.4,57.31 239.82,55.72 237.73,55.72 235.84,53.84 234.23,53.84 232.36,51.97 227.35,51.97 224.66,49.28 221.37,49.28 220.78,48.69 156.81,48.69 152.98,52.52 136.71,52.52 136.4,52.22 76.95,52.22 74.84,50.11 60.36,50.11 59.69,50.78 34.98,50.78 34.74,51.02 34.74,51.52 v1(34.52,51.74)
  BOTTOM w0.107: U4710.K16 v3(241.58,57.56) ; CN603.35 34.28,52.85 34.37,52.94 34.73,52.94 34.9,52.77 34.9,52.13 v1(34.52,51.74)
USB3_RX4P: length 217.4
  L10 w0.084: v1(35.16,51.6) 34.95,51.4 34.95,51.1 35.07,50.99 59.78,50.99 60.45,50.32 74.75,50.32 76.86,52.43 136.32,52.43 136.62,52.73 153.06,52.73 156.9,48.9 220.69,48.9 221.28,49.49 224.57,49.49 227.27,52.19 232.27,52.19 234.14,54.05 235.76,54.05 237.64,55.93 239.73,55.93 241.18,57.39 241.18,57.52 241.02,57.69 v1(240.92,57.69)
  BOTTOM w0.107: CN603.36 34.28,53.35 34.49,53.15 34.82,53.15 35.11,52.86 35.11,52.04 34.97,51.91 34.97,51.74 35.11,51.6 v1(35.16,51.6) ; v1(240.92,57.69) 241.31,58.08 U4710.J15
USB3_RX5_C_DN: length 2.9
  TOP w0.107: C2423.2 289.55,122.64 290,122.64 290.69,121.95 291.07,121.95 291.21,121.8 U2403.23
USB3_RX5_C_DP: length 2.9
  TOP w0.107: U2403.22 291.21,122.3 291.07,122.16 290.77,122.16 290.08,122.85 289.55,122.85 C2422.2
USB3_RX5_L_DN: length 23.6
  TOP w0.107: L2405.3 302.25,134.1 301.96,134.39 D2403.10 D2403.1 301.96,137.05 301.55,137.46 301.55,137.89 301.66,138 301.95,138 v1(302.09,137.85)
  L3 w0.084: CN2401.5 303.47,149.05 303.39,148.97 302.99,148.97 302.38,148.36 301.3,148.36 299.17,146.24 299.17,137.41 299.52,137.06 300.5,137.06 301.52,138.08 301.87,138.08 v1(302.09,137.85)
USB3_RX5_L_DP: length 23.6
  TOP w0.107: v1(302.09,138.51) 301.78,138.2 301.57,138.2 301.35,137.98 301.35,137.37 301.75,136.96 301.75,136.59 301.66,136.5 301.55,136.5 301.46,136.41 D2403.2 D2403.9 301.46,134.78 301.6,134.64 301.6,134.59 301.68,134.52 301.68,134.37 301.45,134.15 L2405.4
  L3 w0.084: v1(302.09,138.51) 301.87,138.29 301.43,138.29 300.42,137.27 299.61,137.27 299.38,137.5 299.38,146.15 301.39,148.15 302.47,148.15 303.08,148.76 303.39,148.76 303.47,148.67 CN2401.6
USB3_RX5N: length 225.4
  L10 w0.084: v1(32.33,49.77) 32.6,50.04 59.59,50.04 60.12,49.51 75.59,49.51 77.7,51.62 103.28,51.62 110.58,44.32 136.79,44.32 140.53,48.06 221,48.06 221.37,48.43 232.21,48.43 233.53,49.75 233.53,51.96 234.81,53.24 236.46,53.24 238.22,54.99 240.12,54.99 242.44,57.31 242.44,58.86 241.93,59.36 241.93,59.39 v3(241.93,59.4)
  BOTTOM w0.107: U4710.J13 241.92,59.4 v3(241.93,59.4) ; v1(32.33,49.77) 32.52,49.96 32.96,49.96 33.07,49.85 CN603.29
USB3_RX5P: length 225.3
  L10 w0.084: v3(32.33,50.43) 32.51,50.25 59.67,50.25 60.2,49.72 75.5,49.72 77.61,51.83 103.37,51.83 110.66,44.53 136.7,44.53 140.44,48.27 220.91,48.27 221.28,48.64 232.13,48.64 233.32,49.84 233.32,52.05 234.73,53.45 236.38,53.45 238.13,55.21 240.04,55.21 242.23,57.4 242.23,58.77 242.01,58.98 241.68,58.98 241.55,58.86 v1(241.55,58.66)
  BOTTOM w0.107: v3(32.33,50.43) 32.59,50.17 32.89,50.17 33.07,50.35 CN603.30 ; v1(241.55,58.66) 241.89,58.66 242.1,58.87 U4710.K13
USB3_TCL_RX4_IC_DN: length 4.1
  BOTTOM w0.107: U2401.8 284.36,119.25 284.3,119.32 284.3,121.58 284,121.88 L2402.2
USB3_TCL_RX4_IC_DP: length 4.2
  BOTTOM w0.107: L2402.1 284.8,121.88 284.5,121.58 284.5,119.41 284.86,119.05 U2401.9
USB3_TCL_RX5_IC_DN: length 14.8
  TOP w0.107: L2405.2 302.25,131.92 301.96,131.63 301.96,131.41 301.77,131.22 301.4,131.22 300.86,130.68 300.86,124.26 299.51,122.91 298.12,122.91 297.02,121.8 U2403.8
USB3_TCL_RX5_IC_DP: length 14.8
  TOP w0.107: U2403.9 295.86,122.4 296.25,122.4 296.36,122.3 296.36,122.06 296.41,122.01 296.93,122.01 298.04,123.12 299.42,123.12 300.65,124.35 300.65,130.76 301.31,131.42 301.68,131.42 301.75,131.49 301.75,131.64 301.45,131.94 L2405.1
USB3_TCL_TX4_IC_DN: length 2
  BOTTOM w0.107: U2401.11 285.9,118.56 285.9,119 286.05,119.14 286.05,119.93 C2405.1
USB3_TCL_TX4_IC_DP: length 2
  BOTTOM w0.107: U2401.12 286.36,119.09 286.26,119.19 286.26,120.05 286.48,120.27 C2406.1
USB3_TCL_TX5_IC_DN: length 2.7
  TOP w0.107: C2417.1 297.59,124.21 297.33,124.21 296.56,123.45 296.24,123.45 296.09,123.3 U2403.11
USB3_TCL_TX5_IC_DP: length 2.7
  TOP w0.107: C2418.1 297.59,124.42 297.24,124.42 296.47,123.66 296.26,123.66 296.11,123.8 U2403.12
USB3_TX1N: length 109
  L3 w0.084: v1(240.79,60.76) 240.53,60.76 240.28,61.01 240.28,61.43 240.8,61.94 240.8,63.91 239.65,65.06 239.65,67.4 241.03,68.79 241.32,68.79 248.51,68.79 249.04,69.32 250.64,69.32 252.5,71.17 263.1,71.17 265.38,68.89 270.69,68.89 272.69,66.9 272.69,66.2 280.18,58.71 280.18,58.22 283.66,54.75 283.66,46.65 296.58,33.72 296.58,32.3 297.66,31.23 297.66,29.63 299.68,27.6 299.68,26.33 301.49,24.51 303.19,24.51 303.81,25.14 303.81,25.9 304.08,26.17 304.26,26.17 304.41,26.02 v3(304.41,25.88)
  BOTTOM w0.089: v1(240.79,60.76) 240.79,61.19 240.59,61.4 240.27,61.4 U4710.F9
  BOTTOM w0.107: v3(304.41,25.88) 304.41,26 304.54,26.14 304.9,26.14 305.22,25.82 305.22,24.66 306.37,23.51 306.37,22.91 306.06,22.6 C2502.2
USB3_TX1P: length 109
  L3 w0.084: v1(304.4,26.55) 304.23,26.38 304,26.38 303.6,25.98 303.6,25.23 303.1,24.73 301.58,24.73 299.89,26.41 299.89,27.69 297.87,29.71 297.87,31.31 296.8,32.39 296.8,33.81 283.87,46.74 283.87,54.84 280.39,58.31 280.39,58.79 272.9,66.29 272.9,66.98 270.78,69.11 265.46,69.11 263.18,71.39 252.41,71.39 250.56,69.53 248.95,69.53 248.42,69 241.23,69 240.94,69 239.44,67.49 239.44,64.97 240.58,63.83 240.58,62.03 240.07,61.51 240.07,60.64 v3(240.08,60.63)
  BOTTOM w0.089: v3(240.08,60.63) 239.78,61.07 239.78,61.23 U4710.F7
  BOTTOM w0.107: v1(304.4,26.55) 304.6,26.35 304.98,26.35 305.43,25.9 305.43,24.74 306.58,23.6 306.58,22.88 C2503.2
USB3_TX2N: length 101.1
  TOP w0.107: v3(302.94,25.68) 302.66,25.4 302.66,24.87 302.87,24.67 C2504.2
  L3 w0.084: v3(302.94,25.68) 302.75,25.88 302.75,26.74 301.75,27.73 301.75,30.76 297.84,34.67 297.84,36.51 288.83,45.53 288.83,46.74 287.32,48.25 287.32,58.24 286.06,59.5 284.41,59.5 280.82,63.08 276.97,63.08 273.66,66.38 273.66,67.48 270.86,70.29 267.09,70.29 265.39,71.98 252.16,71.98 250.37,70.19 248.76,70.19 248.17,69.6 241.16,69.6 240.7,69.6 238.82,67.73 238.82,64.64 239.11,64.36 239.11,64.24 v1(239.04,64.16)
  BOTTOM w0.107: v1(239.04,64.16) 239.04,64.15 238.93,64.04 U4710.C3
USB3_TX2P: length 101.1
  TOP w0.107: v1(302.28,25.66) 302.45,25.49 302.45,25.14 C2501.2
  L3 w0.084: v1(239.37,63.63) 239.37,63.93 239.43,64 239.43,64.33 239.03,64.73 239.03,67.64 240.78,69.39 241.07,69.39 241.07,69.39 248.25,69.39 248.85,69.98 250.46,69.98 252.25,71.77 265.3,71.77 267,70.07 270.77,70.07 273.45,67.4 273.45,66.3 276.88,62.87 280.74,62.87 284.32,59.29 285.98,59.29 287.11,58.15 287.11,48.16 288.62,46.65 288.62,45.44 297.63,36.43 297.63,34.58 301.54,30.68 301.54,27.65 302.54,26.65 302.54,25.91 302.29,25.66 v1(302.28,25.66)
  BOTTOM w0.107: U4710.D4 239.23,63.66 239.26,63.63 v1(239.37,63.63)
USB3_TX3N: length 93.4
  TOP w0.107: C2518.2 296.93,29.16 296.57,29.16 v1(296.26,29.47)
  L3 w0.084: v3(240.24,59.33) 240.3,59.33 240.96,59.99 240.96,59.99 241.41,60.44 241.41,64.15 240.25,65.31 240.25,67.15 240.39,67.29 240.39,67.3 240.62,67.53 240.62,67.53 241.27,68.17 248.74,68.17 249.27,68.7 250.92,68.7 252.73,70.51 260.92,70.51 263.2,68.23 269.8,68.23 278.76,59.27 278.76,59.15 278.76,59.15 278.76,57.71 278.76,57.71 278.76,50.53 295.98,33.32 295.98,31.74 296.9,30.82 296.9,29.59 296.53,29.22 296.35,29.22 296.26,29.31 v1(296.26,29.47)
  BOTTOM w0.107: U4710.F11 v3(240.24,59.33)
USB3_TX3P: length 93.4
  TOP w0.107: v3(296.34,28.73) 296.56,28.95 296.75,28.95 297.13,28.57 C2519.2
  L3 w0.084: v3(296.34,28.73) 297.11,29.5 297.11,30.91 296.19,31.83 296.19,33.41 278.97,50.62 278.97,57.62 278.97,59.24 278.97,59.24 278.97,59.36 269.89,68.44 263.29,68.44 261.01,70.72 252.64,70.72 250.84,68.91 249.18,68.91 248.65,68.39 241.18,68.39 240.53,67.74 240.53,67.74 240.18,67.38 240.18,67.38 240.04,67.24 240.04,65.22 241.2,64.06 241.2,60.53 240.77,60.1 240.61,60.1 v1(240.56,60.15)
  BOTTOM w0.107: U4710.G12 240.66,59.67 240.48,59.85 240.48,60.07 v1(240.56,60.15)
USB3_TX4_C_DN: length 6.5
  BOTTOM w0.107: U2401.20 285.86,114.14 286.15,113.85 286.15,113.43 285.56,112.83 283.28,112.83 282.24,111.79 281.99,111.79 281.76,112.01 C2411.2
USB3_TX4_C_DP: length 6.5
  BOTTOM w0.107: U2401.19 286.36,113.34 285.64,112.62 283.37,112.62 282.33,111.58 281.84,111.58 C2410.2
USB3_TX4_IC_C_DN: length 1.6
  BOTTOM w0.107: L2401.2 285.75,122.27 286.05,121.98 286.05,121.46 C2405.2
USB3_TX4_IC_C_DP: length 1.6
  BOTTOM w0.107: L2401.1 286.55,122.3 286.25,122 286.25,121.46 C2406.2
USB3_TX4_L_DN: length 20.9
  BOTTOM w0.107: CN2400.8 303.47,124.21 303.28,124.02 303.01,124.02 302.28,124.74 299.23,124.74 297.45,126.53 290.59,126.53 290.57,126.55 290.56,126.55 290.43,126.68 D2401.4 D2401.7 288.32,126.68 287.07,125.43 286.38,125.43 286.02,125.08 286.02,124.74 285.75,124.47 L2401.3
USB3_TX4_L_DP: length 20.8
  BOTTOM w0.107: L2401.4 286.55,124.49 286.23,124.82 286.23,124.99 286.46,125.23 287.16,125.23 288.4,126.47 288.64,126.47 288.93,126.18 D2401.6 D2401.5 290.38,126.18 290.53,126.32 297.36,126.32 299.15,124.53 302.2,124.53 302.92,123.81 303.3,123.81 303.47,123.64 CN2400.9
USB3_TX4N: length 214.2
  L10 w0.084: v1(35.2,55.22) 35.62,54.79 59.63,54.79 62.06,52.36 75.1,52.36 76.36,53.63 88.55,53.63 89.11,54.18 97.64,54.18 98.14,53.68 105.28,53.68 106.29,54.69 111.62,54.69 112.15,54.15 153.34,54.15 157.39,50.1 220.19,50.1 223.48,53.38 228.98,53.38 231.16,55.56 234.19,55.56 234.97,56.34 234.97,56.84 235.29,57.16 235.29,57.47 v1(235.12,57.64)
  BOTTOM w0.089: U4710.B14 238.17,58.7 237.97,58.7 237.63,58.36 236.85,58.36 236.76,58.45 236.28,58.45 236.27,58.46 236.18,58.46
  BOTTOM w0.107: CN603.38 34.35,54.35 34.43,54.43 34.79,54.43 35.2,54.85 v1(35.2,55.22) ; 236.18,58.46 235.66,58.46 235.37,58.18 235.37,57.89 v1(235.12,57.64)
USB3_TX4P: length 214.2
  L10 w0.084: v1(34.62,54.84) 35.01,54.84 35.12,54.74 35.38,54.74 35.54,54.58 59.54,54.58 61.97,52.15 75.19,52.15 76.45,53.41 88.64,53.41 89.19,53.97 97.56,53.97 98.06,53.47 105.37,53.47 106.38,54.48 111.53,54.48 112.06,53.94 153.25,53.94 157.31,49.89 220.28,49.89 223.56,53.17 229.07,53.17 231.25,55.35 234.28,55.35 235.18,56.25 235.18,56.76 235.51,57.08 235.51,57.43 235.71,57.64 v3(235.8,57.63)
  BOTTOM w0.089: 236.18,58.26 236.27,58.26 236.28,58.27 236.69,58.27 236.78,58.18 237.7,58.18 238.04,58.52 238.42,58.52 U4710.C14
  BOTTOM w0.107: 236.18,58.26 235.74,58.26 235.58,58.09 235.58,57.85 v3(235.8,57.63) ; v1(34.62,54.84) 34.6,54.82 33.7,54.82 CN603.39
USB3_TX5_C_DN: length 2.8
  TOP w0.107: U2403.20 291.21,123.3 291.02,123.5 290.64,123.5 290.1,124.04 289.55,124.04 C2421.2
USB3_TX5_C_DP: length 2.8
  TOP w0.107: U2403.19 291.21,123.8 291.12,123.71 290.73,123.71 290.19,124.24 289.55,124.24 C2420.2
USB3_TX5_IC_C_DN: length 9.3
  TOP w0.107: L2404.2 300.4,132.02 300.4,131.13 300.24,130.97 300.24,124.85 299.51,124.12 299.03,124.12 C2417.2
USB3_TX5_IC_C_DP: length 9.3
  TOP w0.107: C2418.2 298.78,124.7 299.14,124.33 299.43,124.33 300.03,124.94 300.03,131.06 300.19,131.22 300.19,131.39 300.06,131.52 299.88,131.52 299.73,131.66 299.73,132.14 L2404.1
USB3_TX5_L_DN: length 15.1
  TOP w0.107: L2404.3 300.46,133.91 D2403.7 D2403.4 300.46,137.12 300.61,137.27 300.61,137.98 300.36,138.22 300.09,138.22 v1(299.86,138.46)
  L3 w0.084: CN2401.8 303.47,143.05 303.39,142.97 303.1,142.97 302.39,143.67 301.03,143.67 300.8,143.45 300.8,138.6 300.44,138.23 300.08,138.23 v1(299.86,138.46)
USB3_TX5_L_DP: length 15
  TOP w0.107: L2404.4 299.72,134.15 300.07,134.5 300.07,134.83 299.96,134.94 D2403.6 D2403.5 299.96,136.45 300.25,136.75 300.25,137.21 300.4,137.36 300.4,137.89 300.27,138.02 300.08,138.02 v1(299.86,137.8)
  L3 w0.084: v1(299.86,137.8) 300.08,138.02 300.52,138.02 301.01,138.51 301.01,143.36 301.11,143.46 302.31,143.46 303.01,142.76 303.39,142.76 303.47,142.67 CN2401.9
USB3_TX5N: length 218.7
  L10 w0.084: v1(32.36,51.31) 32.14,51.54 32.14,51.99 34.07,53.92 57.26,53.92 59.63,51.55 75.44,51.55 76.7,52.82 105.56,52.82 106.63,53.88 111.28,53.88 111.82,53.34 112.31,53.34 153,53.34 157.06,49.29 220.53,49.29 221.12,49.88 224.41,49.88 227.11,52.57 230.49,52.57 232.66,54.74 235.9,54.74 236.65,55.49 236.65,56.35 v3(236.88,56.58)
  BOTTOM w0.089: U4710.C15 238.45,57.92 238.45,57.81 238.19,57.55 237.81,57.55 237.79,57.53 237.77,57.53
  BOTTOM w0.107: v3(236.88,56.58) 236.68,56.78 236.68,56.93 237.28,57.53 237.77,57.53 ; v1(32.36,51.31) 32.36,51.64 32.47,51.75 32.86,51.75 33.26,51.35 CN603.32
USB3_TX5P: length 218.7
  L10 w0.084: v1(236.22,56.6) 236.44,56.38 236.44,55.58 235.81,54.95 232.57,54.95 230.41,52.78 227.02,52.78 224.32,50.09 221.03,50.09 220.44,49.5 157.14,49.5 153.09,53.55 112.23,53.55 112.22,53.55 111.9,53.55 111.37,54.09 106.54,54.09 105.48,53.03 76.61,53.03 75.35,51.76 59.72,51.76 57.35,54.13 33.98,54.13 31.93,52.08 31.93,51.77 31.7,51.54 v3(31.65,51.54)
  BOTTOM w0.089: 237.77,57.74 237.79,57.74 237.81,57.73 238.11,57.73 238.27,57.89 238.27,58.09 U4710.B15
  BOTTOM w0.107: v1(236.22,56.6) 236.29,56.6 236.47,56.77 236.47,57.02 237.19,57.74 237.77,57.74 ; v3(31.65,51.54) 31.96,51.54 32.38,51.96 32.94,51.96 33.05,51.85 CN603.33
USB_BT_DN: length 110.6
  L3 w0.084: v1(239.01,62.59) 239.01,62.85 238.22,63.64 238.22,67.97 240.51,70.26 247.7,70.26 248.46,71.02 248.46,71.76 249.37,72.67 251.94,72.67 252.63,73.37 270.42,73.37 274.42,69.37 274.42,66.58 277.31,63.68 281.07,63.68 283.41,61.34 285.07,61.34 287.92,58.49 287.92,58.48 288.08,58.32 288.08,49.2 290.24,47.04 290.24,46.33 v3(290.46,46.1)
  BOTTOM w0.107: L1300.2 269.21,28.08 270.06,28.93 273.11,28.93 282.99,38.81 285.69,38.81 290.21,43.34 290.21,45.85 v3(290.46,46.1) ; U4710.E5 v1(239.01,62.59)
USB_BT_DP: length 110.5
  L3 w0.084: v3(239.59,62.27) 239.41,62.46 239.41,62.75 238.43,63.73 238.43,67.89 240.6,70.05 247.78,70.05 248.67,70.93 248.67,71.67 249.46,72.46 252.03,72.46 252.72,73.16 270.34,73.16 274.21,69.28 274.21,66.49 277.23,63.47 280.99,63.47 283.32,61.13 284.98,61.13 287.71,58.41 287.71,58.4 287.87,58.23 287.87,49.11 290.03,46.95 290.03,46.33 v1(289.8,46.1)
  BOTTOM w0.107: v1(289.8,46.1) 290,45.9 290,43.43 285.6,39.02 282.91,39.02 273.03,29.14 269.98,29.14 268.66,27.82 L1300.1 ; U4710.F6 240.03,62.39 239.71,62.39 v3(239.59,62.27)
USB_CAM_R_DN: length 230.5
  L10 w0.084: v1(35.57,59.86) 35.48,59.86 35.1,60.24 35.1,60.42 35.26,60.58 39.11,60.58 41.86,57.83 46.04,57.83 46.8,57.07 54.42,57.07 55.25,57.9 72.35,57.9 73.02,57.23 74.52,57.23 75.19,57.9 84.84,57.9 88.61,61.67 88.61,61.67 89.12,62.18 152.46,62.18 154.78,64.5 154.78,69.96 156.64,71.81 160.75,71.81 214.76,71.81 215.34,71.23 215.34,71.23 216.15,70.43 218.33,70.43 218.71,70.05 218.71,67.07 220.8,64.98 236.3,64.98 236.72,64.56 240.77,64.56 241.25,64.08 242.31,64.08 243.01,64.78 243.01,65.28 243.16,65.43 243.46,65.43 v1(243.57,65.32)
  BOTTOM w0.089: U4710.L4 242.64,63.66 242.71,63.72 242.82,63.72 243.02,63.92 243.02,64.55 243.24,64.76 243.24,65.02 243.53,65.32 v1(243.57,65.32)
  BOTTOM w0.107: L3002.1 35.32,60.83 35.11,60.62 35.11,60.23 35.31,60.03 35.31,60.02 35.48,59.86 v1(35.57,59.86)
USB_CAM_R_DP: length 230.6
  L10 w0.084: v1(243.5,65.9) 243.25,65.64 243.07,65.64 242.8,65.37 242.8,64.87 242.22,64.29 241.34,64.29 240.86,64.77 236.81,64.77 236.39,65.19 220.89,65.19 218.92,67.16 218.92,70.14 218.42,70.64 216.23,70.64 215.55,71.32 214.85,72.02 160.84,72.02 156.55,72.02 154.57,70.05 154.57,64.59 152.37,62.39 89.03,62.39 88.4,61.76 84.75,58.11 75.1,58.11 74.43,57.44 73.11,57.44 72.44,58.11 55.16,58.11 54.33,57.28 46.89,57.28 46.12,58.04 41.95,58.04 39.2,60.79 35.17,60.79 34.89,60.51 34.89,59.88 v3(34.91,59.86)
  BOTTOM w0.089: U4710.L3 242.66,63.9 242.75,63.9 242.84,64 242.84,64.62 243.06,64.83 243.06,65.42 243.46,65.83 243.46,65.86 v1(243.5,65.9)
  BOTTOM w0.107: v3(34.91,59.86) 34.91,60.59 34.77,60.72 L3002.2
USB_CHR#: length 1.4
  TOP w0.102: R2501.2 286.52,33.29 286.38,33.15 U2501.13
USB_CHR_POWER: length 4.8
  TOP w0.254: U2501.12 v2(288.13,32.43)
  TOP w0.381: 288.16,32.89 C2508.1
  BOTTOM w0.381: C2520.1 302.89,29.65 C2521.1 303.08,28.44
  vias: v1(297.71,33.02) v1(298.29,33.02) v5(289.61,31.89) v5(290.06,32.72) v5(290.34,31.93)
USB_IC4_L_DN: length 13.8
  TOP w0.107: v1(299.21,125.86) 299.03,126.03 298.56,126.03 297.3,127.3 297.3,127.69 296.99,128 296.61,128.39 D2400.1 296.61,129.71 296.72,129.83 297.56,129.83 297.67,129.93 297.67,130.32 297.56,130.43 296.11,130.43 295.88,130.66 295.5,130.66 295.39,130.55 295.39,130.39 295.55,130.23 L2400.3
  BOTTOM w0.107: CN2400.2 301.97,126.65 301.86,126.76 301.01,126.76 300.34,126.08 299.43,126.08 v1(299.21,125.86)
USB_IC4_L_DP: length 13.8
  TOP w0.107: L2400.4 295,130.28 295.18,130.47 295.18,130.64 295.41,130.87 295.97,130.87 296.2,130.64 297.64,130.64 297.87,130.41 297.87,130.01 298.51,129.38 D2400.3 298.51,128.4 298.18,128.07 297.91,128.07 297.51,127.66 297.51,127.38 298.65,126.24 298.93,126.24 v3(299.21,126.52)
  BOTTOM w0.107: CN2400.3 301.97,127.07 301.86,126.97 300.92,126.97 300.25,126.29 299.43,126.29 v3(299.21,126.52)
USB_IC5_L_DN: length 30.8
  TOP w0.107: CN2401.2 301.97,145.53 301.39,146.1 300.1,146.1 299.26,145.27 299.26,134.48 298.64,133.87 v2(298.64,133.15) 297.32,133.15 296.96,132.79 293.5,132.79 293.39,132.68 293.39,132.34 293.94,131.79 D2402.1 293.94,131.18 293.09,130.33 293.09,130.15 292.8,129.87 291.84,129.87 291.11,129.14 291.11,127.98 290.76,127.63 290.76,126.91 290.45,126.6 290.19,126.6 289.99,126.4 L2403.3
USB_IC5_L_DP: length 30.7
  TOP w0.107: CN2401.3 301.42,146.31 300.01,146.31 299.05,145.35 299.05,134.57 298.54,134.06 v2(297.75,134.06) 297.75,133.6 297.51,133.36 297.23,133.36 296.87,133 292.99,133 292.04,132.05 D2402.3 292.04,130.89 292.26,130.66 292.71,130.66 292.88,130.49 292.88,130.24 292.72,130.08 291.76,130.08 290.9,129.22 290.9,128.07 290.55,127.71 290.55,126.99 290.36,126.81 290.19,126.81 290.05,126.95 L2403.4
USB_P4_DN: length 230.9
  L10 w0.084: v1(242.95,60.91) 242.8,61.07 242.37,61.07 241.9,61.54 238.29,61.54 238.16,61.66 238.16,61.66 238.06,61.76 235.06,61.76 234.64,61.34 233.13,61.34 230.69,63.78 220.15,63.78 217.51,66.42 217.51,68.93 217.2,69.23 215.65,69.23 214.27,70.61 157.13,70.61 155.98,69.47 155.98,64 152.96,60.98 89.61,60.98 85.34,56.7 85.16,56.7 84.84,56.7 77.59,56.7 76.67,55.78 39.67,55.78 38.08,57.37 32.14,57.37 31.7,57.82 31.7,57.95 v3(31.47,58.17)
  BOTTOM w0.107: CN603.44 32.22,57.35 31.71,57.87 31.71,57.94 v3(31.47,58.17) ; U4710.M10 v1(242.95,60.91)
USB_P4_DP: length 230.9
  L10 w0.084: v1(32.13,58.17) 32.06,58.17 31.91,58.02 31.91,57.91 32.23,57.59 38.17,57.59 39.76,55.99 76.59,55.99 77.5,56.91 84.93,56.91 84.93,56.91 85.25,56.91 89.53,61.19 152.87,61.19 155.77,64.09 155.77,69.55 157.04,70.83 214.35,70.83 215.74,69.44 217.29,69.44 217.72,69.01 217.72,66.5 220.23,63.99 230.78,63.99 233.22,61.55 234.55,61.55 234.97,61.97 238.15,61.97 238.37,61.75 241.99,61.75 242.46,61.28 242.75,61.28 242.87,61.39 242.87,61.58 v3(242.78,61.67)
  BOTTOM w0.107: v1(32.13,58.17) 32.06,58.17 31.95,58.06 31.95,57.91 32.31,57.56 32.78,57.56 33.07,57.85 CN603.45 ; U4710.L9 242.58,61.1 242.89,61.41 242.89,61.56 v3(242.78,61.67)
USB_P5_DN: length 243.5
  L10 w0.084: v1(242.62,66.87) 242.88,66.87 243.1,67.09 243.7,67.09 244.42,66.36 244.42,63.27 244.42,63.27 244.42,63.09 243.74,62.41 243.74,60.67 243.04,59.97 242.87,59.97 241.89,59.97 240.62,58.7 239.91,58.7 239.79,58.82 238.54,60.07 233.44,60.07 230.32,63.18 219.43,63.18 215.39,67.22 215.39,68.64 214.02,70.01 157.38,70.01 156.58,69.22 156.58,63.75 153.21,60.38 89.86,60.38 85.5,56.01 77.86,56.01 74.68,52.84 62.28,52.84 59.94,55.18 36.67,55.18 35.83,56.02 32.1,56.02 31.78,56.34 31.78,56.63 v3(31.56,56.86)
  BOTTOM w0.089: U4710.M1 242.76,65.12 242.8,65.16 242.8,66.42 242.62,66.6 v1(242.62,66.87)
  BOTTOM w0.107: CN603.41 33.07,55.85 33.07,55.85 32.24,55.85 31.78,56.31 31.78,56.63 v3(31.56,56.86)
USB_P5_DP: length 243.5
  L10 w0.084: v1(32.22,56.86) 32.14,56.86 31.99,56.71 31.99,56.42 32.19,56.23 35.92,56.23 36.76,55.39 60.02,55.39 62.37,53.05 74.59,53.05 77.77,56.22 85.41,56.22 89.78,60.59 153.12,60.59 156.37,63.84 156.37,69.3 157.29,70.23 214.11,70.23 215.6,68.73 215.6,67.31 219.51,63.39 230.41,63.39 233.52,60.28 238.63,60.28 240,58.91 240.53,58.91 241.8,60.18 242.95,60.18 243.53,60.75 243.53,62.5 244.21,63.18 244.21,66.27 243.61,66.88 243.19,66.88 242.78,66.47 242.28,66.47 242.19,66.37 v3(242.19,66.32)
  BOTTOM w0.089: U4710.L2 242.59,64.79 242.51,64.87 242.51,65.13 242.62,65.23 242.62,66.33 242.45,66.5 242.3,66.5 242.19,66.39 v3(242.19,66.32)
  BOTTOM w0.107: v1(32.22,56.86) 31.99,56.63 31.99,56.4 32.33,56.06 32.78,56.06 33.07,56.35 CN603.42
USB_PLL_HVDD: length 4.7
  TOP w0.254: R51752.2 163.09,115.92 v2(162.6,116.41) 161.62,117.39 161.05,117.39 160.73,117.7 C51752.2 160.34,118.23 v4(160.18,118.23)
  BOTTOM w0.254: v4(160.18,118.23) 160.45,118.23 U50000.AW9
USB_PWR_EN: length 2.7
  TOP w0.102: U2501.5 283.2,30.2 282.9,29.9 v2(282.9,29.75) 282.16,29.75 R2555.2
USBPWR_EN: length 293.2
  L8 w0.102: v1(282.52,36.88) 282.52,39.88 279.65,42.75 263.56,42.75 263.36,42.55 256.39,42.55 255.98,42.96 255.98,44.21 255.53,44.66 253.36,44.66 251.66,46.36 250.06,46.36 249.15,47.27 248.68,47.27 248.56,47.39 244.24,47.39 244.02,47.18 242.22,47.18 242.05,47.35 241.06,47.35 240.5,46.79 239.67,46.79 237.66,44.78 234.08,44.78 232.89,43.59 231.13,43.59 229.02,41.48 209.88,41.48 208.35,43.01 v1(207.87,43.01) 207.41,42.55 202.18,42.55 199.21,39.58 187.07,39.58 185.82,38.33 180.85,38.33 175.15,32.63 174.46,32.63 174.46,32.63 169,32.63 168.15,31.78 151.87,31.78 151.44,31.35 134.42,31.35 133.87,31.9 128.2,31.9 120.82,39.27 113.82,39.27 111.1,41.99 106.15,41.99 104.29,43.85 104.29,43.86 104.05,44.1 104.04,44.1 98.61,49.53 62.29,49.53 58.58,53.24 48.91,53.24 46.37,55.78 44.15,55.78 39.6,60.33 37.11,60.33 36.45,59.67 36.45,58.65 36.29,58.5 v1(34.87,58.5)
  BOTTOM w0.102: v1(282.52,36.88) 287.68,36.88 293.24,31.32 U2502.1 ; CN603.46 34.72,58.35 v1(34.87,58.5) ; v1(207.87,43.01) 207.97,43.11 207.97,44.12 R352.2
VADPBL: length 8
  L10 w0.254: v3(44.52,46.74) 44.68,46.59 49.73,46.59 v1(50.03,46.28)
  BOTTOM w0.254: R60005.2 51.25,45.57 50.57,45.57 50.03,46.1 v1(50.03,46.28)
  BOTTOM w0.381: 45.14,47.32 R60020.1
VBIOS_CS#: length 5.4
  BOTTOM w0.109: R51400.1 154.44,83.92 156.3,83.92 156.74,84.36 v2(156.74,84.61) 157.12,84.99 R51401.2 157.45,85.05 U51400.1
VBIOS_SCLK: length 2.9
  BOTTOM w0.109: R51402.1 v2(155.8,93.42) 155.8,92.97 154.91,92.08 U51400.6
VBIOS_SI: length 2.7
  BOTTOM w0.109: R51403.1 154.1,93.65 v2(153.83,93.38) 153.59,93.14 153.59,92.83 153.64,92.78 U51400.5
VGT_VCCSENSE: length 47.5
  TOP w0.254: R4525.1 105.41,143.84 105.69,143.84 106.48,144.64 v1(106.49,144.64) ; R66480.2 78.02,157.66 77.82,157.46 77.82,156.91 79.99,154.74 85.95,154.74 v1(86.08,154.87)
  L3 w0.254: v1(86.08,154.87) 86.15,154.79 86.71,154.79 88.03,153.47 91.49,153.47 92.38,154.36 108.07,154.36 109.5,152.94 109.5,146.9 107.8,145.2 107.06,145.2 v1(106.49,144.64)
  BOTTOM w0.076: U4555.AH38 106.81,144.31 v1(106.49,144.64)
VGT_VSSSENSE: length 47.1
  TOP w0.254: R4527.1 106.49,143.46 v1(106.49,143.99) ; R66481.2 77.44,157.36 77.44,156.75 79.83,154.36 86,154.36 v1(86.1,154.26)
  L3 w0.254: v1(106.49,143.99) 106.48,143.99 106.02,144.44 106.02,144.87 106.71,145.56 107.6,145.56 109.12,147.08 109.12,152.78 107.92,153.98 92.53,153.98 91.65,153.09 87.88,153.09 86.58,154.38 86.23,154.38 v1(86.1,154.26)
  BOTTOM w0.076: U4555.AH37 106.81,143.66 v1(106.49,143.99)
VID0_VCCIO: length 3.5
  BOTTOM w0.102: U60500.4 68.25,108.04 v2(67.87,108.42) 67.28,109.01 R60524.1 67.23,109.33 67.21,109.35 66.76,109.35 R7044.2
VID1_VCCIO: length 3.7
  BOTTOM w0.102: R7043.2 65.85,109.36 R60525.1 66.14,108.87 v2(66.6,108.41) 66.84,108.41 67.75,107.5 U60500.3
VIDALERT#: length 1.4
  TOP w0.109: v3(90.75,140.08) 90.62,139.96 R4511.2
  BOTTOM w0.076: v3(90.75,140.08) 91.07,139.76 U4555.BH31
VR_SVID_ALERT#: length 32.1
  TOP w0.109: R4511.1 90.71,138.44 R4538.2 91.62,139.97 91.51,140.08 v1(91.51,140.09) ; v1(81.02,158.47) 81.02,161.2 80.89,161.33 80.89,161.87 81.18,162.15 U66000.41
  L3 w0.076: v1(91.51,140.09) 91.51,140.09 91.13,140.46 91.13,141 90.67,141.46 90.67,143.01 89.95,143.73 88.88,143.73 88.55,144.05 88.55,146.54 86.02,149.08 84.41,149.08 83.04,150.44 83.04,154.69 82.55,155.18 82.55,155.18 82.1,155.62 82.1,158.77 81.89,158.98 81.43,158.98 81.02,158.57 v1(81.02,158.47)
VR_SVID_CLK: length 25.5
  TOP w0.109: R66102.2 81.58,159.11 81.7,159 v3(81.7,158.58) 81.63,158.51 R66101.2
  L3 w0.076: v3(81.7,158.58) 81.7,155.49 82.39,154.79 82.39,154.79 82.66,154.53 82.66,150.29 84.25,148.7 85.86,148.7 87.32,147.23 87.32,145.55 88.39,144.48 88.39,143.99 88.81,143.56 89.79,143.56 90.5,142.85 90.5,140.98 v1(90.74,140.74)
  BOTTOM w0.076: U4555.BH32 91.07,140.41 v1(90.74,140.74)
VR_SVID_DATA: length 32.4
  TOP w0.109: v1(91.31,137.87) 91.62,138.19 R4509.2 ; R66103.2 80.44,158.55 v3(80.36,158.47) 80.36,158.06 R66100.2
  L3 w0.076: v3(80.36,158.47) 81.26,159.36 82.51,159.36 82.95,158.93 82.95,157.84 82.61,157.5 82.61,155.65 83.42,154.84 83.42,150.6 84.57,149.46 86.17,149.46 86.18,149.46 89.14,146.49 89.14,146.04 90.42,144.76 90.42,144.59 90.83,144.17 90.83,141.57 91.93,140.48 91.93,139.84 91.69,139.6 91.69,138.26 v1(91.31,137.87)
  BOTTOM w0.109: v1(91.31,137.87) 91.31,138.37 U4555.BH29
VRA1V05A_FB: length 3.1
  BOTTOM w0.254: R60900.2 C60920.2 220.07,52.41 R60901.1 220.32,51.92 U60900.14
VRA1V05A_FF: length 0.8
  BOTTOM w0.254: R60920.2 220.07,54.77 C60920.1
VRA1V05A_ILMT: length 1.2
  BOTTOM w0.254: R60905.1 220.03,51.47 U60900.13
VRA1V05A_SNB: length 1
  BOTTOM w0.254: R60916.2 225.38,61.31 C60916.1
VRA1V05A_VOUT: length 19.7
  L8 w0.254: v1(232.51,53.04) 232.25,52.78 222.32,52.78 220.82,54.28 220.82,55.75 221.11,56.04 221.13,56.04 v1(221.31,56.21)
  BOTTOM w0.254: R60900.1 219.17,54.81 R60920.1 219.17,55.11 220.27,56.21 v2(220.47,56.21) v1(221.31,56.21) ; PAD60900.3 232.13,52.38 232.38,52.64 232.38,52.91 v1(232.51,53.04)
VRA1V8A_FB: length 3.8
  TOP w0.254: R60600.1 213.3,20.82 C60605.2 ; C60605.2 213.3,22.04 R60601.2 v2(211.96,22.57) ; C60605.2 214.09,21.74 U60600.5
VRA1V8S_FB: length 3
  TOP w0.102: R67400.1 197.42,171.73 C67420.2 197.46,171.82 R67401.2 197.46,172.65 U67400.14
VRA1V8S_FF: length 0.9
  TOP w0.102: C67420.1 197.38,170.83 R67420.1
VRA1V8S_ILMT: length 1.4
  TOP w0.102: R67405.1 197.01,172.96 U67400.13
VRA1V8S_SNB: length 1.9
  TOP w0.381: R67416.2 201.2,172.67 201.75,172.67 v2(201.77,172.7) 201.83,172.75 C67416.1
VRA1V8S_VOUT: length 14.6
  TOP w0.254: v1(195.23,171.73) R67400.2 195.81,171.27 195.81,171.27 R67420.2 ; PAD67400.3 207.32,172.94 v1(206.94,172.56)
  L3 w0.254: v1(206.94,172.56) 206.75,172.75 203.83,172.75 203.73,172.65 196.15,172.65 v1(195.23,171.73)
VRA1V35_SNB: length 2
  BOTTOM w0.254: C60316.1 66.01,75.16 v2(65.78,75.39) 65.78,75.99 R60316.2
VRA2V5_FB: length 4.1
  BOTTOM w0.254: v2(74.04,58.69) C60405.2 R60400.2 ; U60400.6 76.56,58.69 R60400.2 ; R60400.2 75.87,58.61 75.87,58.02 R60401.1
VRA3V3A_SNB: length 1.8
  TOP w0.254: C60166.1 198.35,27.95 v2(198.35,27.94) 198.34,27.93 R60166.2
VRA3V3A_VCC: length 1.6
  TOP w0.254: C60109.2 194.28,27.6 U60100.9
VRA3V3DS_VOUT: length 22.7
  TOP w0.254: v1(194.41,22.28) C60190.1 193.78,22.29 U60100.5 ; PAD60100.3 210.05,25.25 210.52,24.79 v1(210.52,24.04)
  L3 w0.254: v1(210.52,24.04) 204.81,24.04 203.12,25.73 196.69,25.73 195.32,24.36 195.32,22.58 195.02,22.28 v1(194.41,22.28)
VRA5V0_LDO: length 2.4
  BOTTOM w0.254: U60250.15 59.93,78 59.93,77.97 v2(59.43,77.47) 59.28,77.32 C60280.1
VRA5V0_SNB: length 2
  BOTTOM w0.254: v2(55.44,84.89) 55.78,84.56 55.78,84.06 ; 55.78,84.06 C60266.1 ; 55.78,84.06 55.88,84.17 R60266.2
VRA5V0A_FF: length 2.2
  TOP w0.254: U60200.13 244.89,22.32 244.75,22.18 v2(244.75,21.67) 244.29,21.2 C60231.2
VRA5V0A_FF_R: length 1.7
  TOP w0.254: C60231.1 R60239.1 242.67,19.97 v2(242.64,19.99)
VRA5V0A_LDO: length 1.1
  TOP w0.254: C60230.1 246.02,21.97 245.79,22.21 U60200.15
VRA5V0A_SNB: length 1
  TOP w0.381: C60216.1 R60216.2
VRA5V0A_VOUT: length 16.9
  TOP w0.254: R60239.2 244.92,19.97 245.01,20.05 R60203.2 245.62,20.05 v1(245.89,20.32) ; PAD60200.3 260.14,20.29 v1(259.86,20.02)
  BOTTOM w0.254: v1(245.89,20.32) 246.4,19.82 259.66,19.82 v1(259.86,20.02)
VRA_SY8284_VCC: length 1.1
  TOP w0.254: C67409.1 v2(199.55,173.38)
VRA_SY8288_VCC: length 2.4
  BOTTOM w0.254: U60900.16 221.62,53.8 C60909.1 222.04,53.87 222.04,53.63 222.07,53.59 U60900.17
VRACHG_ACDET: length 6.4
  BOTTOM w0.254: U60000.6 54.46,46.54 53.96,46.54 53.46,47.03 53.46,47.81 v2(53.28,48) 53.24,48.04 C60012.1 R60003.1 R60002.1 49.91,47.33 D6098.2
VRACHG_ACDRV: length 2.4
  BOTTOM w0.254: R60004.1 52.34,46.25 v2(53.07,46.25) 53.07,46.24 53.59,45.71 U60000.4
VRACHG_ACN: length 13.2
  BOTTOM w0.254: R60000.4 45.42,39.03 45.74,39.35 47.2,39.35 48,40.16 48,40.79 48.18,40.97 48.18,42.07 48.76,42.65 v2(49.15,42.65) 50.06,42.65 C60017.1 50.77,42.97 50.78,42.97 51.06,43.24 51.37,43.24 51.5,43.37 C60018.2 52.4,43.37 52.73,43.69 53.19,43.69 54.01,44.51 U60000.1
VRACHG_ACP: length 13.2
  BOTTOM w0.254: R60000.3 45.42,39.98 45.68,39.73 47.04,39.73 47.62,40.31 v2(47.62,41.2) 47.8,41.38 47.8,42.22 48.81,43.23 49.88,43.23 C60014.1 51.21,43.63 51.81,44.22 C60018.1 52.43,44.22 52.57,44.07 53.03,44.07 53.87,44.91 U60000.2
VRACHG_BATDRV: length 2.5
  BOTTOM w0.254: U60000.18 59.63,45.71 v2(59.93,46.02) 60.12,46.21 R60011.1
VRACHG_BATDRV1: length 33.2
  L5 w0.508: v1(61.66,46.92) 61.03,46.29 61.03,43.82 56.23,39.02 46.15,39.02 v3(39.06,31.93)
  BOTTOM w0.432: R60011.2 v1(61.66,46.92)
  BOTTOM w0.508: Q60012.4 39.8,32.19 39.55,31.93 v3(39.06,31.93) 39.06,31.11 C60019.2
VRACHG_BST: length 2.7
  BOTTOM w0.254: U60000.25 56.49,43.31 56.49,42.52 56.65,42.35 v2(56.65,42.12) R60015.1
VRACHG_BST1: length 6.2
  BOTTOM w0.254: v2(56.16,36.22) D60001.3 55.45,39.23 R60015.2 55.42,41.11 C60015.1
VRACHG_CMSRC: length 2.5
  BOTTOM w0.254: R60005.1 52.72,44.95 v2(53.08,44.95) 53.44,45.31 U60000.3
VRACHG_ILIM: length 5.4
  BOTTOM w0.254: U60000.21 58.48,44.11 58.75,43.84 58.75,43.53 C60024.1 59.46,42.95 60.14,42.27 v2(60.14,41.76) 60.45,41.46 60.45,41.02 R60014.2 61.41,40.98 R60013.1
VRACHG_MP1:
  vias: v2(46.22,42.82)
VRACHG_REGN: length 18
  L8 w0.254: v1(49.27,44.22) 50.03,43.46 55.88,43.46 v1(57.32,42.02)
  BOTTOM w0.254: U60000.24 56.91,43.69 56.91,42.75 57.32,42.33 v1(57.32,42.02) 57.79,41.55 C60023.1 58.26,40.55 D60001.1 D60001.2 v2(59.73,37.57) ; R60023.2 49.25,44.2 v1(49.27,44.22)
VRACHG_SNB: length 1.9
  BOTTOM w0.381: R60016.2 49.14,25.83 v2(49.15,25.84) 49.9,25.84 C60016.1
VRACHG_SRN: length 2.8
  BOTTOM w0.254: R60010.1 60.07,44.66 v2(59.84,44.66) 59.18,45.31 U60000.19
VRACHG_SRN1: length 50.8
  TOP w0.254: v1(63.42,44.15) 63.08,44.15 62.38,43.44 62.38,38.26 59.79,35.67 59.79,28.46 58.17,26.84 53.42,26.84 49.98,23.4 38.82,23.4 37.61,24.61 37.61,28.58 v3(37.79,28.76)
  BOTTOM w0.254: v1(63.42,44.15) 63.1,44.15 C60020.1 62.49,44.42 61.64,44.42 C60021.2 61.59,45.26 R60010.2 ; v3(37.79,28.76) 37.34,29.2 R60001.4
VRACHG_SRP: length 3.8
  BOTTOM w0.254: U60000.20 59,44.91 59.25,44.66 59.25,44.28 59.51,44.02 60.35,44.02 v2(60.71,43.67) R60008.1
VRACHG_SRP1: length 51.4
  TOP w0.254: v1(37.13,28.73) 37.23,28.63 37.23,24.45 38.66,23.02 50.14,23.02 53.58,26.46 58.33,26.46 60.17,28.3 60.17,35.51 62.76,38.1 62.76,38.42 62.76,43.29 63.01,43.54 v1(63.7,43.54)
  BOTTOM w0.254: v1(37.13,28.73) 37.13,28.67 37.34,28.45 R60001.3 ; v1(63.7,43.54) 63.37,43.54 63.24,43.67 62.87,43.67 C60022.1 62.49,43.62 C60021.1 61.56,43.59 R60008.2
VRACHG_VCC: length 4.6
  BOTTOM w0.254: R60009.1 51.71,42.13 C60009.2 53.29,42.31 53.29,42.93 v2(53.68,43.32) 54.07,43.71 U60000.28
VRACPU_BST1: length 1.5
  BOTTOM w0.254: U66010.7 100.64,174.39 C66015.2
VRACPU_BST2: length 1.5
  BOTTOM w0.254: C66025.2 111,174.44 U66020.7
VRACPU_BST3: length 1.5
  BOTTOM w0.254: U66030.7 121.42,174.42 C66035.2
VRACPU_BST4: length 1.5
  BOTTOM w0.254: C66045.2 131.78,174.44 U66040.7
VRACPU_BST11: length 1.2
  BOTTOM w0.254: C66015.1 100.13,175.84 R66015.1
VRACPU_BST12: length 1.7
  BOTTOM w0.254: R66015.2 99.64,174.61 U66010.5
VRACPU_BST21: length 1.2
  BOTTOM w0.254: R66025.1 110.49,175.89 C66025.1
VRACPU_BST22: length 1.7
  BOTTOM w0.254: U66020.5 110,174.66 R66025.2
VRACPU_BST31: length 1.2
  BOTTOM w0.254: C66035.1 120.91,175.86 R66035.1
VRACPU_BST32: length 1.7
  BOTTOM w0.254: R66035.2 120.42,174.64 U66030.5
VRACPU_BST41: length 1.2
  BOTTOM w0.254: R66045.1 131.29,175.86 C66045.1
VRACPU_BST42: length 1.7
  BOTTOM w0.254: R66045.2 130.78,174.64 U66040.5
VRACPU_COMP: length 6.2
  TOP w0.254: R66172.1 91.25,164.95 v2(91.23,164.93) 91.2,164.89 C66172.1 90.21,164.89 90.04,164.72 87.83,164.72 87.4,165.15 U66000.6
VRACPU_COMP1: length 1.7
  TOP w0.254: R66172.2 92.94,164.86 v2(92.94,164.11) 92.88,164.06 C66171.1
VRACPU_CSCOMP: length 18.6
  TOP w0.254: R66151.2 91.99,165.61 v1(91.16,165.61) 89.88,165.61 R66005.1 89.58,166.14 C66151.1 C66150.1 88.54,165.96 86.27,165.96 86.26,165.95 U66000.8
  BOTTOM w0.254: v1(91.16,165.61) 91.39,165.38 91.39,157.76 92.96,156.18 93.37,156.18 93.84,155.71 R66150.2
VRACPU_CSCOMP1: length 13.3
  TOP w0.254: R66151.1 91.55,166.62 v3(91.31,166.37) 91.06,166.12 R66152.1
  BOTTOM w0.254: v3(91.31,166.37) 91.77,165.92 91.77,157.92 93.12,156.56 R66150.1
VRACPU_CSN1: length 1.7
  TOP w0.254: R66018.2 98.91,160.02 v2(98.81,159.92) 98.72,160.02 R66113.1
VRACPU_CSN2: length 1.6
  TOP w0.254: R66028.2 v2(109.22,159.97) 109.21,159.97 R66123.1
VRACPU_CSN3: length 1.6
  TOP w0.254: R66133.1 v2(119.61,159.97) 119.66,159.97 119.66,159.97 R66038.2
VRACPU_CSN4: length 1.7
  TOP w0.254: R66143.1 v2(129.99,159.99) 130.02,159.99 130.02,159.99 R66048.2
VRACPU_CSN11: length 3.2
  TOP w0.254: R66018.1 v1(99.64,158.55)
  BOTTOM w0.254: v1(99.64,158.55) L66010.4
VRACPU_CSN21: length 3.1
  TOP w0.254: R66028.1 110.03,158.55 v1(110,158.52)
  BOTTOM w0.254: v1(110,158.52) L66020.4
VRACPU_CSN31: length 3.1
  TOP w0.254: v1(120.42,158.52) R66038.1
  BOTTOM w0.254: L66030.4 v1(120.42,158.52)
VRACPU_CSN41: length 3.2
  TOP w0.254: R66048.1 v1(130.81,158.56)
  BOTTOM w0.254: L66040.4 v1(130.81,158.56)
VRACPU_CSP1: length 15.1
  TOP w0.254: R66112.1 91.76,168.54 v1(91.11,168.54) 90.68,168.54 R66114.1 ; v1(98.78,160.58) 98.96,160.77 R66019.2
  L5 w0.254: v1(98.78,160.58) 96.97,160.58 92.78,164.76 92.78,167.82 92,168.6 91.28,168.6 91.26,168.58 91.16,168.58 v1(91.11,168.54)
VRACPU_CSP1_R: length 5.7
  TOP w0.254: R66115.2 90.19,169.59 89.67,169.07 R66114.2 89.56,168.6 C66114.2 88.69,168.6 87.41,167.31 v2(87.4,167.31) 87.4,167.31 87.25,167.15 U66000.11
VRACPU_CSP2: length 25.2
  TOP w0.254: v1(92.01,170.26) 92.01,170.26 R66122.1 92.66,169.78 92.64,169.76 92.64,169.4 R66124.1 ; R66029.2 109.48,160.72 109.42,160.77 109.42,160.77 v1(109.01,161.17)
  L5 w0.254: v1(92.01,170.26) 94.03,168.24 94.03,165.42 97.63,161.83 100.73,161.83 101.39,161.17 v1(109.01,161.17)
VRACPU_CSP2_R: length 6.9
  TOP w0.254: U66000.12 86.8,167.55 87.31,168.06 87.56,168.06 88.24,168.73 88.24,169.09 C66124.2 88.57,169.27 v1(89.12,169.27) ; R66124.2 91.18,169.37 v1(91,169.19)
  L3 w0.254: v1(89.12,169.27) 90.93,169.27 v1(91,169.19)
VRACPU_CSP3: length 37.4
  TOP w0.254: R66039.2 v1(119.45,160.72) ; R66134.1 92.93,171.65 92.66,171.38 R66132.1 91.91,171.14 v3(91.77,171)
  L5 w0.254: v1(119.45,160.72) 119.42,160.68 101.09,160.68 100.33,161.45 97.47,161.45 93.65,165.27 93.65,168.05 92.33,169.37 92.2,169.37 91.51,170.06 91.51,170.74 v3(91.77,171)
VRACPU_CSP3_R: length 9.6
  TOP w0.254: U66000.13 86.56,167.95 87.05,168.44 87.41,168.44 87.86,168.89 87.86,169.87 87.96,169.98 87.96,170.49 88.49,171.02 C66134.2 88.6,171.44 88.73,171.56 R66136.2 88.73,172.19 88.98,172.44 90.32,172.44 v2(90.83,171.94) 90.93,172.04 R66134.2
VRACPU_CSP4: length 63.8
  TOP w0.254: R66049.2 v1(129.84,160.77) ; R66142.1 78.62,172.44 v3(78.69,172.37) 78.83,172.22 R66144.2
  L5 w0.254: v1(129.84,160.77) 129.17,160.1 100.83,160.1 99.87,161.06 97.17,161.06 93.16,165.07 93.16,167.98 92.16,168.99 92.05,168.99 91.13,169.9 91.13,172.04 89.35,173.82 79.4,173.82 78.69,173.1 v3(78.69,172.37)
VRACPU_CSP4_R: length 6.8
  TOP w0.254: R66137.1 77.84,172.22 77.98,172.08 R66144.1 77.98,171.27 78.61,170.64 C66144.1 79,170.15 79.35,169.8 v2(79.72,169.8) 79.72,168.82 80.1,168.44 U66000.26
VRACPU_CSP11: length 3.3
  TOP w0.254: R66019.1 v3(99.64,162.39)
  BOTTOM w0.254: L66010.3 v3(99.64,162.39)
VRACPU_CSP21: length 3.4
  TOP w0.254: R66029.1 110,161.59 v3(110,162.35)
  BOTTOM w0.254: v3(110,162.35) L66020.3
VRACPU_CSP31: length 3.4
  TOP w0.254: v3(120.42,162.36) R66039.1
  BOTTOM w0.254: L66030.3 v3(120.42,162.36)
VRACPU_CSP41: length 3.3
  TOP w0.254: v3(130.81,162.39) R66049.1
  BOTTOM w0.254: L66040.3 v3(130.81,162.39)
VRACPU_CSREF: length 78.4
  TOP w0.254: v1(90.1,171.51) 89.7,171.91 R66136.1 89.58,171.17 89.45,171.05 C66134.1 89.45,170.5 89.33,170.38 R66115.1 88.88,169.98 88.65,170.2 C66124.1 ; C66113.1 89.95,167.75 v1(89.44,167.75) C66114.1 88.64,167.75 87.65,166.75 U66000.10 ; v1(107.67,159.12) R66123.2 ; R66113.2 97.18,159.17 v1(97.18,159.16) ; C66144.2 79.85,170.98 v1(80.36,171.5) ; v1(118.03,159.12) R66133.2 ; v1(128.42,159.14) R66143.2
  L5 w0.254: v1(80.36,171.5) 80.42,171.56 83.61,171.56 84.5,172.44 89.17,172.44 v1(90.1,171.51) 88.54,169.95 88.54,166.4 91.13,163.81 91.97,163.81 96.62,159.16 v1(97.18,159.16) 98.45,157.89 106.44,157.89 v1(107.67,159.12) 108.92,157.86 116.78,157.86 v1(118.03,159.12) 119.13,158.02 127.29,158.02 v1(128.42,159.14)
  L8 w0.254: v1(89.44,167.75) 90.1,168.4 v1(90.1,171.51)
VRACPU_CSSUM: length 29.8
  TOP w0.254: R66132.2 R66122.2 v2(93.51,169.27) 92.72,168.48 R66112.2 92.67,168.04 91.9,167.26 v1(91.74,167.26) 91.23,167.26 90.94,166.97 R66152.2 C66151.2 C66150.2 88.53,166.97 87.92,166.35 U66000.9 ; R66142.2 v1(79.47,172.37)
  L5 w0.254: v1(91.74,167.26) 91.52,167.26 90.52,168.26 90.33,168.45 90.33,169.92 90.75,170.34 90.75,171.88 89.32,173.31 79.72,173.31 79.47,173.05 v1(79.47,172.37)
