# Allegro board PH317-53 COVINI-6050A3087701-MB-AX2 (BDV)(.BRD).brd (continued)
## Library data of the parts (continued)
U2401 = PS8713BTQFN24GTR2_A2: part number: PS8713BTQFN24GTR2_A2-PARADE_PS8713BTQFN24GTR2_A3_TQFN_24P,6019B1566001,TQFN_400X400X080_24_050_T6,0.90MM,,IC,REPEATER/REDRIVER,USB3.0,TQFN,24P,TR; room: Sheet121
U2403 = PS8713BTQFN24GTR2_A2: part number: PS8713BTQFN24GTR2_A2-PARADE_PS8713BTQFN24GTR2_A3_TQFN_24P,6019B1566001,TQFN_400X400X080_24_050_T6,0.90MM,,IC,REPEATER/REDRIVER,USB3.0,TQFN,24P,TR; room: Sheet122
U2500 = G518B1TP1U: part number: G518B1TP1U-GMT_G518B1TP1U_TSOT23_6P,6019B1647001,TSOT23_290X160X090_6_095_P2,1MM,,IC\POWER_SWCH_GMT_G518B1TP1U_TSOT-23-6_6PIN; room: Sheet60
U2501 = TPS2546RTER: part number: TPS2546RTER-TEXAS_TPS2546RTER_QFN_16P,6019B1035901,QFN_300X300X080_16_050_T1,0.95MM,,TEXAS_TPS2546RTER_QFN_16P; room: Sheet61
U2502 = 74LVC1G08GW: part number: 74LVC1G08GW-NXP_74LVC1G08GW_TSOT353_5P,6019A0136301,TSOT353_205X125X110_5_065,1.25MM,,IC-AND GATE-SINGLE 2INPUT-SOT353-5P-TR; room: Sheet60
U3000 = NCT3521U: part number: NCT3521U-NUVO_NCT3521U_SOT23_5P,6019B0849401,TSSOT23_290X160X135_5_095,1.5MM,,IC,POWER SWITCH,SOT23,5P,TR; room: Sheet62
U3500 = NPCT750AAAYX: part number: NPCT750AAAYX-NUVOTON_NPCT750AAAYX_QFN_32P,6019B1730201,QFN_500X500X080_32_050_T7,0.9MM,,IC,TPM,SPI,QFN32,32P,TR; room: Sheet63
U4450 = NCT7718W_MSOP: part number: NCT7718W_MSOP-NUVOTON_NCT7718W_MSOP_8P,6019B1814201,MSOP_300X300X110_8_065_P3,1.2MM,,IC,TEMPERATURE SENSOR,3.3V,MSOP,8P,TR; room: Sheet49
U4555 = J43242: part number: J43242-INTEL_J43242_BGA_1440P,6025B0338701,CPU_INTEL_COF_6C_B_4200X2800,1.55MM,,CPU,COFFEE LAKE,HEXA CORE,BGA,1440P; room: Sheet28
U4700 = 74LVC1G08GW: part number: 74LVC1G08GW-NXP_74LVC1G08GW_TSOT353_5P,6019A0136301,TSOT353_205X125X110_5_065,1.25MM,,IC-AND GATE-SINGLE 2INPUT-SOT353-5P-TR; room: Sheet36
U4710 = J44894: part number: J44894-INTEL_J44894_BGA_874P,6019B1621501,IC-BGA_INTEL_2500_2400_141,1.412MM,,IC,PCH,BGA,874P,TR; room: Sheet36
U7006 = AND_GATE: part number: AND_GATE-TC7SET08FU,6019A0059801,SSOP_200X125X100_5_065,1.15MM,AND_GATE,IC-TC7SET08FU-SSOP-TAP-TSB(5PIN); room: Sheet22
U50000 = N18E_G1_KD_QS_A1: part number: N18E_G1_KD_QS_A1-NVIDIA_N18E_G1_KD_QS_A1_BGA_2228P,6019B1849201,GPU_NVDIA_FB_N18E_3750X3750,3.05MM,,IC,GRAPHIC CONTROLLER,BGA,2228P,TRAY; room: Sheet74
U50020 = AND_GATE: part number: AND_GATE-TC7SZ08FU,6019B0090701,SSOP_200X125X100_5_065,1.15MM,AND_GATE,IC,AND GATE,ONE,5PIN; room: Sheet74
U50500 = MT61K256M32JE_14_A: part number: MT61K256M32JE_14_A-MICRON_MT61K256M32JE_14_A_FBGA_180P,TMP181005002,IC-MEMORY_MICRO_1400X1200X110,1.2MM,,IC,GDDR6,SGRAM,256MX32,FBGA,180P; room: Sheet79
U50600 = MT61K256M32JE_14_A: part number: MT61K256M32JE_14_A-MICRON_MT61K256M32JE_14_A_FBGA_180P,TMP181005002,IC-MEMORY_MICRO_1400X1200X110,1.2MM,,IC,GDDR6,SGRAM,256MX32,FBGA,180P; room: Sheet80
U50700 = MT61K256M32JE_14_A: part number: MT61K256M32JE_14_A-MICRON_MT61K256M32JE_14_A_FBGA_180P,TMP181005002,IC-MEMORY_MICRO_1400X1200X110,1.2MM,,IC,GDDR6,SGRAM,256MX32,FBGA,180P; room: Sheet81
U50800 = MT61K256M32JE_14_A: part number: MT61K256M32JE_14_A-MICRON_MT61K256M32JE_14_A_FBGA_180P,TMP181005002,IC-MEMORY_MICRO_1400X1200X110,1.2MM,,IC,GDDR6,SGRAM,256MX32,FBGA,180P; room: Sheet82
U50900 = MT61K256M32JE_14_A: part number: MT61K256M32JE_14_A-MICRON_MT61K256M32JE_14_A_FBGA_180P,TMP181005002,IC-MEMORY_MICRO_1400X1200X110,1.2MM,,IC,GDDR6,SGRAM,256MX32,FBGA,180P; room: Sheet83
U51000 = MT61K256M32JE_14_A: part number: MT61K256M32JE_14_A-MICRON_MT61K256M32JE_14_A_FBGA_180P,TMP181005002,IC-MEMORY_MICRO_1400X1200X110,1.2MM,,IC,GDDR6,SGRAM,256MX32,FBGA,180P; room: Sheet84
U51100 = MT61K256M32JE_14_A: part number: MT61K256M32JE_14_A-MICRON_MT61K256M32JE_14_A_FBGA_180P,TMP181005002,IC-MEMORY_MICRO_1400X1200X110,1.2MM,,IC,GDDR6,SGRAM,256MX32,FBGA,180P; room: Sheet85
U51200 = MT61K256M32JE_14_A: part number: MT61K256M32JE_14_A-MICRON_MT61K256M32JE_14_A_FBGA_180P,TMP181005002,IC-MEMORY_MICRO_1400X1200X110,1.2MM,,IC,GDDR6,SGRAM,256MX32,FBGA,180P; room: Sheet86
U51400 = MX25L1005MC_12G: part number: MX25L1005MC_12G-WINBOND_W25Q80EWSNIG_SOP_8P,6019B1486201,SOP_490X390X175_8_127,1.85MM,,IC,FLASH MEMORY,8M,-40~+85C,1.65~1.95V,104MHZ,4K,SOIC,8P,TR; room: Sheet88
U52000 = NCP45491XMNTWG: part number: NCP45491XMNTWG-ON_NCP45491XMNTWG_QFN_32P,6019B1849101,QFN_400X400X100_32_040_T2,1.1MM,,IC,PWM CONTROLLER,POWER MANAGEMENT,QFN,32P,TR; room: Sheet98
U53500 U53550 U53585 U53590 = 74LVC1G32: part number: 74LVC1G32-PHILIPS_74LVC1G32_TSOT353_5P,6019B0256101,TSOT353_200X125X110_5_065,1.2MM,,IC,OR GATE,ONE,SOT353,5P,TR; room: Sheet105
U53520 U53540 U53555 U53570 U53580 = AND_GATE: part number: AND_GATE-TC7SZ08FU,6019B0090701,SSOP_200X125X100_5_065,1.15MM,AND_GATE,IC,AND GATE,ONE,5PIN; room: Sheet105
U55300 = TPS22965DSGR: part number: TPS22965DSGR-TI_TPS22965DSGR_SON_8P,6019B1019901,SON_200X200X080_8_050_T1,0.95MM,,IC,LOAD-SWITCH,SON,8P,TR; room: Sheet107
U55800 = PI3DPX1203BZHEX: part number: PI3DPX1203BZHEX-PERICOM_PI3DPX1203BZHEX_TQFN_42P,6019B1848801,TQFN_900X350X084_42_050_T4,0.94MM,,IC,DP1.4 REDRIVER,TQFN,42P,TR; room: Sheet92
U56250 = NCT3521U: part number: NCT3521U-NUVO_NCT3521U_SOT23_5P,6019B0849401,TSSOT23_290X160X135_5_095,1.5MM,,IC,POWER SWITCH,SOT23,5P,TR; room: Sheet93
U56400 = IT66317FN_0003_R: part number: IT66317FN_0003_R-ITE_IT66317FN_BW_0006_R_QFN_48P,6019B1852001,QFN_600X600X090_48_040_T13,1MM,,IC,HDMI2.0 RETIMING BUFFER,QFN,48P,TR; room: Sheet95
U56610 = AP2802NTR_G1: part number: AP2802NTR_G1-GMT_G5250Q1T73U_SOT23_3P,6019B1243701,SOT23_290X160X145_3_095,1.60MM,,IC,POWER DISTRIBUTION SWITCH,SOT-23,3P,TR; room: Sheet96
U60000 = BQ24780S: part number: BQ24780S-TI_BQ24780S_QFN_28P,6019B1297701,WQFN_400X400X080_28_040_T1,0.95MM,,IC,CHARGER CONTROLLER,SMBUS,WQFN,28P,TR; room: Sheet8
U60100 = NB680AGD_Z: part number: NB680AGD_Z-MPS_NB680AGD_Z_QFN_12P,6019B1289201,QFN_300X200X100_12_050,1.15MM,,IC,DC/DC CONVERTER,QFN-12,12P,TR; room: Sheet12
U60200 = SY8288CRAC: part number: SY8288CRAC-SILERGY_SY8288CRAC_QFN_21P,6019B1731301,QFN_300X300X090_20_045_T2,1MM,,IC,SYNC BUCK,REGULATOR,QFN,21P,TR; room: Sheet10
U60250 = SY8284CRAC: part number: SY8284CRAC-SILERGY_SY8284CRAC_QFN_20P,6019B1529201,QFN_300X300X090_20_045_T1,1.00MM,,IC,SYNCHRONOUS STEP-DOWN REG,DC/DC,QFN,20P,TR; room: Sheet11
U60300 = NB685GQ_Z: part number: NB685GQ_Z-MPS_NB685AGQ_Z_QFN_16P,6019B1397101,QFN_300X300X100_16_050_P1,1.15MM,,IC,DC/DC CONVERTER,QFN-16,16P,TR; room: Sheet13
U60400 = RT8097ALGJ6: part number: RT8097ALGJ6-RICHTEK_RT8097ALGE_TSOT23_6P,6019B1265401,TSOT23_290X160X130_6_095,1.45MM,,IC,DC/DC CONVERTER,TSOT-23-6,6P,TR; room: Sheet15
U60500 = NB681GD_Z: part number: NB681GD_Z-MPS_NB681GD_Z_QFN_13P,6019B1244701,QFN_300X200X100_13_050,1.15MM,,IC,DC/DC CONVERTER,QFN13,13P,TR; room: Sheet17
U60600 = G5728TO1U: part number: G5728TO1U-SILERGY_SY8088AAC_SOT23_5P,6019B1522701,TSOT23_295X160X140_5_095,1.5MM,,IC,SYNCHRONOUS STEP-DOWN REG,2.5~5.5V,1.5MHZ,SOT-23-5,5P,TR; room: Sheet14
U60900 = SY8284RAC: part number: SY8284RAC-SILERGY_SY8288RAC_QFN_20P,6019B1830101,QFN_300X300X090_20_045_T2,1MM,,IC,STEP-DOWN REGULATOR,DC/DC,QFN,20P,TR; room: Sheet16
U66000 = NCP81215MNTXG: part number: NCP81215MNTXG-ON_NCP81215MNTXG_QFN_52P,6019B1607901,QFN_600X600X100_52_040_T1,1.10MM,,IC,PWM CONTROLLER,QFN,52P,TR; room: Sheet18
U66010 U66020 U66030 U66040 = NCP302035MNTXG: part number: NCP302035MNTXG-ON_NCP302045MNTWG_PQFN_33P,6019B1611701,PQFN_500X500X080_31_050_T2,0.90MM,,IC,MOSFET DRIVER,45A,PQFN,33P,TR; room: Sheet19
U66310 = NCP81151MNTBG_DFN: part number: NCP81151MNTBG_DFN-ON_NCP81151MNTBG_DFN_8P,6019B1111301,DFN_200X200X100_8_050_T2,1.15MM,,IC,MOSFET DRIVER,DUAL,DFN,8P,TR; room: Sheet20
U66610 = NCP81253MNTBG: part number: NCP81253MNTBG-ON_NCP81253MNTBG_DFN_8P,6019B1258401,DFN_200X200X100_8_050_T2,1.15MM,,IC,DRIVER MOSFET,DFN8,8P,TR; room: Sheet21
U67000 = MP2886AGU_Z: part number: MP2886AGU_Z-MPS_MP2886AGU_Z_QFN_40P,6019B1849501,QFN_500X500X100_40_040_T6,1.1MM,,IC,POWER CONTROLLER,MULTI PHASE,QFN-40; room: Sheet108
U67010 U67020 = MP86901_CGLT: part number: MP86901_CGLT-MPS_MP86941GQVT_Z_TQFN_21P,6019B1849601,TQFN_500X300X080_21_040,0.9MM,,IC,DRIVER MOSFET,30A,TQFN,21P,TR; room: Sheet109
U67030 U67040 = MP86901_CGLT: part number: MP86901_CGLT-MPS_MP86941GQVT_Z_TQFN_21P,6019B1849601,TQFN_500X300X080_21_040,0.9MM,,IC,DRIVER MOSFET,30A,TQFN,21P,TR; room: Sheet110
U67050 U67060 = MP86901_CGLT: part number: MP86901_CGLT-MPS_MP86941GQVT_Z_TQFN_21P,6019B1849601,TQFN_500X300X080_21_040,0.9MM,,IC,DRIVER MOSFET,30A,TQFN,21P,TR; room: Sheet111
U67200 = RT8816A: part number: RT8816A-RICHTEK_RT8816A_QFN_20P,6019B1485601,QFN_300X300X080_20_040_T2,0.90MM,,IC,PWM CONTROLLER,WQFN-20L,20P,TR; room: Sheet112
U67400 = SY8284RAC: part number: SY8284RAC-SILERGY_SY8284RAC_QFN_20P,6019B1715601,QFN_300X300X090_20_045_T1,1MM,,IC,STEP-DOWN REGULATOR,DC/DC,QFN,20P,TR; room: Sheet114
U67600 = RT8068AZQW: part number: RT8068AZQW-RICHTEK_RT8068AZQW_WDFN_10P,6019B0952001,WDFN_300X300X080_10_050_T1,0.95MM,,IC,DC/DC CONVERTER,3A,1 MHZ,WDFN,10P,TR; room: Sheet113
UU52100 = APL3537BHAI: part number: APL3537BHAI-ANPEC_APL3537BHAI_TRG_WLCSP_6P,6019B1228801,WLCSP_092X142X047_6_050,0.47MM,,IC,POWER SWITCH,WLCSP,6P,TR; room: Sheet99
X400 = XTAL_4PIN_F: part number: XTAL_4PIN_F-25MHZ_10PF,6018B0058301,XTAL_320X250X090_4_220-2,1.05MM,XTAL_4PIN_F,,,CRYSTAL,25MHZ,20PPM,10PF,SMD,3.2X2.5,TR; room: Sheet124
X4750 = XTAL_4PIN: part number: XTAL_4PIN-32.768KHZ_12.5PF,6018A0009301,XTAL_670X140X140_4_630,1.55MM,XTAL_4PIN,12.5PF,20PPM,XTAL-32.768KHZ(6H03200413)-20PPM-12.5PF-TAP-TXC; room: Sheet45
X4751 = XTAL_4PIN_F: part number: XTAL_4PIN_F-TXC_24MHZ_12PF,6018B0097301,XTAL_320X250X080_4_220,0.90MM,XTAL_4PIN_F,,,CRYSTAL,24MHZ,+/-20PPM,12PF,SMD,3.2X2.5X0.8,TR; room: Sheet45
X51310 = XTAL_4PIN_F: part number: XTAL_4PIN_F-27MHZ_10PF,6018B0057601,XTAL_320X250X090_4-2,1.05MM,XTAL_4PIN_F,,,CRYSTAL,27MHZ,10PPM,10PF,SMD,3.2X2.5X0.8,TR; room: Sheet87
XU300 = 91960_0084L: part number: 91960_0084L-ACES_91960_0084L_8P,6026B0150101,SKT-BIOS_ACES_970X920X500,5MM,SOCKET,SPI,8P,1.27MM,5.0MM,STR,SMD,TR; room: Sheet50

## Footprints (pads in the part's own frame, mm; a bottom-side part is the same pattern mirrored in y, then rotated)
APUS-6015B0153201-001
  rect 0.457x0.508 smd: 1(-0.65,-0.95) 2(0,-0.95) 3(0.65,-0.95) 4(0.65,0.95) 5(0,0.95) 6(-0.65,0.95)
ASHMORE-6036B0093201-003
  rect 1.778x3.15 smd: 1(-2.391,0) 2(2.391,0)
AUDIO_SIGAT_6_R_050_200_1
  oval 1.092x2.007 hole 0.61x1.499: 1(-4.85,0) 2(4.705,-5.5) 3(-4.85,-7.8) 4(4.705,-8.4) 5(4.705,0) 6(4.705,-2.75) MS(-4.85,-4.1)
CAESAR-6014B0247601-001
  rect 0.584x0.297 smd: 1(-0.585,0.275) 2(-0.585,-0.275) 3(0.585,-0.275) 4(0.585,0.275)
CLOONEY-6010B0219002-001
  rect 0.813x0.813 smd: 1(-0.6,0) 2(0.6,0)
COVINI-6012B0760101-001
  round 0.94 hole 0.94 unplated: (-3.9,0) (3.9,0)
  round 0.787 hole 0.508: 1(-2.7,-1.17) 3(-2.3,-2.17) 5(-1.3,-2.17) 7(-0.9,-1.17) 9(-0.5,-0.17) 11(0.5,-0.17) 13(0.9,-1.17) 15(1.3,-2.17) 17(2.3,-2.17) 19(2.7,-1.17)
  rect 0.406x1.88 smd: 2(-2.7,1.65) 4(-2.1,1.65) 6(-1.5,1.65) 8(-0.9,1.65) 10(-0.3,1.65) 12(0.3,1.65) 14(0.9,1.65) 16(1.5,1.65) 18(2.1,1.65) 20(2.7,1.65)
  oval 1.194x2.413 hole 0.711x1.905: G1(-5.6,0.43) G2(5.6,0.43) G3(-5.6,-7.62) G4(5.6,-7.62)
COVINI-6026B0276201-002
  oval 1.6x1.702 hole 1.6x1.702 unplated: (-10,0)
  oval 1.092x1.194 hole 1.092x1.194 unplated: (10.003,0)
  rect 0.356x1.626 smd: 1(9.251,-5.28) 2(9.002,2.281) 3(8.75,-5.28) 4(8.501,2.281) 5(8.252,-5.28) 6(8.001,2.281) 7(7.752,-5.28) 8(7.501,2.281) 9(7.252,-5.28) 10(7,2.281) 11(6.749,-5.28) 12(6.502,2.281) 13(6.251,-5.28) 14(6.002,2.281) 15(5.751,-5.28) 16(5.502,2.281) 17(5.25,-5.28) 18(5.001,2.281) 19(4.75,-5.28) 20(4.501,2.281) 21(4.252,-5.28) 22(4,2.281) 23(3.752,-5.28) 32(1.501,2.281) 33(1.252,-5.28) 34(1.001,2.281) 35(0.752,-5.28) 36(0.5,2.281) 37(0.249,-5.28) 38(0.003,2.281) 39(-0.249,-5.28) 40(-0.5,2.281) 41(-0.749,-5.28) 42(-1.001,2.281) 43(-1.25,-5.28) 44(-1.501,2.281) 45(-1.75,-5.28) 46(-1.999,2.281) 47(-2.25,-5.28) 48(-2.499,2.281) 49(-2.751,-5.28) 50(-3,2.281) 51(-3.251,-5.28) 52(-3.5,2.281) 53(-3.749,-5.28) 54(-4,2.281) 55(-4.249,-5.28) 56(-4.501,2.281) 57(-4.75,-5.28) 58(-4.999,2.281) 59(-5.25,-5.28) 60(-5.499,2.281) 61(-5.751,-5.28) 62(-5.999,2.281) 63(-6.248,-5.28) 64(-6.5,2.281) 65(-6.749,-5.28) 66(-7,2.281) 67(-7.249,-5.28) 68(-7.501,2.281) 69(-7.75,-5.28) 70(-8.001,2.281) 71(-8.25,-5.28) 72(-8.499,2.281) 73(-8.748,-5.28) 74(-8.999,2.281) 75(-9.251,-5.28)
  rect 1.194x2.743 smd: G1(10.35,-4.5) G2(-10.35,-4.5)
COVINI-6026B0363901-001
  oval 1.6x1.702 hole 1.6x1.702 unplated: (-34.4,0)
  oval 1.092x1.194 hole 1.092x1.194 unplated: (34.4,0)
  rect 0.356x2.007 smd: 1(-33.375,-4.227) 2(-33.125,4.227) 3(-32.875,-4.227) 4(-32.625,4.227) 5(-32.375,-4.227) 6(-32.125,4.227) 7(-31.875,-4.227) 8(-31.625,4.227) 9(-31.375,-4.227) 10(-31.125,4.227) 11(-30.875,-4.227) 12(-30.625,4.227) 13(-30.375,-4.227) 14(-30.125,4.227) 15(-29.875,-4.227) 16(-29.625,4.227) 17(-29.375,-4.227) 18(-29.125,4.227) 19(-28.875,-4.227) 20(-28.625,4.227) 21(-28.375,-4.227) 22(-28.125,4.227) 23(-27.875,-4.227) 24(-27.625,4.227) 25(-27.375,-4.227) 26(-27.125,4.227) 27(-26.875,-4.227) 28(-26.625,4.227) 29(-26.375,-4.227) 30(-26.125,4.227) 31(-25.875,-4.227) 32(-25.625,4.227) 33(-25.375,-4.227) 34(-25.125,4.227) 35(-24.875,-4.227) 36(-24.625,4.227) 37(-24.375,-4.227) 38(-24.125,4.227) 39(-23.875,-4.227) 40(-23.625,4.227) 41(-23.375,-4.227) 42(-23.125,4.227) 43(-22.875,-4.227) 44(-22.625,4.227) 45(-22.375,-4.227) 46(-22.125,4.227) 47(-21.875,-4.227) 48(-21.625,4.227) 49(-21.375,-4.227) 50(-21.125,4.227) 51(-20.875,-4.227) 52(-20.625,4.227) 53(-20.375,-4.227) 54(-20.125,4.227) 55(-19.875,-4.227) 56(-19.625,4.227) 57(-19.375,-4.227) 58(-19.125,4.227) 59(-18.875,-4.227) 60(-18.625,4.227) 61(-18.375,-4.227) 62(-18.125,4.227) 63(-17.875,-4.227) 64(-17.625,4.227) 65(-17.375,-4.227) 66(-17.125,4.227) 67(-16.875,-4.227) 68(-16.625,4.227) 69(-16.375,-4.227) 70(-16.125,4.227) 71(-15.875,-4.227) 72(-15.625,4.227) 73(-15.375,-4.227) 74(-15.125,4.227) 75(-14.875,-4.227) 76(-14.625,4.227) 77(-14.375,-4.227) 78(-14.125,4.227) 79(-13.875,-4.227) 80(-13.625,4.227) 81(-13.375,-4.227) 82(-13.125,4.227) 83(-12.875,-4.227) 84(-12.625,4.227) 85(-12.375,-4.227) 86(-12.125,4.227) 87(-11.875,-4.227) 88(-11.625,4.227) 89(-11.375,-4.227) 90(-11.125,4.227) 91(-10.875,-4.227) 92(-10.625,4.227) 93(-10.375,-4.227) 94(-10.125,4.227) 95(-9.875,-4.227) 96(-9.625,4.227) 97(-9.375,-4.227) 98(-9.125,4.227) 99(-8.875,-4.227) 100(-8.625,4.227) 101(-8.375,-4.227) 102(-8.125,4.227) 103(-7.875,-4.227) 104(-7.625,4.227) 105(-7.375,-4.227) 106(-7.125,4.227) 107(-6.875,-4.227) 108(-6.625,4.227) 109(-6.375,-4.227) 110(-6.125,4.227) 111(-5.875,-4.227) 112(-5.625,4.227) 113(-5.375,-4.227) 114(-5.125,4.227) 115(-4.875,-4.227) 116(-4.625,4.227) 117(-4.375,-4.227) 118(-4.125,4.227) 119(-3.875,-4.227) 120(-3.625,4.227) 121(-3.375,-4.227) 122(-3.125,4.227) 123(-2.875,-4.227) 124(-2.625,4.227) 125(-2.375,-4.227) 126(-2.125,4.227) 127(-1.875,-4.227) 128(-1.625,4.227) 129(-1.375,-4.227) 130(-1.125,4.227) 131(-0.875,-4.227) 132(-0.625,4.227) 133(-0.375,-4.227) 134(-0.125,4.227) 135(0.125,-4.227) 136(0.375,4.227) 137(0.625,-4.227) 138(0.875,4.227) 139(1.125,-4.227) 140(1.375,4.227) 141(1.625,-4.227) 142(1.875,4.227) 143(2.125,-4.227) 144(2.375,4.227) 145(4.625,-4.227) 146(4.875,4.227) 147(5.125,-4.227) 148(5.375,4.227) 149(5.625,-4.227) 150(5.875,4.227) 151(6.125,-4.227) 152(6.375,4.227) 153(6.625,-4.227) 154(6.875,4.227) 155(7.125,-4.227) 156(7.375,4.227) 157(7.625,-4.227) 158(7.875,4.227) 159(8.125,-4.227) 160(8.375,4.227) 161(8.625,-4.227) 162(8.875,4.227) 163(9.125,-4.227) 164(9.375,4.227) 165(9.625,-4.227) 166(9.875,4.227) 167(10.125,-4.227) 168(10.375,4.227) 169(10.625,-4.227) 170(10.875,4.227) 171(11.125,-4.227) 172(11.375,4.227) 173(11.625,-4.227) 174(11.875,4.227) 175(12.125,-4.227) 176(12.375,4.227) 177(12.625,-4.227) 178(12.875,4.227) 179(13.125,-4.227) 180(13.375,4.227) 181(13.625,-4.227) 182(13.875,4.227) 183(14.125,-4.227) 184(14.375,4.227) 185(14.625,-4.227) 186(14.875,4.227) 187(15.125,-4.227) 188(15.375,4.227) 189(15.625,-4.227) 190(15.875,4.227) 191(16.125,-4.227) 192(16.375,4.227) 193(16.625,-4.227) 194(16.875,4.227) 195(17.125,-4.227) 196(17.375,4.227) 197(17.625,-4.227) 198(17.875,4.227) 199(18.125,-4.227) 200(18.375,4.227) 201(18.625,-4.227) 202(18.875,4.227) 203(19.125,-4.227) 204(19.375,4.227) 205(19.625,-4.227) 206(19.875,4.227) 207(20.125,-4.227) 208(20.375,4.227) 209(20.625,-4.227) 210(20.875,4.227) 211(21.125,-4.227) 212(21.375,4.227) 213(21.625,-4.227) 214(21.875,4.227) 215(22.125,-4.227) 216(22.375,4.227) 217(22.625,-4.227) 218(22.875,4.227) 219(23.125,-4.227) 220(23.375,4.227) 221(23.625,-4.227) 222(23.875,4.227) 223(24.125,-4.227) 224(24.375,4.227) 225(24.625,-4.227) 226(24.875,4.227) 227(25.125,-4.227) 228(25.375,4.227) 229(25.625,-4.227) 230(25.875,4.227) 231(26.125,-4.227) 232(26.375,4.227) 233(26.625,-4.227) 234(26.875,4.227) 235(27.125,-4.227) 236(27.375,4.227) 237(27.625,-4.227) 238(27.875,4.227) 239(28.125,-4.227) 240(28.375,4.227) 241(28.625,-4.227) 242(28.875,4.227) 243(29.125,-4.227) 244(29.375,4.227) 245(29.625,-4.227) 246(29.875,4.227) 247(30.125,-4.227) 248(30.375,4.227) 249(30.625,-4.227) 250(30.875,4.227) 251(31.125,-4.227) 252(31.375,4.227) 253(31.625,-4.227) 254(31.875,4.227) 255(32.125,-4.227) 256(32.375,4.227) 257(32.625,-4.227) 258(32.875,4.227) 259(33.125,-4.227) 260(33.375,4.227)
  rect 3.505x4.597 smd: G1(-33.8,12) G2(33.8,12)
COVINI-6026B0375701-001
  oval 1.092x1.194 hole 1.092x1.194 unplated: (-34.4,0)
  oval 1.6x1.702 hole 1.6x1.702 unplated: (34.4,0)
  rect 0.356x2.007 smd: 1(33.375,4.227) 2(33.125,-4.227) 3(32.875,4.227) 4(32.625,-4.227) 5(32.375,4.227) 6(32.125,-4.227) 7(31.875,4.227) 8(31.625,-4.227) 9(31.375,4.227) 10(31.125,-4.227) 11(30.875,4.227) 12(30.625,-4.227) 13(30.375,4.227) 14(30.125,-4.227) 15(29.875,4.227) 16(29.625,-4.227) 17(29.375,4.227) 18(29.125,-4.227) 19(28.875,4.227) 20(28.625,-4.227) 21(28.375,4.227) 22(28.125,-4.227) 23(27.875,4.227) 24(27.625,-4.227) 25(27.375,4.227) 26(27.125,-4.227) 27(26.875,4.227) 28(26.625,-4.227) 29(26.375,4.227) 30(26.125,-4.227) 31(25.875,4.227) 32(25.625,-4.227) 33(25.375,4.227) 34(25.125,-4.227) 35(24.875,4.227) 36(24.625,-4.227) 37(24.375,4.227) 38(24.125,-4.227) 39(23.875,4.227) 40(23.625,-4.227) 41(23.375,4.227) 42(23.125,-4.227) 43(22.875,4.227) 44(22.625,-4.227) 45(22.375,4.227) 46(22.125,-4.227) 47(21.875,4.227) 48(21.625,-4.227) 49(21.375,4.227) 50(21.125,-4.227) 51(20.875,4.227) 52(20.625,-4.227) 53(20.375,4.227) 54(20.125,-4.227) 55(19.875,4.227) 56(19.625,-4.227) 57(19.375,4.227) 58(19.125,-4.227) 59(18.875,4.227) 60(18.625,-4.227) 61(18.375,4.227) 62(18.125,-4.227) 63(17.875,4.227) 64(17.625,-4.227) 65(17.375,4.227) 66(17.125,-4.227) 67(16.875,4.227) 68(16.625,-4.227) 69(16.375,4.227) 70(16.125,-4.227) 71(15.875,4.227) 72(15.625,-4.227) 73(15.375,4.227) 74(15.125,-4.227) 75(14.875,4.227) 76(14.625,-4.227) 77(14.375,4.227) 78(14.125,-4.227) 79(13.875,4.227) 80(13.625,-4.227) 81(13.375,4.227) 82(13.125,-4.227) 83(12.875,4.227) 84(12.625,-4.227) 85(12.375,4.227) 86(12.125,-4.227) 87(11.875,4.227) 88(11.625,-4.227) 89(11.375,4.227) 90(11.125,-4.227) 91(10.875,4.227) 92(10.625,-4.227) 93(10.375,4.227) 94(10.125,-4.227) 95(9.875,4.227) 96(9.625,-4.227) 97(9.375,4.227) 98(9.125,-4.227) 99(8.875,4.227) 100(8.625,-4.227) 101(8.375,4.227) 102(8.125,-4.227) 103(7.875,4.227) 104(7.625,-4.227) 105(7.375,4.227) 106(7.125,-4.227) 107(6.875,4.227) 108(6.625,-4.227) 109(6.375,4.227) 110(6.125,-4.227) 111(5.875,4.227) 112(5.625,-4.227) 113(5.375,4.227) 114(5.125,-4.227) 115(4.875,4.227) 116(4.625,-4.227) 117(4.375,4.227) 118(4.125,-4.227) 119(3.875,4.227) 120(3.625,-4.227) 121(3.375,4.227) 122(3.125,-4.227) 123(2.875,4.227) 124(2.625,-4.227) 125(2.375,4.227) 126(2.125,-4.227) 127(1.875,4.227) 128(1.625,-4.227) 129(1.375,4.227) 130(1.125,-4.227) 131(0.875,4.227) 132(0.625,-4.227) 133(0.375,4.227) 134(0.125,-4.227) 135(-0.125,4.227) 136(-0.375,-4.227) 137(-0.625,4.227) 138(-0.875,-4.227) 139(-1.125,4.227) 140(-1.375,-4.227) 141(-1.625,4.227) 142(-1.875,-4.227) 143(-2.125,4.227) 144(-2.375,-4.227) 145(-4.625,4.227) 146(-4.875,-4.227) 147(-5.125,4.227) 148(-5.375,-4.227) 149(-5.625,4.227) 150(-5.875,-4.227) 151(-6.125,4.227) 152(-6.375,-4.227) 153(-6.625,4.227) 154(-6.875,-4.227) 155(-7.125,4.227) 156(-7.375,-4.227) 157(-7.625,4.227) 158(-7.875,-4.227) 159(-8.125,4.227) 160(-8.375,-4.227) 161(-8.625,4.227) 162(-8.875,-4.227) 163(-9.125,4.227) 164(-9.375,-4.227) 165(-9.625,4.227) 166(-9.875,-4.227) 167(-10.125,4.227) 168(-10.375,-4.227) 169(-10.625,4.227) 170(-10.875,-4.227) 171(-11.125,4.227) 172(-11.375,-4.227) 173(-11.625,4.227) 174(-11.875,-4.227) 175(-12.125,4.227) 176(-12.375,-4.227) 177(-12.625,4.227) 178(-12.875,-4.227) 179(-13.125,4.227) 180(-13.375,-4.227) 181(-13.625,4.227) 182(-13.875,-4.227) 183(-14.125,4.227) 184(-14.375,-4.227) 185(-14.625,4.227) 186(-14.875,-4.227) 187(-15.125,4.227) 188(-15.375,-4.227) 189(-15.625,4.227) 190(-15.875,-4.227) 191(-16.125,4.227) 192(-16.375,-4.227) 193(-16.625,4.227) 194(-16.875,-4.227) 195(-17.125,4.227) 196(-17.375,-4.227) 197(-17.625,4.227) 198(-17.875,-4.227) 199(-18.125,4.227) 200(-18.375,-4.227) 201(-18.625,4.227) 202(-18.875,-4.227) 203(-19.125,4.227) 204(-19.375,-4.227) 205(-19.625,4.227) 206(-19.875,-4.227) 207(-20.125,4.227) 208(-20.375,-4.227) 209(-20.625,4.227) 210(-20.875,-4.227) 211(-21.125,4.227) 212(-21.375,-4.227) 213(-21.625,4.227) 214(-21.875,-4.227) 215(-22.125,4.227) 216(-22.375,-4.227) 217(-22.625,4.227) 218(-22.875,-4.227) 219(-23.125,4.227) 220(-23.375,-4.227) 221(-23.625,4.227) 222(-23.875,-4.227) 223(-24.125,4.227) 224(-24.375,-4.227) 225(-24.625,4.227) 226(-24.875,-4.227) 227(-25.125,4.227) 228(-25.375,-4.227) 229(-25.625,4.227) 230(-25.875,-4.227) 231(-26.125,4.227) 232(-26.375,-4.227) 233(-26.625,4.227) 234(-26.875,-4.227) 235(-27.125,4.227) 236(-27.375,-4.227) 237(-27.625,4.227) 238(-27.875,-4.227) 239(-28.125,4.227) 240(-28.375,-4.227) 241(-28.625,4.227) 242(-28.875,-4.227) 243(-29.125,4.227) 244(-29.375,-4.227) 245(-29.625,4.227) 246(-29.875,-4.227) 247(-30.125,4.227) 248(-30.375,-4.227) 249(-30.625,4.227) 250(-30.875,-4.227) 251(-31.125,4.227) 252(-31.375,-4.227) 253(-31.625,4.227) 254(-31.875,-4.227) 255(-32.125,4.227) 256(-32.375,-4.227) 257(-32.625,4.227) 258(-32.875,-4.227) 259(-33.125,4.227) 260(-33.375,-4.227)
  rect 3.505x4.597 smd: G1(33.8,12) G2(-33.8,12)
COVINI-6026B0436901-001
  oval 1.092x1.194 hole 1.092x1.194 unplated: (-10,0)
  oval 1.6x1.702 hole 1.6x1.702 unplated: (10,0)
  rect 0.356x1.626 smd: 1(-9.25,5.275) 2(-9,-2.275) 3(-8.75,5.275) 4(-8.5,-2.275) 5(-8.25,5.275) 6(-8,-2.275) 7(-7.75,5.275) 8(-7.5,-2.275) 9(-7.25,5.275) 10(-7,-2.275) 11(-6.75,5.275) 12(-6.5,-2.275) 13(-6.25,5.275) 14(-6,-2.275) 15(-5.75,5.275) 16(-5.5,-2.275) 17(-5.25,5.275) 18(-5,-2.275) 19(-4.75,5.275) 20(-4.5,-2.275) 21(-4.25,5.275) 22(-4,-2.275) 23(-3.75,5.275) 24(-3.5,-2.275) 25(-3.25,5.275) 26(-3,-2.275) 27(-2.75,5.275) 28(-2.5,-2.275) 29(-2.25,5.275) 30(-2,-2.275) 31(-1.75,5.275) 32(-1.5,-2.275) 33(-1.25,5.275) 34(-1,-2.275) 35(-0.75,5.275) 36(-0.5,-2.275) 37(-0.25,5.275) 38(0,-2.275) 39(0.25,5.275) 40(0.5,-2.275) 41(0.75,5.275) 42(1,-2.275) 43(1.25,5.275) 44(1.5,-2.275) 45(1.75,5.275) 46(2,-2.275) 47(2.25,5.275) 48(2.5,-2.275) 49(2.75,5.275) 50(3,-2.275) 51(3.25,5.275) 52(3.5,-2.275) 53(3.75,5.275) 54(4,-2.275) 55(4.25,5.275) 56(4.5,-2.275) 57(4.75,5.275) 58(5,-2.275) 67(7.25,5.275) 68(7.5,-2.275) 69(7.75,5.275) 70(8,-2.275) 71(8.25,5.275) 72(8.5,-2.275) 73(8.75,5.275) 74(9,-2.275) 75(9.25,5.275)
  rect 1.194x2.743 smd: G1(-10.35,4.5) G2(10.35,4.5)
CPU_INTEL_COF_6C_B_4200X2800
  round 0.406 smd: A3(12.06,-20.314) A37(-12.739,-20.314) B2(12.654,-19.654) B38(-13.314,-19.761) BR1(13.314,19.748) BR38(-13.314,19.722) BT2(12.743,20.314) BT37(-12.722,20.314) C1(13.314,-19.047)
  round 0.381 smd: A4(11.343,-20.314) A34(-11.146,-20.314) A36(-11.958,-20.314) AA13(5.502,-5.766) AA14(4.851,-5.766) AA29(-7.411,-5.899) AA30(-8.061,-5.899) AB29(-7.411,-5.111) AB30(-8.061,-5.111) AC13(5.502,-4.852) AC14(4.851,-4.852) AC29(-7.411,-4.324) AC30(-8.061,-4.324) AD13(5.502,-3.937) AD14(4.851,-3.937) AD29(-7.411,-3.537) AD30(-8.061,-3.537) AE13(5.502,-3.023) AE14(4.851,-3.023) AE29(-7.411,-2.749) AE30(-8.061,-2.749) AF13(5.502,-2.108) AF14(4.851,-2.108) AF29(-7.411,-1.962) AF30(-8.061,-1.962) AG13(5.502,-1.194) AG14(4.851,-1.194) AG29(-7.411,-1.174) AG30(-8.061,-1.174) AH13(5.502,-0.28) AH14(4.851,-0.28) AH29(-7.411,-0.387) AH30(-8.061,-0.387) AJ13(5.502,0.635) AJ14(4.851,0.635) AJ29(-7.411,0.4) AJ30(-8.061,0.4) AK29(-7.411,1.188) AK30(-8.061,1.188) AL13(5.502,1.549) AL14(4.851,1.549) AL29(-7.411,1.975) AL30(-8.061,1.975) AM13(5.502,2.464) AM14(4.851,2.464) AM29(-7.411,2.763) AM30(-8.061,2.763) AN13(5.502,3.378) AN14(4.851,3.378) AN29(-7.411,3.55) AN30(-8.061,3.55) AP13(5.502,4.292) AP14(4.851,4.292) AP29(-7.411,4.337) AP30(-8.061,4.337) AR13(5.502,5.207) AR14(4.851,5.207) AR29(-7.411,5.125) AR30(-8.061,5.125) AT13(5.502,6.121) AT14(4.851,6.121) AT29(-7.411,5.912) AT30(-8.061,5.912) AU13(5.502,7.036) AU14(4.851,7.036) AU29(-7.411,6.7) AU30(-8.061,6.7) AV29(-7.411,7.487) AV30(-8.061,7.487) AW13(5.502,7.95) AW14(4.851,7.95) AW29(-7.411,8.274) AW30(-8.061,8.274) AY13(5.502,8.864) AY14(4.851,8.864) AY29(-7.411,9.062) AY30(-8.061,9.062) B3(11.933,-19.616) B37(-12.595,-19.612) BA13(5.502,9.779) BA14(4.851,9.779) BA29(-7.411,9.849) BA30(-8.061,9.849) BB13(5.502,10.693) BB14(4.851,10.693) BB29(-7.411,10.637) BB30(-8.061,10.637) BC13(5.502,11.608) BC14(4.851,11.608) BC29(-7.411,11.424) BC30(-8.061,11.424) BD13(5.502,12.522) BD14(4.851,12.522) BD29(-7.411,12.211) BD30(-8.061,12.211) BE29(-7.411,12.999) BE30(-8.061,12.999) BF13(5.502,13.436) BF14(4.851,13.436) BF29(-7.411,13.786) BF30(-8.061,13.786) BG13(5.502,14.351) BG14(4.851,14.351) BG29(-7.411,14.574) BG30(-8.061,14.574) BH13(5.502,15.265) BH14(4.851,15.227) BH29(-7.411,15.234) BH30(-8.061,15.361) BJ13(5.144,15.812) BJ14(4.463,15.762) BJ15(3.713,15.762) BJ16(2.926,15.762) BJ17(2.139,15.762) BJ18(1.351,15.762) BJ19(0.564,15.762) BJ20(-0.224,15.762) BJ21(-1.011,15.762) BJ22(-1.798,15.762) BJ23(-2.586,15.762) BJ24(-3.373,15.762) BJ25(-4.161,15.762) BJ26(-4.948,15.762) BJ27(-5.735,15.762) BJ28(-6.523,15.762) BJ29(-7.183,15.844) BJ30(-8.039,16.015) BK29(-7.518,16.421) BN1(13.314,18.3) BN38(-13.314,18.285) BP1(13.314,19.024) BP38(-13.314,18.996) BR2(12.596,19.619) BR37(-12.59,19.613) BT3(12.019,20.314) BT4(11.295,20.314) BT35(-11.184,20.314) BT36(-11.996,20.314) C2(12.616,-18.953) C38(-13.314,-18.98) D1(13.314,-18.323) D38(-13.314,-18.218) H13(5.059,-15.712) H14(4.272,-15.712) H15(3.484,-15.712) H16(2.697,-15.712) H17(1.91,-15.712) H18(1.122,-15.712) H19(0.335,-15.712) H20(-0.453,-15.712) H21(-1.24,-15.712) H22(-2.027,-15.712) H23(-2.815,-15.712) H24(-3.602,-15.712) H25(-4.39,-15.712) H26(-5.177,-15.712) H27(-5.964,-15.712) H28(-6.752,-15.712) H29(-7.539,-15.762) J14(4.272,-15.061) J15(3.484,-15.061) J16(2.697,-15.061) J17(1.91,-15.061) J18(1.122,-15.061) J19(0.335,-15.061) J20(-0.453,-15.061) J21(-1.24,-15.061) J22(-2.027,-15.061) J23(-2.815,-15.061) J24(-3.602,-15.061) J25(-4.39,-15.061) J26(-5.177,-15.061) J27(-5.964,-15.061) J28(-6.752,-15.061) J30(-7.747,-15.146) K13(5.436,-15.138) K14(4.851,-14.656) K29(-7.411,-14.56) K30(-8.061,-14.56) L13(5.502,-13.996) L14(4.851,-13.996) L29(-7.411,-13.773) L30(-8.061,-13.773) M13(5.502,-13.081) M14(4.851,-13.081) M29(-7.411,-12.985) M30(-8.061,-12.985) N13(5.502,-12.167) N14(4.851,-12.167) N29(-7.411,-12.198) N30(-8.061,-12.198) P13(5.502,-11.252) P14(4.851,-11.252) P29(-7.411,-11.411) P30(-8.061,-11.411) R13(5.502,-10.338) R14(4.851,-10.338) R29(-7.411,-10.623) R30(-8.061,-10.623) T13(5.502,-9.424) T14(4.851,-9.424) T29(-7.411,-9.836) T30(-8.061,-9.836) U29(-7.411,-9.048) U30(-8.061,-9.048) V13(5.502,-8.509) V14(4.851,-8.509) V29(-7.411,-8.261) V30(-8.061,-8.261) W13(5.502,-7.595) W14(4.851,-7.595) W29(-7.411,-7.474) W30(-8.061,-7.474) Y13(5.502,-6.68) Y14(4.851,-6.68) Y29(-7.411,-6.686) Y30(-8.061,-6.686)
  round 0.356 smd: A5(10.543,-20.314) A33(-10.345,-20.314) B4(11.283,-19.344) B36(-11.884,-19.613) BM1(13.314,17.5) BM38(-13.314,17.573) BP2(12.486,18.965) BP37(-12.374,18.943) BR3(11.927,19.664) BR36(-11.879,19.657) BT5(10.495,20.314) BT34(-10.384,20.314) C37(-12.594,-18.912) D3(12.081,-18.492) E1(13.314,-17.536) E38(-13.314,-17.418)
  round 0.33 smd: A6(9.768,-20.314) A32(-9.558,-20.314) AA11(6.802,-5.766) AA12(6.152,-5.766) AC11(6.802,-4.852) AC12(6.152,-4.852) AD11(6.802,-3.937) AD12(6.152,-3.937) AE11(6.802,-3.023) AE12(6.152,-3.023) AF11(6.802,-2.108) AF12(6.152,-2.108) AG11(6.802,-1.194) AG12(6.152,-1.194) AH11(6.802,-0.28) AH12(6.152,-0.28) AJ11(6.802,0.635) AJ12(6.152,0.635) AL11(6.802,1.549) AL12(6.152,1.549) AM11(6.802,2.464) AM12(6.152,2.464) AN11(6.802,3.378) AN12(6.152,3.378) AP11(6.802,4.292) AP12(6.152,4.292) AR11(6.802,5.207) AR12(6.152,5.207) AT11(6.802,6.121) AT12(6.152,6.121) AU11(6.802,7.036) AU12(6.152,7.036) AW11(6.802,7.95) AW12(6.152,7.95) AY11(6.802,8.864) AY12(6.152,8.864) B5(10.571,-19.664) B34(-11.129,-19.645) BA11(6.802,9.779) BA12(6.152,9.779) BB11(6.802,10.693) BB12(6.152,10.693) BC11(6.802,11.608) BC12(6.152,11.608) BD11(6.802,12.522) BD12(6.152,12.522) BF11(6.802,13.436) BF12(6.152,13.436) BG11(6.802,14.351) BG12(6.152,14.351) BH11(6.802,15.265) BH12(6.152,15.265) BJ11(6.802,16.18) BJ12(6.032,16.091) BK1(13.314,16.722) BK13(5.415,16.413) BK14(4.501,16.413) BK15(3.713,16.413) BK16(2.926,16.413) BK17(2.139,16.413) BK18(1.351,16.413) BK19(0.564,16.413) BK20(-0.224,16.413) BK21(-1.011,16.413) BK22(-1.798,16.413) BK23(-2.586,16.413) BK24(-3.373,16.413) BK25(-4.161,16.413) BK26(-4.948,16.413) BK27(-5.735,16.413) BK28(-6.523,16.413) BL38(-13.314,16.862) BN2(12.664,18.328) BN37(-12.651,18.35) BR5(11.148,19.67) BR35(-11.222,19.664) BT6(9.721,20.314) BT32(-9.609,20.314) D37(-12.289,-18.329) E2(12.664,-17.84) G1(13.314,-16.733) G38(-13.314,-16.643) K11(6.802,-14.834) K12(6.152,-14.834) L11(6.802,-13.996) L12(6.152,-13.996) M11(6.802,-13.081) M12(6.152,-13.081) N11(6.802,-12.167) N12(6.152,-12.167) P11(6.802,-11.252) P12(6.152,-11.252) R11(6.802,-10.338) R12(6.152,-10.338) T11(6.802,-9.424) T12(6.152,-9.424) V11(6.802,-8.509) V12(6.152,-8.509) W11(6.802,-7.595) W12(6.152,-7.595) Y11(6.802,-6.68) Y12(6.152,-6.68)
  round 0.305 smd: A8(8.996,-20.314) A9(8.209,-20.314) A10(7.421,-20.314) A11(6.634,-20.314) A12(5.847,-20.314) A13(5.059,-20.314) A14(4.272,-20.314) A15(3.484,-20.314) A16(2.697,-20.314) A17(1.91,-20.314) A18(1.122,-20.314) A19(0.335,-20.314) A20(-0.453,-20.314) A21(-1.24,-20.314) A22(-2.027,-20.314) A23(-2.815,-20.314) A24(-3.602,-20.314) A25(-4.39,-20.314) A26(-5.177,-20.314) A27(-5.964,-20.314) A28(-6.752,-20.314) A29(-7.539,-20.314) A30(-8.53,-20.314) AA1(13.314,-6.295) AA2(12.664,-6.295) AA3(12.014,-6.295) AA4(11.363,-6.295) AA5(10.713,-6.295) AA6(10.063,-6.346) AA7(9.403,-5.766) AA8(8.753,-5.766) AA9(8.103,-5.766) AA10(7.452,-5.766) AA31(-8.762,-5.899) AA32(-9.413,-5.899) AA33(-10.063,-5.899) AA34(-10.713,-5.899) AA35(-11.363,-5.899) AA36(-12.014,-5.899) AA37(-12.664,-5.899) AA38(-13.314,-5.899) AB1(13.314,-5.559) AB2(12.664,-5.559) AB3(12.014,-5.559) AB4(11.363,-5.559) AB5(10.713,-5.559) AB6(10.063,-5.508) AB31(-8.762,-5.111) AB32(-9.413,-5.111) AB33(-10.063,-5.111) AB34(-10.713,-5.111) AB35(-11.363,-5.111) AB36(-12.014,-5.111) AB37(-12.664,-5.111) AB38(-13.314,-5.111) AC1(13.314,-4.67) AC2(12.664,-4.67) AC3(12.014,-4.67) AC4(11.363,-4.67) AC5(10.713,-4.67) AC6(10.063,-4.67) AC7(9.403,-4.852) AC8(8.753,-4.852) AC9(8.103,-4.852) AC10(7.452,-4.852) AC31(-8.762,-4.324) AC32(-9.413,-4.324) AC33(-10.063,-4.324) AC34(-10.713,-4.324) AC35(-11.363,-4.324) AC36(-12.014,-4.324) AC37(-12.664,-4.324) AC38(-13.314,-4.324) AD1(13.314,-3.781) AD2(12.664,-3.781) AD3(12.014,-3.781) AD4(11.363,-3.781) AD5(10.713,-3.781) AD6(10.063,-3.831) AD7(9.403,-3.937) AD8(8.753,-3.937) AD9(8.103,-3.937) AD10(7.452,-3.937) AD31(-8.762,-3.537) AD32(-9.413,-3.537) AD33(-10.063,-3.537) AD34(-10.713,-3.537) AD35(-11.363,-3.537) AD36(-12.014,-3.537) AD37(-12.664,-3.537) AD38(-13.314,-3.537) AE1(13.314,-3.044) AE2(12.664,-3.044) AE3(12.014,-3.044) AE4(11.363,-3.044) AE5(10.713,-3.044) AE6(10.063,-2.993) AE7(9.403,-3.023) AE8(8.753,-3.023) AE9(8.103,-3.023) AE10(7.452,-3.023) AE31(-8.762,-2.749) AE32(-9.413,-2.749) AE33(-10.063,-2.749) AE34(-10.713,-2.749) AE35(-11.363,-2.749) AE36(-12.014,-2.749) AE37(-12.664,-2.749) AE38(-13.314,-2.749) AF1(13.314,-2.155) AF2(12.664,-2.155) AF3(12.014,-2.155) AF4(11.363,-2.155) AF5(10.713,-2.155) AF6(10.063,-2.155) AF7(9.403,-2.108) AF8(8.753,-2.108) AF9(8.103,-2.108) AF10(7.452,-2.108) AF31(-8.762,-1.962) AF32(-9.413,-1.962) AF33(-10.063,-1.962) AF34(-10.713,-1.962) AF35(-11.363,-1.962) AF36(-12.014,-1.962) AF37(-12.664,-1.962) AF38(-13.314,-1.962) AG1(13.314,-1.266) AG2(12.664,-1.266) AG3(12.014,-1.266) AG4(11.363,-1.266) AG5(10.713,-1.266) AG6(10.063,-1.317) AG7(9.403,-1.194) AG8(8.753,-1.194) AG9(8.103,-1.194) AG10(7.452,-1.194) AG31(-8.762,-1.174) AG32(-9.413,-1.174) AG33(-10.063,-1.174) AG34(-10.713,-1.174) AG35(-11.363,-1.174) AG36(-12.014,-1.174) AG37(-12.664,-1.174) AG38(-13.314,-1.174) AH1(13.314,-0.529) AH2(12.664,-0.529) AH3(12.014,-0.529) AH4(11.363,-0.529) AH5(10.713,-0.529) AH6(10.063,-0.479) AH7(9.403,-0.28) AH8(8.753,-0.28) AH9(8.103,-0.28) AH10(7.452,-0.28) AH31(-8.762,-0.387) AH32(-9.413,-0.387) AH33(-10.063,-0.387) AH34(-10.713,-0.387) AH35(-11.363,-0.387) AH36(-12.014,-0.387) AH37(-12.664,-0.387) AH38(-13.314,-0.387) AJ1(13.314,0.36) AJ2(12.664,0.36) AJ3(12.014,0.36) AJ4(11.363,0.36) AJ5(10.713,0.36) AJ6(10.063,0.36) AJ7(9.403,0.635) AJ8(8.753,0.635) AJ9(8.103,0.635) AJ10(7.452,0.635) AJ31(-8.762,0.4) AJ32(-9.413,0.4) AJ33(-10.063,0.4) AJ34(-10.713,0.4) AJ35(-11.363,0.4) AJ36(-12.014,0.4) AJ37(-12.664,0.4) AJ38(-13.314,0.4) AK1(13.314,1.249) AK2(12.664,1.249) AK3(12.014,1.249) AK4(11.363,1.249) AK5(10.713,1.249) AK6(10.063,1.198) AK31(-8.762,1.188) AK32(-9.413,1.188) AK33(-10.063,1.188) AK34(-10.713,1.188) AK35(-11.363,1.188) AK36(-12.014,1.188) AK37(-12.664,1.188) AK38(-13.314,1.188) AL1(13.314,1.985) AL2(12.664,1.985) AL3(12.014,1.985) AL4(11.363,1.985) AL5(10.713,1.985) AL6(10.063,2.036) AL7(9.403,1.549) AL8(8.753,1.549) AL9(8.103,1.549) AL10(7.452,1.549) AL31(-8.762,1.975) AL32(-9.413,1.975) AL33(-10.063,1.975) AL34(-10.713,1.975) AL35(-11.363,1.975) AL36(-12.014,1.975) AL37(-12.664,1.975) AL38(-13.314,1.975) AM1(13.314,2.874) AM2(12.664,2.874) AM3(12.014,2.874) AM4(11.363,2.874) AM5(10.713,2.874) AM6(10.063,2.874) AM7(9.403,2.464) AM8(8.753,2.464) AM9(8.103,2.464) AM10(7.452,2.464) AM31(-8.762,2.763) AM32(-9.413,2.763) AM33(-10.063,2.763) AM34(-10.713,2.763) AM35(-11.363,2.763) AM36(-12.014,2.763) AM37(-12.664,2.763) AM38(-13.314,2.763) AN1(13.314,3.763) AN2(12.664,3.763) AN3(12.014,3.763) AN4(11.363,3.763) AN5(10.713,3.763) AN6(10.063,3.712) AN7(9.403,3.378) AN8(8.753,3.378) AN9(8.103,3.378) AN10(7.452,3.378) AN31(-8.762,3.55) AN32(-9.413,3.55) AN33(-10.063,3.55) AN34(-10.713,3.55) AN35(-11.363,3.55) AN36(-12.014,3.55) AN37(-12.664,3.55) AN38(-13.314,3.55) AP1(13.314,4.5) AP2(12.664,4.5) AP3(12.014,4.5) AP4(11.363,4.5) AP5(10.713,4.5) AP6(10.063,4.551) AP7(9.403,4.292) AP8(8.753,4.292) AP9(8.103,4.292) AP10(7.452,4.292) AP31(-8.762,4.337) AP32(-9.413,4.337) AP33(-10.063,4.337) AP34(-10.713,4.337) AP35(-11.363,4.337) AP36(-12.014,4.337) AP37(-12.664,4.337) AP38(-13.314,4.337) AR1(13.314,5.389) AR2(12.664,5.389) AR3(12.014,5.389) AR4(11.363,5.389) AR5(10.713,5.389) AR6(10.063,5.389) AR7(9.403,5.207) AR8(8.753,5.207) AR9(8.103,5.207) AR10(7.452,5.207) AR31(-8.762,5.125) AR32(-9.413,5.125) AR33(-10.063,5.125) AR34(-10.713,5.125) AR35(-11.363,5.125) AR36(-12.014,5.125) AR37(-12.664,5.125) AR38(-13.314,5.125) AT1(13.314,6.278) AT2(12.664,6.278) AT3(12.014,6.278) AT4(11.363,6.278) AT5(10.713,6.278) AT6(10.063,6.227) AT7(9.403,6.121) AT8(8.753,6.121) AT9(8.103,6.121) AT10(7.452,6.121) AT31(-8.762,5.912) AT32(-9.413,5.912) AT33(-10.063,5.912) AT34(-10.713,5.912) AT35(-11.363,5.912) AT36(-12.014,5.912) AT37(-12.664,5.912) AT38(-13.314,5.912) AU1(13.314,7.014) AU2(12.664,7.014) AU3(12.014,7.014) AU4(11.363,7.014) AU5(10.713,7.014) AU6(10.063,7.065) AU7(9.403,7.036) AU8(8.753,7.036) AU9(8.103,7.036) AU10(7.452,7.036) AU31(-8.762,6.7) AU32(-9.413,6.7) AU33(-10.063,6.7) AU34(-10.713,6.7) AU35(-11.363,6.7) AU36(-12.014,6.7) AU37(-12.664,6.7) AU38(-13.314,6.7) AV31(-8.762,7.487) AV32(-9.413,7.487) AV33(-10.063,7.487) AV34(-10.713,7.487) AV35(-11.363,7.487) AV36(-12.014,7.487) AV37(-12.664,7.487) AV38(-13.314,7.487) AW1(13.314,7.903) AW2(12.664,7.903) AW3(12.014,7.903) AW4(11.363,7.903) AW5(10.713,7.903) AW6(10.063,7.903) AW7(9.403,7.95) AW8(8.753,7.95) AW9(8.103,7.95) AW10(7.452,7.95) AW31(-8.762,8.274) AW32(-9.413,8.274) AW33(-10.063,8.274) AW34(-10.713,8.274) AW35(-11.363,8.274) AW36(-12.014,8.274) AW37(-12.664,8.274) AW38(-13.314,8.274) AY1(13.314,8.792) AY2(12.664,8.792) AY3(12.014,8.792) AY4(11.363,8.792) AY5(10.713,8.792) AY6(10.063,8.742) AY7(9.403,8.864) AY8(8.753,8.864) AY9(8.103,8.864) AY10(7.452,8.864) AY31(-8.762,9.062) AY32(-9.413,9.062) AY33(-10.063,9.062) AY34(-10.713,9.062) AY35(-11.363,9.062) AY36(-12.014,9.062) AY37(-12.664,9.062) AY38(-13.314,9.062) B6(9.784,-19.664) B8(8.996,-19.664) B9(8.209,-19.664) B10(7.421,-19.664) B11(6.634,-19.664) B12(5.847,-19.664) B13(5.059,-19.664) B14(4.272,-19.664) B15(3.484,-19.664) B16(2.697,-19.664) B17(1.91,-19.664) B18(1.122,-19.664) B19(0.335,-19.664) B20(-0.453,-19.664) B21(-1.24,-19.664) B22(-2.027,-19.664) B23(-2.815,-19.664) B24(-3.602,-19.664) B25(-4.39,-19.664) B26(-5.177,-19.664) B27(-5.964,-19.664) B28(-6.752,-19.664) B29(-7.539,-19.664) B30(-8.327,-19.664) B31(-9.114,-19.664) B33(-9.901,-19.664) BA1(13.314,9.529) BA2(12.664,9.529) BA3(12.014,9.529) BA4(11.363,9.529) BA5(10.713,9.529) BA6(10.063,9.58) BA7(9.403,9.779) BA8(8.753,9.779) BA9(8.103,9.779) BA10(7.452,9.779) BA31(-8.762,9.849) BA32(-9.413,9.849) BA33(-10.063,9.849) BA34(-10.713,9.849) BA35(-11.363,9.849) BA36(-12.014,9.849) BA37(-12.664,9.849) BA38(-13.314,9.849) BB1(13.314,10.418) BB2(12.664,10.418) BB3(12.014,10.418) BB4(11.363,10.418) BB5(10.713,10.418) BB6(10.063,10.418) BB7(9.403,10.693) BB8(8.753,10.693) BB9(8.103,10.693) BB10(7.452,10.693) BB31(-8.762,10.637) BB32(-9.413,10.637) BB33(-10.063,10.637) BB34(-10.713,10.637) BB35(-11.363,10.637) BB36(-12.014,10.637) BB37(-12.664,10.637) BB38(-13.314,10.637) BC1(13.314,11.307) BC2(12.664,11.307) BC3(12.014,11.307) BC4(11.363,11.307) BC5(10.713,11.307) BC6(10.063,11.256) BC7(9.403,11.608) BC8(8.753,11.608) BC9(8.103,11.608) BC10(7.452,11.608) BC31(-8.762,11.424) BC32(-9.413,11.424) BC33(-10.063,11.424) BC34(-10.713,11.424) BC35(-11.363,11.424) BC36(-12.014,11.424) BC37(-12.664,11.424) BC38(-13.314,11.424) BD1(13.314,12.044) BD2(12.664,12.044) BD3(12.014,12.044) BD4(11.363,12.044) BD5(10.713,12.044) BD6(10.063,12.094) BD7(9.403,12.522) BD8(8.753,12.522) BD9(8.103,12.522) BD10(7.452,12.522) BD31(-8.762,12.211) BD32(-9.413,12.211) BD33(-10.063,12.211) BD34(-10.713,12.211) BD35(-11.363,12.211) BD36(-12.014,12.211) BD37(-12.664,12.211) BD38(-13.314,12.211) BE1(13.314,12.933) BE2(12.664,12.933) BE3(12.014,12.933) BE4(11.363,12.933) BE5(10.713,12.933) BE6(10.063,12.933) BE31(-8.762,12.999) BE32(-9.413,12.999) BE33(-10.063,12.999) BE34(-10.713,12.999) BE35(-11.363,12.999) BE36(-12.014,12.999) BE37(-12.664,12.999) BE38(-13.314,12.999) BF1(13.314,13.822) BF2(12.664,13.822) BF3(12.014,13.822) BF4(11.363,13.822) BF5(10.713,13.822) BF6(10.063,13.771) BF7(9.403,13.436) BF8(8.753,13.436) BF9(8.103,13.436) BF10(7.452,13.436) BF31(-8.762,13.786) BF32(-9.413,13.786) BF33(-10.063,13.786) BF34(-10.713,13.786) BF35(-11.363,13.786) BF36(-12.014,13.786) BF37(-12.664,13.786) BF38(-13.314,13.786) BG1(13.314,14.558) BG2(12.664,14.558) BG3(12.014,14.558) BG4(11.363,14.558) BG5(10.713,14.558) BG6(10.063,14.609) BG7(9.403,14.351) BG8(8.753,14.351) BG9(8.103,14.351) BG10(7.452,14.351) BG31(-8.762,14.574) BG32(-9.413,14.574) BG33(-10.063,14.574) BG34(-10.713,14.574) BG35(-11.363,14.574) BG36(-12.014,14.574) BG37(-12.664,14.574) BG38(-13.314,14.574) BH1(13.314,15.701) BH2(12.664,15.447) BH3(12.014,15.447) BH4(11.363,15.447) BH5(10.713,15.447) BH6(10.063,15.447) BH7(9.403,15.265) BH8(8.753,15.265) BH9(8.103,15.265) BH10(7.452,15.265) BH31(-8.762,15.361) BH32(-9.413,15.361) BH33(-10.063,15.361) BH34(-10.713,15.361) BH35(-11.363,15.361) BH36(-12.014,15.361) BH37(-12.664,15.361) BH38(-13.314,15.361) BJ7(9.403,16.18) BJ8(8.753,16.18) BJ9(8.103,16.18) BJ10(7.452,16.18) BJ31(-8.762,16.148) BJ32(-9.413,16.148) BJ33(-10.063,16.148) BJ34(-10.713,16.148) BJ35(-11.363,16.148) BJ36(-12.014,16.148) BJ37(-12.664,16.148) BJ38(-13.314,16.098) BK2(12.664,16.285) BK3(12.014,16.285) BK4(11.363,16.285) BK5(10.713,16.285) BK6(10.063,16.285) BL2(12.664,17.124) BL3(12.014,17.073) BL4(11.363,17.073) BL5(10.713,17.073) BL6(10.063,17.124) BL7(9.327,17.069) BL8(8.438,17.063) BL9(7.65,17.063) BL11(6.863,17.063) BL12(6.076,17.063) BL13(5.288,17.063) BL14(4.501,17.063) BL15(3.713,17.063) BL16(2.926,17.063) BL17(2.139,17.063) BL18(1.351,17.063) BL19(0.564,17.063) BL20(-0.224,17.063) BL21(-1.011,17.063) BL22(-1.798,17.063) BL23(-2.586,17.063) BL24(-3.373,17.063) BL25(-4.161,17.063) BL26(-4.948,17.063) BL27(-5.735,17.063) BL28(-6.523,17.063) BL29(-7.31,17.063) BL30(-8.112,16.936) BL31(-8.762,16.936) BL32(-9.413,16.936) BL33(-10.063,16.936) BL34(-10.713,16.936) BL35(-11.363,16.936) BL36(-12.014,16.936) BL37(-12.664,16.936) BM2(12.352,17.738) BM3(11.701,17.815) BM5(10.789,17.815) BM6(10.145,17.916) BM7(9.225,17.713) BM8(8.438,17.713) BM9(7.65,17.713) BM11(6.863,17.713) BM12(6.076,17.713) BM13(5.288,17.713) BM14(4.501,17.713) BM15(3.713,17.713) BM16(2.926,17.713) BM17(2.139,17.713) BM18(1.351,17.713) BM19(0.564,17.713) BM20(-0.224,17.713) BM21(-1.011,17.713) BM22(-1.798,17.713) BM23(-2.586,17.713) BM24(-3.373,17.713) BM25(-4.161,17.713) BM26(-4.948,17.713) BM27(-5.735,17.713) BM28(-6.523,17.713) BM29(-7.31,17.713) BM30(-8.098,17.713) BM31(-8.885,17.713) BM33(-9.672,17.713) BM34(-10.46,17.713) BM35(-11.247,17.713) BM36(-12.014,17.672) BM37(-12.664,17.672) BN3(12.014,18.387) BN4(11.209,18.315) BN5(10.566,18.479) BN7(9.225,18.363) BN8(8.438,18.363) BN9(7.65,18.363) BN11(6.863,18.363) BN12(6.076,18.363) BN13(5.288,18.363) BN14(4.501,18.363) BN15(3.713,18.363) BN16(2.926,18.363) BN17(2.139,18.363) BN18(1.351,18.363) BN19(0.564,18.363) BN20(-0.224,18.363) BN21(-1.011,18.363) BN22(-1.798,18.363) BN23(-2.586,18.363) BN24(-3.373,18.363) BN25(-4.161,18.363) BN26(-4.948,18.363) BN27(-5.735,18.363) BN28(-6.523,18.363) BN29(-7.31,18.363) BN30(-8.098,18.363) BN31(-8.885,18.363) BN33(-9.672,18.363) BN34(-10.46,18.363) BN35(-11.248,18.363) BN36(-11.999,18.324) BP3(11.831,19.02) BP5(10.94,19.037) BP6(10.02,18.974) BP7(9.225,19.014) BP8(8.438,19.014) BP9(7.65,19.014) BP11(6.863,19.014) BP12(6.076,19.014) BP13(5.288,19.014) BP14(4.501,19.014) BP15(3.713,19.014) BP16(2.926,19.014) BP17(2.139,19.014) BP18(1.351,19.014) BP19(0.564,19.014) BP20(-0.224,19.014) BP21(-1.011,19.014) BP22(-1.798,19.014) BP23(-2.586,19.014) BP24(-3.373,19.014) BP25(-4.161,19.014) BP26(-4.948,19.014) BP27(-5.735,19.014) BP28(-6.523,19.014) BP29(-7.31,19.014) BP30(-8.098,19.014) BP31(-8.885,19.014) BP33(-9.672,19.014) BP34(-10.46,19.014) BP35(-11.247,19.014) BR6(10.122,19.647) BR7(9.225,19.664) BR8(8.438,19.664) BR9(7.65,19.664) BR11(6.863,19.664) BR12(6.076,19.664) BR13(5.288,19.664) BR14(4.501,19.664) BR15(3.713,19.664) BR16(2.926,19.664) BR17(2.139,19.664) BR18(1.351,19.664) BR19(0.564,19.664) BR20(-0.224,19.664) BR21(-1.011,19.664) BR22(-1.798,19.664) BR23(-2.586,19.664) BR24(-3.373,19.664) BR25(-4.161,19.664) BR26(-4.948,19.664) BR27(-5.735,19.664) BR28(-6.523,19.664) BR29(-7.31,19.664) BR30(-8.098,19.664) BR31(-8.885,19.664) BR33(-9.672,19.664) BR34(-10.46,19.664) BT8(8.666,20.314) BT9(7.65,20.314) BT11(6.863,20.314) BT12(6.076,20.314) BT13(5.288,20.314) BT14(4.501,20.314) BT15(3.713,20.314) BT16(2.926,20.314) BT17(2.139,20.314) BT18(1.351,20.314) BT19(0.564,20.314) BT20(-0.224,20.314) BT21(-1.011,20.314) BT22(-1.798,20.314) BT23(-2.586,20.314) BT24(-3.373,20.314) BT25(-4.161,20.314) BT26(-4.948,20.314) BT27(-5.735,20.314) BT28(-6.523,20.314) BT29(-7.31,20.314) BT30(-8.098,20.314) BT31(-8.86,20.314) C5(10.571,-19.014) C6(9.784,-19.014) C8(8.996,-19.014) C9(8.209,-19.014) C10(7.421,-19.014) C11(6.634,-19.014) C12(5.847,-19.014) C13(5.059,-19.014) C14(4.272,-19.014) C15(3.484,-19.014) C16(2.697,-19.014) C17(1.91,-19.014) C18(1.122,-19.014) C19(0.335,-19.014) C20(-0.453,-19.014) C21(-1.24,-19.014) C22(-2.027,-19.014) C23(-2.815,-19.014) C24(-3.602,-19.014) C25(-4.39,-19.014) C26(-5.177,-19.014) C27(-5.964,-19.014) C28(-6.752,-19.014) C29(-7.539,-19.014) C30(-8.327,-19.014) C31(-9.114,-19.014) C33(-9.901,-19.014) C34(-10.697,-19.025) C36(-11.831,-18.926) D4(11.42,-18.66) D5(10.571,-18.363) D6(9.784,-18.363) D8(8.996,-18.363) D9(8.209,-18.363) D10(7.421,-18.363) D11(6.634,-18.363) D12(5.847,-18.363) D13(5.059,-18.363) D14(4.272,-18.363) D15(3.484,-18.363) D16(2.697,-18.363) D17(1.91,-18.363) D18(1.122,-18.363) D19(0.335,-18.363) D20(-0.453,-18.363) D21(-1.24,-18.363) D22(-2.027,-18.363) D23(-2.815,-18.363) D24(-3.602,-18.363) D25(-4.39,-18.363) D26(-5.177,-18.363) D27(-5.964,-18.363) D28(-6.752,-18.363) D29(-7.539,-18.363) D30(-8.327,-18.363) D31(-9.114,-18.363) D33(-9.901,-18.363) D34(-10.689,-18.363) D35(-11.341,-18.453) E3(12.014,-17.84) E4(11.363,-17.739) E5(10.571,-17.713) E6(9.784,-17.713) E8(8.996,-17.713) E9(8.209,-17.713) E10(7.421,-17.713) E11(6.634,-17.713) E12(5.847,-17.713) E13(5.059,-17.713) E14(4.272,-17.713) E15(3.484,-17.713) E16(2.697,-17.713) E17(1.91,-17.713) E18(1.122,-17.713) E19(0.335,-17.713) E20(-0.453,-17.713) E21(-1.24,-17.713) E22(-2.027,-17.713) E23(-2.815,-17.713) E24(-3.602,-17.713) E25(-4.39,-17.713) E26(-5.177,-17.713) E27(-5.964,-17.713) E28(-6.752,-17.713) E29(-7.539,-17.713) E30(-8.327,-17.713) E31(-9.114,-17.713) E33(-9.901,-17.713) E34(-10.689,-17.713) E35(-11.363,-17.71) E36(-12.014,-17.71) E37(-12.664,-17.71) F2(12.664,-17.155) F3(12.014,-17.155) F4(11.363,-17.053) F5(10.571,-17.041) F6(9.784,-17.041) F8(8.996,-17.063) F9(8.209,-17.063) F10(7.421,-17.063) F11(6.634,-17.063) F12(5.847,-17.063) F13(5.059,-17.063) F14(4.272,-17.063) F15(3.484,-17.063) F16(2.697,-17.063) F17(1.91,-17.063) F18(1.122,-17.063) F19(0.335,-17.063) F20(-0.453,-17.063) F21(-1.24,-17.063) F22(-2.027,-17.063) F23(-2.815,-17.063) F24(-3.602,-17.063) F25(-4.39,-17.063) F26(-5.177,-17.063) F27(-5.964,-17.063) F28(-6.752,-17.063) F29(-7.539,-17.063) F30(-8.327,-17.063) F31(-9.114,-17.063) F33(-9.901,-17.063) F34(-10.713,-16.922) F35(-11.363,-16.922) F36(-12.014,-16.922) F37(-12.664,-16.922) G2(12.664,-16.367) G3(12.014,-16.367) G4(11.363,-16.367) G5(10.713,-16.367) G6(10.063,-16.367) G8(8.996,-16.413) G9(8.209,-16.413) G10(7.421,-16.413) G11(6.634,-16.413) G12(5.847,-16.413) G13(5.059,-16.413) G14(4.272,-16.413) G15(3.484,-16.413) G16(2.697,-16.413) G17(1.91,-16.413) G18(1.122,-16.413) G19(0.335,-16.413) G20(-0.453,-16.413) G21(-1.24,-16.413) G22(-2.027,-16.413) G23(-2.815,-16.413) G24(-3.602,-16.413) G25(-4.39,-16.413) G26(-5.177,-16.413) G27(-5.964,-16.413) G28(-6.752,-16.413) G29(-7.539,-16.413) G30(-8.327,-16.413) H1(13.314,-15.871) H11(6.634,-15.762) H12(5.847,-15.762) H30(-8.289,-15.762) H32(-9.413,-16.135) H33(-10.063,-16.135) H34(-10.713,-16.135) H35(-11.363,-16.135) H36(-12.014,-16.135) H37(-12.664,-16.135) J2(12.664,-15.566) J3(12.014,-15.566) J4(11.363,-15.566) J5(10.713,-15.566) J6(10.063,-15.566) J7(9.421,-15.695) J8(8.773,-15.598) J9(8.103,-15.621) J10(7.421,-15.686) J31(-8.762,-15.31) J32(-9.413,-15.348) J33(-10.063,-15.348) J34(-10.713,-15.348) J35(-11.363,-15.348) J36(-12.014,-15.348) J37(-12.664,-15.348) J38(-13.314,-15.602) K1(13.314,-14.728) K2(12.664,-14.728) K3(12.014,-14.728) K4(11.363,-14.728) K5(10.713,-14.728) K6(10.063,-14.728) K7(9.403,-14.758) K8(8.753,-14.834) K9(8.103,-14.834) K10(7.452,-14.834) K31(-8.762,-14.56) K32(-9.413,-14.56) K33(-10.063,-14.56) K34(-10.713,-14.56) K35(-11.363,-14.56) K36(-12.014,-14.56) K37(-12.664,-14.56) K38(-13.314,-14.56) L1(13.314,-13.839) L2(12.664,-13.839) L3(12.014,-13.839) L4(11.363,-13.839) L5(10.713,-13.839) L6(10.063,-13.89) L7(9.403,-13.919) L8(8.753,-13.97) L9(8.103,-13.996) L10(7.452,-13.996) L31(-8.762,-13.773) L32(-9.413,-13.773) L33(-10.063,-13.773) L34(-10.713,-13.773) L35(-11.363,-13.773) L36(-12.014,-13.773) L37(-12.664,-13.773) L38(-13.314,-13.773) M1(13.314,-13.102) M2(12.664,-13.102) M3(12.014,-13.102) M4(11.363,-13.102) M5(10.713,-13.102) M6(10.063,-13.052) M7(9.403,-13.081) M8(8.753,-13.081) M9(8.103,-13.081) M10(7.452,-13.081) M31(-8.762,-12.985) M32(-9.413,-12.985) M33(-10.063,-12.985) M34(-10.713,-12.985) M35(-11.363,-12.985) M36(-12.014,-12.985) M37(-12.664,-12.985) M38(-13.314,-12.985) N1(13.314,-12.213) N2(12.664,-12.213) N3(12.014,-12.213) N4(11.363,-12.213) N5(10.713,-12.213) N6(10.063,-12.213) N7(9.403,-12.167) N8(8.753,-12.167) N9(8.103,-12.167) N10(7.452,-12.167) N31(-8.762,-12.198) N32(-9.413,-12.198) N33(-10.063,-12.198) N34(-10.713,-12.198) N35(-11.363,-12.198) N36(-12.014,-12.198) N37(-12.664,-12.198) N38(-13.314,-12.198) P1(13.314,-11.324) P2(12.664,-11.324) P3(12.014,-11.324) P4(11.363,-11.324) P5(10.713,-11.324) P6(10.063,-11.375) P7(9.403,-11.252) P8(8.753,-11.252) P9(8.103,-11.252) P10(7.452,-11.252) P31(-8.762,-11.411) P32(-9.413,-11.411) P33(-10.063,-11.411) P34(-10.713,-11.411) P35(-11.363,-11.411) P36(-12.014,-11.411) P37(-12.664,-11.411) P38(-13.314,-11.411) R1(13.314,-10.588) R2(12.664,-10.588) R3(12.014,-10.588) R4(11.363,-10.588) R5(10.713,-10.588) R6(10.063,-10.537) R7(9.403,-10.338) R8(8.753,-10.338) R9(8.103,-10.338) R10(7.452,-10.338) R31(-8.762,-10.623) R32(-9.413,-10.623) R33(-10.063,-10.623) R34(-10.713,-10.623) R35(-11.363,-10.623) R36(-12.014,-10.623) R37(-12.664,-10.623) R38(-13.314,-10.623) T1(13.314,-9.699) T2(12.664,-9.699) T3(12.014,-9.699) T4(11.363,-9.699) T5(10.713,-9.699) T6(10.063,-9.699) T7(9.403,-9.424) T8(8.753,-9.424) T9(8.103,-9.424) T10(7.452,-9.424) T31(-8.762,-9.836) T32(-9.413,-9.836) T33(-10.063,-9.836) T34(-10.713,-9.836) T35(-11.363,-9.836) T36(-12.014,-9.836) T37(-12.664,-9.836) T38(-13.314,-9.836) U1(13.314,-8.81) U2(12.664,-8.81) U3(12.014,-8.81) U4(11.363,-8.81) U5(10.713,-8.81) U6(10.063,-8.861) U31(-8.762,-9.048) U32(-9.413,-9.048) U33(-10.063,-9.048) U34(-10.713,-9.048) U35(-11.363,-9.048) U36(-12.014,-9.048) U37(-12.664,-9.048) U38(-13.314,-9.048) V1(13.314,-8.073) V2(12.664,-8.073) V3(12.014,-8.073) V4(11.363,-8.073) V5(10.713,-8.073) V6(10.063,-8.022) V7(9.403,-8.509) V8(8.753,-8.509) V9(8.103,-8.509) V10(7.452,-8.509) V31(-8.762,-8.261) V32(-9.413,-8.261) V33(-10.063,-8.261) V34(-10.713,-8.261) V35(-11.363,-8.261) V36(-12.014,-8.261) V37(-12.664,-8.261) V38(-13.314,-8.261) W1(13.314,-7.184) W2(12.664,-7.184) W3(12.014,-7.184) W4(11.363,-7.184) W5(10.713,-7.184) W6(10.063,-7.184) W7(9.403,-7.595) W8(8.753,-7.595) W9(8.103,-7.595) W10(7.452,-7.595) W31(-8.762,-7.474) W32(-9.413,-7.474) W33(-10.063,-7.474) W34(-10.713,-7.474) W35(-11.363,-7.474) W36(-12.014,-7.474) W37(-12.664,-7.474) W38(-13.314,-7.474) Y7(9.403,-6.68) Y8(8.753,-6.68) Y9(8.103,-6.68) Y10(7.452,-6.68) Y31(-8.762,-6.686) Y32(-9.413,-6.686) Y33(-10.063,-6.686) Y34(-10.713,-6.686) Y35(-11.363,-6.686) Y36(-12.014,-6.686) Y37(-12.664,-6.686) Y38(-13.314,-6.686)
