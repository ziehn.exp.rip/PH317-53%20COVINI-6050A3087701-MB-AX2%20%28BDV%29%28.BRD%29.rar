# Allegro board PH317-53 COVINI-6050A3087701-MB-AX2 (BDV)(.BRD).brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
M_B_A_1: length 70.1
  L3 w0.076: 106.58,109.01 106.58,117.45 106.31,117.71 106.31,120.46 106.16,120.61 v1(105.7,120.61)
  L3 w0.109: 106.58,109.01 107.64,107.95 107.64,106.73 109.71,104.66 109.71,101.88 109.56,101.73 109.13,101.73 108.98,101.58 108.98,101.36 109.13,101.21 109.56,101.21 109.71,101.06 109.71,100.85 109.56,100.69 109.13,100.69 108.98,100.54 108.98,100.33 109.13,100.18 109.56,100.18 109.71,100.03 109.71,99.81 109.56,99.66 109.13,99.66 108.98,99.51 108.98,99.3 109.13,99.15 109.56,99.15 109.71,99 109.71,92.04 109.99,91.37 115.4,85.96 115.4,84.83 116.88,83.35 116.88,81.84 116.76,81.72 116.64,81.72 116.52,81.59 116.52,81.42 116.64,81.3 116.76,81.3 116.88,81.18 116.88,81.01 116.76,80.89 116.64,80.89 116.52,80.77 116.52,80.6 116.64,80.47 116.76,80.47 116.88,80.35 116.88,80.18 116.76,80.06 116.64,80.06 116.52,79.94 116.52,79.77 116.64,79.65 116.76,79.65 116.88,79.52 116.88,79.35 116.76,79.23 116.64,79.23 116.52,79.11 116.52,78.94 116.64,78.82 116.76,78.82 116.88,78.7 116.88,78.53 116.76,78.4 116.64,78.4 116.52,78.28 116.52,78.11 116.64,77.99 116.76,77.99 116.88,77.87 116.88,77.7 116.76,77.58 116.64,77.58 116.52,77.45 116.52,77.28 116.64,77.16 116.76,77.16 116.88,77.04 116.88,76.63 119.28,74.23 119.28,70.96 119.81,70.42 119.81,70.02 119.98,69.86 120.38,69.86 120.49,69.75 120.49,69.34 120.37,69.22 119.93,69.22 119.81,69.09 119.81,68.92 119.93,68.8 120.37,68.8 120.49,68.68 120.49,68.19 120.37,68.07 v3(119.89,68.07)
  BOTTOM w0.076: U4555.AK6 v1(105.7,120.61)
  BOTTOM w0.17: v3(119.89,68.07) 119.86,68.05 118.92,68.05 118.66,68.31 CN4125.133
M_B_A_2: length 70
  L3 w0.076: v1(105.7,119.96) 105.88,119.96 106.1,119.74 106.1,117.92 105.74,117.56 105.74,112.47 106.18,112.02 106.18,108.69 106.37,108.5
  L3 w0.109: 106.37,108.5 107.15,107.73 107.15,106.64 108.53,105.26 108.53,104.28 108.68,104.13 109.01,104.13 109.16,103.97 109.16,103.76 109.01,103.61 108.68,103.61 108.53,103.46 108.53,103.25 108.68,103.09 109.01,103.09 109.16,102.94 109.16,102.73 109.01,102.58 108.68,102.58 108.53,102.43 108.53,93.81 109.64,91.13 114.98,85.78 114.98,84.66 116.11,83.54 116.11,76.81 118.87,74.05 118.87,70.79 119.4,70.25 119.4,67.59 119.95,67.05 120.93,66.07 120.93,64.38 120.64,64.1 119.79,64.1 v3(119.48,64.41)
  BOTTOM w0.076: U4555.AK5 v1(105.7,119.96)
  BOTTOM w0.17: CN4125.132 118.41,64.14 118.68,64.41 v3(119.48,64.41)
M_B_A_3: length 71.3
  L3 w0.076: 103.28,110.83 103.28,118.34 104.07,119.13 v1(104.07,119.96)
  L3 w0.109: 103.28,110.83 103.9,110.21 103.9,104.36 104.03,104.23 104.72,104.23 104.87,104.08 104.87,103.87 104.72,103.72 104.03,103.72 103.9,103.6 103.9,103.29 104.07,103.11 105.6,103.11 105.77,102.95 105.77,102.64 105.6,102.48 104.66,102.48 104.51,102.32 104.51,102.11 104.66,101.96 105.8,101.96 105.96,101.81 105.96,90.13 110.96,85.13 110.96,84.03 113.02,81.97 113.02,79.81 113.27,79.55 113.27,75.14 113.39,75.02 114.27,75.02 114.4,74.9 114.4,74.72 114.27,74.6 113.39,74.6 113.27,74.48 113.27,73.47 116.21,70.54 116.38,70.54 116.71,70.87 116.88,70.87 117,70.75 117,70.58 116.67,70.25 116.67,70.08 117.6,69.15 117.67,68.98 117.67,66.98 v3(117.79,66.86)
  BOTTOM w0.076: v1(104.07,119.96) 104.4,120.29 U4555.AL5
  BOTTOM w0.17: CN4125.131 118.16,67.72 118.27,67.61 118.27,67.26 117.87,66.86 v3(117.79,66.86)
M_B_A_4: length 71.1
  L3 w0.076: v1(104.07,120.61) 103.78,120.61 103.66,120.5 103.66,119.09 103.04,118.46 103.04,110.62 103.25,110.41
  L3 w0.109: 103.25,110.41 103.49,110.17 103.49,102.25 104.62,101.11 105.36,101.11 105.54,100.94 105.54,100.54 105.39,100.39 104.93,100.39 104.78,100.24 104.78,100.02 104.93,99.87 105.39,99.87 105.54,99.72 105.54,99.31 105.39,99.16 104.85,99.16 104.69,99 104.69,98.78 104.83,98.64 105.39,98.64 105.54,98.49 105.54,89.96 110.55,84.95 110.55,83.82 112.11,82.26 112.11,75.89 112.86,75.14 112.86,73.3 117.25,68.91 117.25,68.9 117.25,65.52 117.38,65.4 118.25,65.4 118.37,65.27 118.37,65.1 118.25,64.98 117.38,64.98 117.25,64.86 117.25,64.42 117.43,64.25 v3(117.44,64.25)
  BOTTOM w0.076: v1(104.07,120.61) 104.4,120.94 U4555.AL6
  BOTTOM w0.17: CN4125.128 117.41,64.22 v3(117.44,64.25)
M_B_A_5: length 67.7
  L3 w0.076: 102.95,110.25 102.81,110.38 102.81,120.19 v1(103.23,120.61)
  L3 w0.109: v3(116.2,64.66) 116.38,64.47 116.66,64.47 116.84,64.65 116.84,68.73 112.44,73.13 112.44,74.84 110.96,76.33 110.96,82.82 110.14,83.65 110.14,84.78 105.13,89.79 105.13,96.11 103.69,97.55 103.69,99.34 103.84,99.49 104.21,99.49 104.37,99.64 104.37,99.86 104.21,100.01 103.84,100.01 103.69,100.16 103.69,101.44 103.07,102.06 103.07,110.12 102.95,110.25
  BOTTOM w0.076: U4555.AM6 103.56,120.94 v1(103.23,120.61)
  BOTTOM w0.17: CN4125.126 116.91,63.97 116.22,64.66 v3(116.2,64.66)
M_B_A_6: length 69.4
  L3 w0.076: 102.6,110.13 102.6,120.45 102.82,120.67 102.82,120.75 103.58,121.51 v1(103.58,121.85)
  L3 w0.109: v3(116.43,66.02) 116.43,68.56 112.03,72.96 112.03,74.6 110.55,76.08 110.55,82.49 105.67,87.36 105.67,87.52 105.93,87.77 105.93,87.92 105.79,88.06 105.63,88.06 105.38,87.81 105.23,87.81 104.67,88.36 104.67,95.91 102.92,97.67 102.66,99.2 102.66,99.74 102.81,99.89 103.09,99.89 103.24,100.05 103.24,100.26 103.09,100.41 102.81,100.41 102.66,100.56 102.66,100.78 102.81,100.93 103.09,100.93 103.24,101.08 103.24,101.29 103.09,101.44 102.81,101.44 102.66,101.59 102.66,110.07 102.6,110.13
  BOTTOM w0.076: U4555.AN7 103.5,121.86 v1(103.58,121.85)
  BOTTOM w0.17: CN4125.127 117.16,66.29 116.89,66.02 v3(116.43,66.02)
M_B_A_7: length 68.2
  L3 w0.076: v1(103.58,123.87) 103.21,123.5 103.21,122.34 102.93,122.05 102.93,121.53 102.15,120.75 102.15,112.84 102.07,112.76
  L3 w0.109: 102.07,112.76 101.83,112.52 101.83,99.13 103.89,86.82 105.95,83.74 108.39,81.3 108.74,80.78 109.08,79.96 109.08,77.47 109.72,76.83 109.72,75.55 111.2,74.07 111.2,72.62 114.86,68.96 115.34,67.8 115.34,65.19 115.89,63.87 v3(115.89,63.42)
  BOTTOM w0.076: v1(103.58,123.87) U4555.AN10
  BOTTOM w0.17: v3(115.89,63.42) 115.91,63.4 CN4125.122
M_B_A_8: length 67.9
  L3 w0.076: v1(103.59,122.55) 103.59,122.42 103.21,122.04 103.21,121.48 102.37,120.64 102.37,112.53 102.25,112.41
  L3 w0.109: 102.25,112.41 102.25,99.16 102.53,97.47 104.26,95.74 104.26,87.93 109.36,82.82 109.36,82.46 109.19,82.29 108.87,82.29 108.75,82.16 108.75,81.75 108.91,81.58 109.97,81.58 110.13,81.42 110.13,81.11 109.98,80.96 109.64,80.96 109.49,80.8 109.49,80.59 109.64,80.44 109.98,80.44 110.13,80.29 110.13,80.08 109.98,79.92 109.64,79.92 109.49,79.77 109.49,77.65 110.13,77.01 110.13,75.87 111.62,74.38 111.62,72.79 115.99,68.41 v3(115.99,67.59)
  BOTTOM w0.076: U4555.AN8 103.15,122.24 v1(103.59,122.55)
  BOTTOM w0.17: v3(115.99,67.59) 116.15,67.43 116.49,67.43 116.66,67.6 116.66,67.98 116.58,68.06 116.58,68.66 116.66,68.73 CN4125.125
M_B_A_9: length 67.2
  L3 w0.076: v1(101.75,124.52) 102.28,123.99 102.28,122.43 102.44,122.28 102.44,121.6 101.7,120.86 101.7,113.45 101.61,113.36
  L3 w0.109: v3(114.01,66.54) 114.4,67.48 114.4,67.8 114.35,67.91 111.24,71.02 108.3,74.6 107.07,76.66 106.65,78.03 105.43,82.36 102.79,87.06 101,97.73 101,112.75 101.61,113.36
  BOTTOM w0.076: v1(101.75,124.52) U4555.AR11
  BOTTOM w0.17: CN4125.121 115.66,68.99 115.52,68.67 114.29,66.83 v3(114.01,66.54)
M_B_A_10: length 69
  L3 w0.076: v1(107.22,121.91) 107.18,121.86 107.18,118.07 107.54,117.71 107.54,110.81 107.76,110.6
  L3 w0.109: v3(122.68,63.33) 122.92,63.33 123.27,63.68 123.27,67.13 122.72,67.67 122.72,71.77 121.97,72.52 121.97,73.88 119.67,76.18 119.67,78.21 119.48,78.4 119.48,83.1 117.11,85.46 117.11,86.24 117.11,86.59 111.4,92.3 111.4,105.37 109.49,107.28 109.49,108.86 107.76,110.6
  BOTTOM w0.076: v1(107.22,121.91) 107.22,121.91 U4555.AH7
  BOTTOM w0.17: CN4125.146 123.03,61.5 122.68,61.85 v3(122.68,63.33)
M_B_A_11: length 68.7
  L3 w0.076: 101.8,112.99 101.93,113.12 101.93,120.86 102.71,121.64 102.71,122.07 103.05,122.41 103.05,122.45 103.05,122.45 103.05,123.99 v1(103.58,124.52)
  L3 w0.109: v3(114.88,64.47) 114.62,64.73 114.62,66.29 114.88,66.55 114.88,67.72 114.45,68.75 110.68,72.53 110.68,73.95 108.9,75.73 106.53,80.17 105.94,82.31 103.19,87.2 101.42,97.76 101.42,112.6 101.8,112.99
  BOTTOM w0.076: v1(103.58,124.52) U4555.AN11
  BOTTOM w0.17: CN4125.120 115.34,62.78 115.28,63.09 114.96,63.88 114.88,64.26 v3(114.88,64.47)
M_B_A_12: length 64.6
  L3 w0.076: v1(101.75,123.87) 102.12,123.5 102.12,122.36 102.27,122.21 102.27,121.69 101.48,120.9 101.48,117.09 100.82,116.43 100.41,115.29 100.23,114.38
  L3 w0.109: 100.23,114.38 99.72,113.15 99.59,112.46 99.59,111.81 99.67,111.62 99.67,110.37 99.68,110.35 100.11,109.3 100.11,103.39 100.44,98.97 100.59,98.08 100.59,97.69 102.24,87.83 102.37,86.93 102.38,86.92 104.96,82.31 104.96,79.4 105.17,78.35 106.15,75.99 107.18,74.45 113.81,67.83 v3(113.81,67.8)
  BOTTOM w0.076: v1(101.75,123.87) U4555.AR10
  BOTTOM w0.17: CN4125.119 115.06,69 115.06,68.88 114.68,68.5 v3(113.81,67.8)
M_B_A_13: length 72.2
  L3 w0.109: v1(109.07,123.22) 109.44,123.22 109.55,123.11 109.55,118.86 110.07,118.33 110.07,113.79 110.5,113.36 110.5,112.31 114.3,108.51 114.3,93.5 122.66,85.14 122.66,84.02 124.41,82.27 124.41,75.68 124.98,75.11 125.4,75.11 127.18,73.33 127.18,70.6 126.78,70.2 126.78,65.76 126.98,65.56 127.92,65.56 128.16,65.31 128.16,64.49 127.91,64.24 v3(127.61,64.24)
  BOTTOM w0.076: v1(109.07,123.22) U4555.AF9
  BOTTOM w0.17: v3(127.61,64.24) 126.91,63.54 CN4125.158
M_B_ACT#: length 67.7
  L3 w0.076: v1(100.84,123.22) 101.2,122.86 101.2,122.4 100.74,121.94 100.46,121.51 100.08,120.81 100,120.62 100,120.14 99.97,119.79 99.41,115.99 99.35,115.4 99.25,114.91 99.25,114.89 99.24,114.81 99.23,114.79 99.22,114.77 98.78,113.69 98.77,113.68 98.77,113.66 98.49,112.88
  L3 w0.109: 98.49,112.88 97.47,110.67 97.36,110.37 97.36,109.21 98.18,98.03 99.95,87.47 100.1,86.47 100.11,86.43 100.11,86.38 100.26,85.73 100.57,84.41 100.8,83.44 100.85,83.26 101.81,80.18 101.88,80 102.3,78.65 103.14,76.49 103.48,75.87 103.52,75.8 104.97,73.21 105.82,72.09 110.92,66.99 111.18,66.48 112.25,64.76 v3(112.35,64.64)
  BOTTOM w0.076: v1(100.84,123.22) U4555.AT9
  BOTTOM w0.17: v3(112.35,64.64) 113.44,63.31 113.73,62.87 113.81,62.51 CN4125.114
M_B_ALERT#: length 66.9
  L3 w0.076: 99.18,112 99.18,112 99.49,113.56 99.91,114.58 99.97,114.88 100.53,116.43 101.26,117.17 101.26,117.17 101.27,117.18 101.27,120.92 102.09,121.74 102.09,122.04 101.74,122.39 v1(101.74,122.55)
  L3 w0.109: v3(113.48,65.27) 113.18,65.98 112.64,67.77 107.4,73.02 106.64,73.94 106.6,73.98 106.57,74.02 105.87,75.08 105.48,75.65 105.37,75.88 104.42,78.17 104.22,79.2 104.22,82.11 101.66,86.68 101.51,87.72 99.75,98.19 99.72,98.66 99.37,103.36 99.37,109.07 98.93,110.13 98.93,110.75 99.18,112
  BOTTOM w0.076: U4555.AR8 101.72,122.55 v1(101.74,122.55)
  BOTTOM w0.17: v3(113.48,65.27) 113.43,65.17 114.01,63.77 114.41,62.81 CN4125.116
M_B_BG0: length 66.7
  L3 w0.076: 98.71,112.73 98.97,113.6 99.47,114.79 99.51,115.09 99.57,115.37 99.59,115.65 100.19,119.65 100.22,120.03 100.22,120.54 100.28,120.69 100.34,120.81 100.74,121.56 101.1,122 101.37,122.27 101.37,122.84 101.73,123.2 v1(101.73,123.2)
  L3 w0.109: 98.71,112.73 97.77,110.47 97.77,109.23 98.59,98.08 100.36,87.54 100.53,86.38 101.25,83.37 102.2,80.32 103.83,76.12 105.31,73.46 106.2,72.29 111.25,67.24 111.72,66.53 112.06,66.2 v3(112.06,66.17)
  BOTTOM w0.076: v1(101.73,123.2) U4555.AR9
  BOTTOM w0.17: v3(112.06,66.17) 112.37,66.48 112.48,66.62 112.62,66.84 112.78,67.21 113.26,67.93 113.92,68.59 114.07,68.97 114.07,69.08 114.16,69.28 CN4125.115
M_B_BG1: length 67.1
  L3 w0.076: 98.94,112.48 99.22,113.58 99.73,114.83 100,116.2 101.06,117.25 101.06,121.01 101.22,121.18 101.22,121.81 101.34,121.92 101.68,121.92 v1(101.71,121.89)
  L3 w0.109: 98.94,112.48 98.19,110.38 98.19,109.25 98.62,108.81 98.62,108.11 98.33,107.82 98.33,107.54 98.62,107.24 98.62,103.33 98.99,98.41 98.99,98.38 99.01,98.13 99.01,98.1 100.1,91.57 100.52,89.11 100.77,87.6 100.94,86.46 100.95,86.42 101.75,84.99 101.75,83.3 101.93,83.13 102.72,83.13 102.85,83 102.85,82.85 102.71,82.71 102.16,82.71 102.01,82.56 102.01,82.35 102.27,82.09 103.32,82.09 103.45,81.96 103.45,81.75 103.34,81.64 103.01,81.64 102.9,81.53 102.9,81.34 103.05,81.19 103.34,81.19 103.45,81.08 103.45,78.25 104.4,76.29 104.69,75.58 104.84,75.28 105.02,75.01 105.26,74.51 105.83,73.48 106.3,72.86 111.66,67.5 v3(112.08,67.5)
  BOTTOM w0.076: v1(101.71,121.89) U4555.AR7
  BOTTOM w0.17: CN4125.113 113.58,69.87 113.58,68.89 113.27,68.58 113.16,68.58 v3(112.08,67.5)
M_B_BS0: length 68.7
  L3 w0.076: 108,110.95 107.77,111.17 107.77,117.8 107.39,118.18 107.39,121.53 107.62,121.75 107.62,122.06 107.22,122.45 v1(107.22,122.58)
  L3 w0.109: v3(124.82,63.59) 123.68,64.74 123.68,67.3 123.18,67.8 123.18,72.31 122.51,73.92 120.66,75.78 120.66,77.81 119.89,78.57 119.89,83.27 117.53,85.63 117.53,86.07 117.53,86.76 111.81,92.47 111.81,105.86 110.13,108.67 109.85,109.1 108,110.95
  BOTTOM w0.076: U4555.AH8 107.17,122.52 v1(107.22,122.58)
  BOTTOM w0.17: v3(124.82,63.59) 124.8,63.57 CN4125.150
M_B_BS1: length 70.9
  L3 w0.076: 107.51,110.21 107.31,110.41 107.31,117.63 106.96,117.98 106.96,121.43 106.85,121.54 106.85,122.86 v1(107.21,123.22)
  L3 w0.109: 107.51,110.21 109.05,108.67 109.05,107.13 110.99,105.2 110.99,92.2 111.04,92.07 116.64,86.47 116.7,86.42 116.7,85.29 118.23,83.75 118.23,80.79 119.06,79.96 119.06,78.23 119.26,78.03 119.26,76.01 120.61,74.65 120.61,73.76 120.87,73.5 121.41,73.5 121.56,73.36 121.56,72.54 121.45,72.43 120.74,72.43 120.63,72.32 120.63,72 120.76,71.86 121.99,71.86 122.24,71.62 122.24,71.28 122.09,71.13 121.41,71.13 121.29,71.01 121.29,70.74 121.4,70.64 122.19,70.64 122.31,70.51 122.31,67.1 v3(122.53,66.88)
  BOTTOM w0.076: U4555.AH9 107.21,123.2 v1(107.21,123.22)
  BOTTOM w0.17: CN4125.145 123.66,68.01 v3(122.53,66.88)
M_B_CAS#: length 69.9
  L3 w0.076: v1(109.07,122.58) 108.57,122.09 108.57,121.78 108.97,121.38
  L3 w0.109: v3(126.23,63.83) 125.92,64.13 125.73,64.6 125.73,70.5 126.3,71.07 126.3,72.98 126.09,73.19 125,74.28 124.64,74.28 123.11,75.81 123.11,78.38 122.97,78.53 122.97,82.53 119.18,86.32 119.18,87.1 119.18,87.44 113.47,93.16 113.47,107.98 109.65,111.81 109.65,113.14 109.49,113.3 109.49,117.81 108.97,118.33 108.97,121.38
  BOTTOM w0.076: v1(109.07,122.58) U4555.AF8
  BOTTOM w0.17: v3(126.23,63.83) 126.41,63.65 CN4125.156
M_B_DQ<0>: length 74.1
  L3 w0.076: v1(83.58,123.72) 83.58,123.52 83.14,123.08 82.09,123.08 78.1,119.09 78.1,110.48 78.52,110.06 78.52,98.11 78.67,97.95 78.9,97.95 79.01,97.84 79.01,97.68 78.9,97.57 78.63,97.57 78.52,97.46 78.52,97.3 78.63,97.19 78.9,97.19 79.01,97.08 79.01,96.92 78.9,96.81 78.63,96.81 78.52,96.7 78.52,96.54 78.63,96.43 78.9,96.43 79.01,96.32 79.01,96.16 78.9,96.05 78.63,96.05 78.52,95.94 78.52,95.78 78.63,95.67 78.9,95.67 79.01,95.56 79.01,95.4 78.9,95.29 78.63,95.29 78.52,95.18 78.52,95.02 78.63,94.91 78.9,94.91 79.01,94.79 79.01,94.64 78.9,94.53 78.63,94.53 78.52,94.41 78.52,94.26 78.63,94.14 78.9,94.14 79.01,94.03 79.01,93.87 78.9,93.76 78.63,93.76 78.52,93.65 78.52,93.49 78.63,93.38 78.9,93.38 79.01,93.27 79.01,93.11 78.9,93 78.63,93 78.52,92.89 78.52,92.73 78.63,92.62 78.9,92.62 79.01,92.51 79.01,92.35 78.9,92.24 78.63,92.24 78.52,92.13 78.52,91.97 78.63,91.86 78.9,91.86 79.01,91.75 79.01,91.59 78.9,91.48 78.63,91.48 78.52,91.37 78.52,91.21 78.63,91.1 78.9,91.1 79.01,90.98 79.01,86.36 78.04,83.14 78.04,83.14 77.81,82.4 77.19,79.27 77.19,77.77 79.41,75.55 79.41,74.88 81.47,72.82 81.47,71.99 81.95,71.52 85.24,68.23 85.46,68.23 v3(85.75,68.53)
  BOTTOM w0.076: v1(83.58,123.72) 83.77,123.52 84.05,123.33 84.26,123.33 84.72,123.52 85.47,123.92 86.18,124.14 U4555.BT11
  BOTTOM w0.109: v3(85.75,68.53) 86,68.85 86.05,68.98 86.07,69.1 CN4125.3
M_B_DQ<1>: length 75.3
  L3 w0.076: v3(85.89,67.22) 85.72,67.22 81.19,71.74 81.19,72.7 79.13,74.76 79.13,75.44 76.91,77.66 76.91,79.3 76.96,79.57 77.54,82.46 77.77,83.23 77.77,83.23 78.21,84.67 78.24,84.77 78.73,86.4 78.73,86.72 78.62,86.83 78.35,86.83 78.24,86.94 78.24,87.1 78.35,87.21 78.62,87.21 78.73,87.32 78.73,87.48 78.62,87.59 78.35,87.59 78.24,87.71 78.24,87.86 78.35,87.97 78.62,87.97 78.73,88.09 78.73,88.24 78.62,88.36 78.35,88.36 78.24,88.47 78.24,88.63 78.35,88.74 78.62,88.74 78.73,88.85 78.73,89.01 78.62,89.12 78.35,89.12 78.24,89.23 78.24,89.39 78.35,89.5 78.62,89.5 78.73,89.61 78.73,89.77 78.62,89.88 78.35,89.88 78.24,89.99 78.24,90.15 78.35,90.26 78.62,90.26 78.73,90.37 78.73,90.53 78.62,90.64 78.35,90.64 78.24,90.75 78.24,109.89 77.76,110.36 77.76,119.15 81.9,123.28 82.98,123.28 83.08,123.39 83.08,123.58 v1(82.94,123.72)
  BOTTOM w0.076: U4555.BR11 86.6,124.14 86.45,123.98 86.45,123.98 86.15,123.69 85.45,123.69 85.26,123.61 84.82,123.32 84.19,123.13 83.97,123.13 83.36,123.38 83.1,123.56 v1(82.94,123.72)
  BOTTOM w0.109: v3(85.89,67.22) 87.16,68.48 CN4125.7
M_B_DQ<2>: length 71.9
  L3 w0.076: v3(87.95,63.98) 87.81,64.11 87.81,68.19 85.82,70.19 84.97,70.19 82.67,72.49 82.67,73.31 80.6,75.38 80.6,76.05 78.39,78.26 78.39,78.26 78.39,79.21 78.94,81.94 79.28,83.07 79.51,83.72 80.21,86.01 80.21,110.08 79.42,110.86 79.42,118.65 80.37,119.59 80.37,119.65 82.82,122.1 83.18,122.1 83.95,122.87 84.61,122.87 85.02,123.28 v1(85.5,123.28)
  BOTTOM w0.076: U4555.BT9 v1(85.5,123.28)
  BOTTOM w0.109: v3(87.95,63.98) 88.6,63.98 89.34,63.24 89.34,61.57 CN4125.16
M_B_DQ<3>: length 73.1
  L3 w0.076: v3(88.57,65.31) 88.27,65.31 88.09,65.49 88.09,68.31 85.94,70.47 85.08,70.47 82.95,72.6 82.95,73.43 80.89,75.48 80.89,80.58 80.31,81.16 80.31,84.25 80.93,84.87 80.93,87.33 80.85,87.41 80.77,87.41 80.7,87.49 80.7,87.71 80.77,87.79 80.85,87.79 80.93,87.87 80.93,88.09 80.85,88.17 80.77,88.17 80.7,88.25 80.7,88.48 80.77,88.55 80.85,88.55 80.93,88.63 80.93,109.75 79.7,110.97 79.7,118.53 82.8,121.63 v1(83.27,121.63)
  BOTTOM w0.076: U4555.BR8 86.37,122.56 86.31,122.63 86.06,122.63 85.4,121.97 84.75,121.97 84.41,121.63 v1(83.27,121.63)
  BOTTOM w0.109: CN4125.21 90.66,68.48 89.25,67.07 89.25,65.87 88.69,65.31 v3(88.57,65.31)
M_B_DQ<4>: length 74.8
  L3 w0.076: v3(86.66,65.06) 86.78,65.17 86.78,65.76 80.92,71.63 80.92,72.48 78.82,74.58 78.82,75.36 76.63,77.54 76.63,79.33 76.69,79.63 76.97,81.04 77.27,82.55 77.96,87.19 77.96,109.77 77.48,110.25 77.48,119.26 81.88,123.66 81.97,123.86 82.15,124.05 82.34,124.13 84.6,124.13 v1(84.63,124.16)
  BOTTOM w0.076: U4555.BP11 87.36,124.27 86.96,124.43 86.06,124.43 85.41,124.16 v1(84.63,124.16)
  BOTTOM w0.109: v3(86.66,65.06) 87.41,63.94 CN4125.8
M_B_DQ<5>: length 75.1
  L3 w0.076: v3(86.19,63.7) 86.07,63.82 86.07,65.49 86,65.77 85.73,66.41 80.64,71.51 80.64,72.37 78.42,74.58 77.51,75.7 76.35,77.43 76.35,79.36 77,82.6 77.68,87.22 77.68,109.02 77.2,110.16 77.2,119.38 82.03,124.2 82.29,124.33 82.76,124.46 v1(85.15,124.57)
  BOTTOM w0.076: U4555.BN11 87.89,124.3 87.37,124.52 87.02,124.59 87,124.59 85.17,124.59 v1(85.15,124.57)
  BOTTOM w0.109: v3(86.19,63.7) 86.41,63.48 CN4125.4
M_B_DQ<6>: length 73.9
  L3 w0.076: v1(83.9,122.03) 83.9,121.64 83.02,120.76 82.39,120.76 79.98,118.34 79.98,111.09 81.21,109.87 81.21,84.75 80.72,84.26 80.72,83.78 80.88,83.62 81.74,83.62 81.89,83.46 81.89,83.28 81.74,83.13 80.78,83.13 80.63,82.98 80.63,82.78 80.76,82.65 81.82,82.65 81.96,82.51 81.96,82.29 81.83,82.17 80.73,82.17 80.59,82.03 80.59,81.27 81.17,80.69 81.17,75.6 83.23,73.54 83.23,72.72 85.2,70.75 86.05,70.75 88.53,68.27 v3(88.53,66.79)
  BOTTOM w0.076: U4555.BP8 87.19,122.85 85.87,122.85 85.32,122.3 84.81,122.3 84.54,122.03 v1(83.9,122.03)
  BOTTOM w0.109: v3(88.53,66.79) 89.66,67.92 CN4125.17
M_B_DQ<7>: length 74.6
  L3 w0.076: v1(85.12,122.68) 84.85,122.42 84.85,122.27 82.9,120.32 82.57,120.32 80.26,118 80.26,111.21 81.5,109.97 81.5,98.84 81.64,98.7 81.93,98.7 82.07,98.56 82.07,98.36 81.93,98.22 81.64,98.22 81.5,98.08 81.5,97.88 81.64,97.74 81.93,97.74 82.07,97.59 82.07,97.39 81.93,97.25 81.64,97.25 81.5,97.11 81.5,96.91 81.64,96.77 81.93,96.77 82.07,96.63 82.07,96.43 81.5,95.86 81.5,84.25 82.24,83.51 82.24,74.95 83.86,73.33 83.86,72.48 85.32,71.03 86.17,71.03 89.07,68.12 89.07,64.86 88.73,64.52 88.73,64.06 89.05,63.74 89.41,63.74 v3(89.59,63.91)
  BOTTOM w0.076: v1(85.12,122.68) 85.46,122.68 85.84,123.06 87.59,123.06 88.08,122.56 U4555.BN8
  BOTTOM w0.109: v3(89.59,63.91) 90.29,63.21 90.29,63.21 90.3,63.2 90.3,61.61 CN4125.20
M_B_DQ<8>: length 74.9
  L3 w0.076: v1(89.11,124.53) 89.11,123.82 88.28,122.98 86.19,122.98 80.75,117.53 80.75,111.41 82.01,110.14 82.01,101.55 82.72,100.83 82.72,100.51 82.58,100.37 82.33,100.37 82.19,100.23 82.19,100.03 82.33,99.89 82.58,99.89 82.72,99.74 82.72,75.15 89.56,68.32 89.56,64.63 90.29,63.9 90.29,63.24 90.61,62.92 91.04,62.92 91.31,63.19 v3(91.31,63.55)
  BOTTOM w0.076: v1(89.11,124.53) 89.11,124.6 U4555.BL12
  BOTTOM w0.109: v3(91.31,63.55) 91.41,63.46 CN4125.24
M_B_DQ<9>: length 74.5
  L3 w0.076: v1(89.91,124.52) 89.39,124 89.39,123.84 88.18,122.62 86.29,122.62 81.02,117.36 81.02,111.52 82.41,110.14 82.41,101.83 83,101.24 83,75.27 89.84,68.43 89.84,65.71 89.95,65.6 90.02,65.6 90.13,65.49 90.13,65.33 90.02,65.22 89.95,65.22 89.84,65.11 89.84,64.75 90.1,64.48 90.38,64.48 90.61,64.71 v3(90.61,64.9)
  BOTTOM w0.076: U4555.BL11 v1(89.91,124.52)
  BOTTOM w0.109: CN4125.28 92.41,63.1 v3(90.61,64.9)
M_B_DQ<10>: length 73.3
  L3 w0.076: v3(90.67,66.37) 90.67,66.16 90.49,65.98 90.22,65.98 90.12,66.09 90.12,68.55 83.28,75.39 83.28,91.78 83.57,92.07 83.57,92.55 83.28,92.84 83.28,101.88 83.07,102.09 82.83,102.09 82.69,102.24 82.69,102.44 82.83,102.58 83.07,102.58 83.21,102.72 83.21,102.92 83.07,103.06 82.83,103.06 82.69,103.2 82.69,103.4 82.83,103.54 83.07,103.54 83.21,103.68 83.21,103.88 83.07,104.02 82.83,104.02 82.69,104.17 82.69,104.37 82.83,104.51 83.07,104.51 83.21,104.65 83.21,104.85 83.07,104.99 82.83,104.99 82.69,105.13 82.69,110.25 81.3,111.64 81.3,116.33 85.1,120.13 85.68,120.13 87.93,122.38 88.35,122.38 88.5,122.53 89.07,122.53 89.2,122.66 89.2,122.84 v1(89.1,122.95)
  BOTTOM w0.076: U4555.BL8 89.41,122.56 v1(89.1,122.95)
  BOTTOM w0.109: v3(90.67,66.37) 91.03,66.37 92.66,67.99 CN4125.29
M_B_DQ<11>: length 73.6
  L3 w0.076: v1(90.78,122.52) 90.78,122.39 90.33,121.95 90.33,121.73 89.08,120.48 88.73,120.48 87.48,119.23 87.48,117.86 85.21,115.6 84.86,115.6 83.64,114.37 83.64,112.28 85.7,110.22 85.7,103.25 85.99,102.95 86.41,102.95 86.6,102.76 86.6,102.48 86.46,102.34 85.87,102.34 85.73,102.19 85.73,101.99 85.87,101.85 86.46,101.85 86.6,101.71 86.6,101.51 86.46,101.37 85.87,101.37 85.73,101.23 85.73,101.03 85.87,100.89 86.46,100.89 86.6,100.75 86.6,100.55 86.46,100.41 85.87,100.41 85.73,100.26 85.73,100.06 85.87,99.92 86.46,99.92 86.6,99.78 86.6,85.97 86.06,85.42 86.06,82.49 86.36,82.19 86.36,75.26 93.29,68.33 93.29,66.76 93.45,66.61 93.83,66.61 v3(94.06,66.83)
  BOTTOM w0.076: U4555.BJ8 90.72,122.53 v1(90.78,122.52)
  BOTTOM w0.109: v3(94.06,66.83) 94.47,66.83 94.9,67.27 94.9,67.42 95.66,68.17 CN4125.41
M_B_DQ<12>: length 74.9
  L3 w0.076: v3(94.18,64.12) 94.18,64.12 94.18,64.15 93.19,65.14 93.19,65.67 92.69,66.17 92.69,68.14 85.23,75.6 85.23,93.06 85.94,93.77 85.94,94.47 85.8,94.61 85.25,94.61 85.11,94.75 85.11,94.95 85.25,95.09 85.8,95.09 85.94,95.23 85.94,95.43 85.8,95.57 85.25,95.57 85.11,95.71 85.11,95.91 85.25,96.06 85.65,96.06 85.79,96.2 85.79,96.55 85.11,97.23 85.11,110.01 83.08,112.05 83.08,114.8 84.55,116.27 85.09,116.27 86.96,118.14 86.96,119.35 88.71,121.1 89.21,121.1 90,121.89 90,122.08 90.22,122.31 90.22,122.75 90.39,122.91 90.39,123.48 v1(90.78,123.87)
  BOTTOM w0.076: v1(90.78,123.87) U4555.BJ11
  BOTTOM w0.109: CN4125.38 94.91,63.81 94.6,64.12 v3(94.18,64.12)
M_B_DQ<13>: length 75.2
  L3 w0.076: v3(94.17,65.5) 93.86,65.18 93.61,65.18 93.47,65.32 93.47,65.78 93.01,66.24 93.01,68.21 86.08,75.14 86.08,81.89 85.72,82.25 85.72,92.8 86.33,93.4 86.33,96.98 86.18,97.13 85.65,97.13 85.51,97.27 85.51,97.47 85.65,97.61 86.18,97.61 86.33,97.75 86.33,97.95 86.18,98.09 85.65,98.09 85.51,98.23 85.51,98.43 85.65,98.57 86.18,98.57 86.33,98.71 86.33,99.04 86.16,99.21 85.78,99.21 85.39,99.6 85.39,110.13 83.36,112.16 83.36,114.61 84.7,115.95 85.13,115.95 87.23,118.06 87.23,119.32 88.65,120.74 89.08,120.74 90.16,121.82 90.16,122.01 90.39,122.24 90.39,122.68 90.78,123.07 v1(90.78,123.22)
  BOTTOM w0.076: v1(90.78,123.22) U4555.BJ10
  BOTTOM w0.109: CN4125.42 95.91,63.07 95.22,63.76 95.22,63.94 94.91,64.26 94.91,64.76 v3(94.17,65.5)
M_B_DQ<14>: length 72.6
  L3 w0.076: v1(89.11,122.15) 87.98,122.15 85.98,120.15 85.98,119.47 85.79,119.27 85.68,119.27 85.68,119.27 85.5,119.27 84.25,118.03 83.52,118.03 81.58,116.09 81.58,111.75 82.97,110.37 82.97,105.55 83.62,104.89 83.62,93.12 84.04,92.71 84.04,91.52 83.9,91.38 83.66,91.38 83.56,91.28 83.56,91.12 83.68,91 83.9,91 84.04,90.86 84.04,90.67 83.93,90.56 83.67,90.56 83.56,90.45 83.56,90.29 83.67,90.18 83.93,90.18 84.04,90.07 84.04,89.76 83.9,89.62 83.71,89.62 83.57,89.48 83.57,89.28 83.71,89.13 83.9,89.13 84.04,88.99 84.04,88.79 83.9,88.65 83.71,88.65 83.57,88.51 83.57,88.31 83.71,88.17 83.9,88.17 84.04,88.03 84.04,87.83 83.9,87.69 83.71,87.69 83.57,87.55 83.57,87.35 83.71,87.2 83.9,87.2 84.04,87.06 84.04,86.86 83.9,86.72 83.71,86.72 83.57,86.58 83.57,86.38 83.71,86.24 83.9,86.24 84.04,86.1 84.04,85.9 83.9,85.76 83.71,85.76 83.57,85.62 83.57,85.42 83.71,85.27 83.9,85.27 84.04,85.13 84.04,84.93 83.9,84.79 83.71,84.79 83.57,84.65 83.57,84.45 83.71,84.31 83.9,84.31 84.04,84.17 84.04,83.97 83.9,83.83 83.71,83.83 83.57,83.68 83.57,83.48 83.71,83.34 83.9,83.34 84.04,83.2 84.04,83 83.9,82.86 83.71,82.86 83.57,82.72 83.57,82.52 83.71,82.38 83.9,82.38 84.04,82.24 84.04,82 83.93,81.89 83.72,81.89 83.57,81.74 83.57,75.51 90.63,68.45 v3(90.63,67.73)
  BOTTOM w0.076: U4555.BL7 89.39,121.68 v1(89.11,122.15)
  BOTTOM w0.109: v3(90.63,67.73) 90.77,67.73 91.66,68.63 CN4125.25
M_B_DQ<15>: length 73.6
  L3 w0.076: v3(94.19,68.15) 93.87,68.15 92.36,69.65 92.36,69.81 92.45,69.89 92.45,70.05 92.34,70.16 92.18,70.16 92.09,70.08 91.94,70.08 91.83,70.19 91.83,70.35 91.91,70.43 91.91,70.59 91.8,70.7 91.64,70.7 91.56,70.62 91.4,70.62 86.64,75.37 86.64,82.35 86.34,82.65 86.34,85.31 86.88,85.85 86.88,103.39 86.74,103.54 86.14,103.54 86,103.68 86,103.88 86.14,104.02 86.74,104.02 86.88,104.16 86.88,104.36 86.74,104.5 86.14,104.5 86,104.64 86,104.84 86.14,104.98 86.74,104.98 86.88,105.12 86.88,105.32 86.74,105.47 86.14,105.47 86,105.61 86,105.81 86.14,105.95 86.74,105.95 86.88,106.09 86.88,106.29 86.74,106.43 86.14,106.43 86,106.57 86,106.77 86.14,106.91 86.74,106.91 86.88,107.05 86.88,107.25 86.74,107.4 86.14,107.4 86,107.54 86,107.74 86.14,107.88 86.74,107.88 86.88,108.02 86.88,108.22 86.74,108.36 86.14,108.36 86,108.5 86,108.7 86.14,108.84 86.55,108.84 86.71,109 86.71,109.59 83.91,112.39 83.91,114.18 84.96,115.23 85.24,115.23 87.73,117.72 87.73,119.21 88.77,120.24 89.1,120.24 90.71,121.86 v1(90.78,121.86)
  BOTTOM w0.076: U4555.BJ7 90.71,121.87 v1(90.78,121.86)
  BOTTOM w0.109: CN4125.37 94.66,68.62 v3(94.19,68.15)
M_B_DQ<16>: length 71.9
  L3 w0.076: v3(95.66,64.46) 95.51,64.55 95.34,64.69 95.11,64.92 94.79,65.79 94.69,66.39 94.69,68.66 87.54,75.81 87.54,97.99 87.37,98.16 87.37,109.63 84.98,112.02 84.4,113.42 84.4,113.76 84.62,114.28 88,117.67 88.32,118.44 89.19,119.31 89.35,119.7 89.35,119.87 89.5,120.22 90.31,121.03 90.82,121.24 92.06,122.48 92.06,123.75 92.06,123.75 92.06,123.96 v1(92.61,124.51)
  BOTTOM w0.076: v1(92.61,124.51) U4555.BG11
  BOTTOM w0.109: v3(95.66,64.46) 95.69,64.46 96.69,63.46 96.91,62.93 CN4125.46
M_B_DQ<17>: length 71.6
  L3 w0.076: v3(95.42,65.77) 95.09,66.1 95.09,68.65 87.82,75.93 87.82,82.02 88.26,82.46 88.26,97.66 87.65,98.27 87.65,109.81 85.48,111.97 85.48,111.98 85.48,111.99 85.48,112 85.47,112 85.47,113.68 90.06,118.26 90.77,118.26 91.04,118.53 91.04,120.94 91.81,121.71 91.81,121.97 92.23,122.39 92.23,123.49 v1(92.61,123.87)
  BOTTOM w0.076: v1(92.61,123.87) U4555.BG10
  BOTTOM w0.109: v3(95.42,65.77) 95.43,65.77 96.01,66.35 96.01,67.31 97.56,68.86 97.56,69.85 CN4125.49
M_B_DQ<18>: length 70.6
  L3 w0.076: v1(92.61,122.53) 92.61,122.52 92.59,122.5 92.59,122.48 92.08,121.97 92.08,121.58 91.24,120.74 91.24,118.47 90.79,118.01 90.33,118.01 85.76,113.44 85.76,112.11 85.76,112.1 85.76,112.09 87.93,109.92 87.93,102.07 88.82,101.18 88.82,100.98 88.68,100.84 88.25,100.84 88.1,100.69 88.1,100.49 88.25,100.35 88.68,100.35 88.82,100.21 88.82,100.01 88.68,99.87 88.25,99.87 88.1,99.73 88.1,99.53 88.25,99.39 88.68,99.39 88.82,99.25 88.82,99.05 88.68,98.91 88.25,98.91 88.1,98.76 88.1,98.56 88.25,98.42 88.68,98.42 88.81,98.29 88.81,82.62 88.1,81.9 88.1,76.04 95.82,68.31 95.82,67.38 95.61,67.16 v3(95.5,67.16)
  BOTTOM w0.076: U4555.BG8 92.54,122.53 v1(92.61,122.53)
  BOTTOM w0.109: CN4125.45 96.66,68.42 95.5,67.26 v3(95.5,67.16)
M_B_DQ<19>: length 71.4
  L3 w0.076: v3(99.34,64.24) 99.02,64.24 98.31,64.94 98.31,68.31 91.43,75.18 91.43,84.36 90.7,85.09 90.7,103.79 90.69,103.82 90.43,104.08 89.85,104.08 89.71,104.22 89.71,104.42 89.85,104.56 90.43,104.56 90.57,104.7 90.57,104.9 90.43,105.04 89.85,105.04 89.71,105.19 89.71,105.39 89.85,105.53 90.43,105.53 90.57,105.67 90.57,105.87 89.71,106.72 89.71,114.34 92.28,116.91 92.28,120.23 93.5,121.44 93.65,121.44 93.89,121.68 93.89,122.08 93.52,122.45 v1(93.52,122.56)
  BOTTOM w0.076: U4555.BF8 93.51,122.56 v1(93.52,122.56)
  BOTTOM w0.109: v3(99.34,64.24) 100.24,63.33 100.65,63.33 100.91,63.08 CN4125.62
M_B_DQ<20>: length 72.6
  L3 w0.076: v1(93.52,124.51) 93.96,124.07 93.96,123.81 94.06,123.71 94.06,122.42 94.3,122.18 94.3,121.61 93.74,121.05 93.74,121.04 93.62,121.04 92.69,120.12 92.69,116.45 90.4,114.16 90.4,113.34 90.51,113.23 91.08,113.23 91.26,113.06 91.26,112.78 91.12,112.64 90.64,112.64 90.5,112.49 90.5,112.29 90.64,112.15 91.12,112.15 91.26,112.01 91.26,111.81 91.12,111.67 90.64,111.67 90.5,111.53 90.5,111.33 90.64,111.19 91.12,111.19 91.26,111.05 91.26,110.85 91.12,110.71 90.64,110.71 90.5,110.56 90.5,110.36 90.64,110.22 91.12,110.22 91.26,110.08 91.26,109.88 91.12,109.74 90.64,109.74 90.5,109.6 90.5,109.4 90.64,109.26 91.12,109.26 91.26,109.12 91.26,85.42 92.57,84.11 92.57,75.63 92.59,75.61 95.25,72.94 95.25,72.25 98.9,68.61 98.9,67.22 v3(99.15,66.98)
  BOTTOM w0.076: v1(93.52,124.51) U4555.BF11
  BOTTOM w0.109: CN4125.59 100.16,68.48 99.92,68.24 99.92,67.15 99.74,66.98 v3(99.15,66.98)
M_B_DQ<21>: length 72.4
  L3 w0.076: v3(99.06,65.59) 98.85,65.59 98.59,65.84 98.59,68.42 92.3,74.71 92.3,75.5 91.71,76.09 91.71,84.57 90.98,85.3 90.98,106.55 90.84,106.7 90.31,106.7 90.17,106.84 90.17,107.04 90.31,107.18 90.84,107.18 90.98,107.32 90.98,107.52 90.84,107.66 90.31,107.66 90.17,107.8 90.17,108 90.31,108.14 90.84,108.14 90.98,108.28 90.98,108.48 90.11,109.35 90.11,114.31 92.49,116.68 92.49,120.15 93.54,121.21 93.67,121.21 94.07,121.61 94.07,122.17 93.89,122.35 93.89,123.5 v1(93.52,123.87)
  BOTTOM w0.076: v1(93.52,123.87) U4555.BF10
  BOTTOM w0.109: CN4125.63 101.04,69.83 101.04,68.76 100.25,67.97 100.25,66.78 v3(99.06,65.59)
M_B_DQ<22>: length 69.7
  L3 w0.076: v3(96.87,64.86) 96.62,64.86 96.1,65.38 96.1,68.43 89.2,75.33 89.2,101.5 89.06,101.64 88.78,101.64 88.64,101.78 88.64,101.99 88.78,102.13 89.06,102.13 89.2,102.27 89.2,102.55 88.21,103.55 88.21,110.04 86.04,112.2 86.04,113.32 90.5,117.77 90.82,117.77 91.42,118.38 91.42,120.06 91.42,120.55 92.59,121.72 v1(92.59,121.92)
  BOTTOM w0.076: U4555.BG7 92.59,121.91 v1(92.59,121.92)
  BOTTOM w0.109: v3(96.87,64.86) 96.87,64.32 97.91,63.28 CN4125.50
M_B_DQ<23>: length 70.6
  L3 w0.076: v3(98.05,64.06) 97.99,64.12 97.99,68.23 91.15,75.07 91.15,84.24 90.42,84.98 90.42,103.07 89.4,104.09 89.4,111.63 89.26,111.77 88.61,111.77 88.46,111.92 88.46,112.12 88.61,112.26 89.26,112.26 89.4,112.4 89.4,112.6 89.26,112.74 88.61,112.74 88.46,112.88 88.46,113.08 88.61,113.22 89.26,113.22 89.4,113.36 89.4,114.51 92.05,117.16 92.05,120.27 93.52,121.74 v1(93.52,121.92)
  BOTTOM w0.076: v1(93.52,121.92) U4555.BF7
  BOTTOM w0.109: CN4125.58 99.91,63.06 98.9,64.06 v3(98.05,64.06)
M_B_DQ<24>: length 70.5
  L3 w0.076: v3(104.47,68.41) 103.91,68.96 103.91,69.78 102.4,71.29 102.4,71.44 102.47,71.52 102.47,71.66 102.36,71.77 102.19,71.77 102.13,71.71 101.97,71.71 101.86,71.83 101.86,71.98 102.01,72.14 102.01,72.29 101.9,72.41 101.74,72.41 101.59,72.25 101.43,72.25 100.74,72.95 100.74,73.11 101.17,73.55 101.17,73.7 101.06,73.81 100.9,73.81 100.47,73.38 100.31,73.38 100.2,73.49 100.2,73.65 100.63,74.08 100.63,74.24 100.52,74.35 100.37,74.35 99.93,73.92 99.77,73.92 99.66,74.03 99.66,74.19 100.1,74.62 100.1,74.78 99.98,74.89 99.83,74.89 99.39,74.45 99.23,74.45 99.12,74.57 99.12,74.72 99.56,75.16 99.56,75.32 99.44,75.43 99.29,75.43 98.85,74.99 98.69,74.99 98.49,75.19 98.49,84.16 95.17,87.48 95.17,112.2 97,114.04 97,120.43 97.2,120.62 97.2,122.09 96.87,122.42 96.87,123.02 96.8,123.09 96.8,123.7 96.73,123.77 96.73,124.06 v1(96.26,124.52)
  BOTTOM w0.076: v1(96.26,124.52) U4555.BB11
  BOTTOM w0.109: CN4125.79 105.16,68.79 104.77,68.41 v3(104.47,68.41)
M_B_DQ<25>: length 69.7
  L3 w0.076: v1(95.35,124.51) 94.9,124.06 94.9,123.76 94.81,123.67 94.81,122.45 94.5,122.13 94.5,121.53 94.34,121.38 94.34,120.25 93.6,119.15 93.6,115.91 91.78,114.08 91.78,85.6 91.78,85.6 91.78,85.58 93.07,84.29 93.07,75.81 99.65,69.23 99.65,65.84 99.96,65.53 99.96,64.01 100.08,63.9 v3(100.74,63.9)
  BOTTOM w0.076: v1(95.35,124.51) U4555.BC11
  BOTTOM w0.109: v3(100.74,63.9) 101.02,63.9 101.91,63.02 CN4125.66
M_B_DQ<26>: length 69.1
  L3 w0.076: v3(104.44,65.71) 103.72,65 103.49,65 103.35,65.13 103.35,69.52 97.12,75.75 97.12,84.55 94.61,87.06 94.61,112.48 96.39,114.27 96.39,120.63 96.69,120.93 96.69,122.03 96.31,122.42 v1(96.31,122.54)
  BOTTOM w0.076: v1(96.31,122.54) 96.23,122.54 U4555.BB8
  BOTTOM w0.109: v3(104.44,65.71) 106.41,63.75 CN4125.84
M_B_DQ<27>: length 68.7
  L3 w0.076: v3(100.76,65.81) 100.47,65.81 100.21,66.07 100.21,69.46 93.63,76.04 93.63,84.53 92.34,85.82 92.34,109.5 92.45,109.61 92.67,109.61 92.78,109.72 92.78,109.88 92.67,109.99 92.45,109.99 92.34,110.11 92.34,110.26 92.45,110.38 92.67,110.38 92.78,110.49 92.78,110.64 92.67,110.76 92.45,110.76 92.34,110.87 92.34,112.96 94.18,114.8 94.18,118.99 94.7,119.51 94.7,121.08 94.93,121.31 94.93,122.03 95.35,122.46 95.35,122.51 v1(95.37,122.52)
  BOTTOM w0.076: v1(95.37,122.52) 95.28,122.52 U4555.BC8
  BOTTOM w0.109: v3(100.76,65.81) 100.9,65.81 103.16,68.07 CN4125.71
M_B_DQ<28>: length 69
  L3 w0.076: v1(95.35,123.87) 94.99,123.52 94.99,122.36 94.7,122.06 94.7,121.39 94.52,121.21 94.52,120.09 93.81,119.03 93.81,115.72 92.06,113.97 92.06,85.7 93.35,84.41 93.35,75.93 99.93,69.34 99.93,65.95 101.05,64.84 v3(101.6,64.84)
  BOTTOM w0.076: v1(95.35,123.87) U4555.BC10
  BOTTOM w0.109: v3(101.6,64.84) 101.98,64.45 101.98,64.21 102.91,63.29 CN4125.70
M_B_DQ<29>: length 70.6
  L3 w0.076: v1(96.26,123.87) 96.64,123.5 96.64,123.02 96.71,122.95 96.71,122.29 96.95,122.05 96.95,120.81 96.68,120.54 96.68,114.13 94.89,112.34 94.89,87.17 97.4,84.66 97.4,82.09 97.51,81.98 97.95,81.98 98.06,81.87 98.06,81.71 97.95,81.6 97.51,81.6 97.4,81.49 97.4,81.33 97.51,81.22 97.95,81.22 98.06,81.11 98.06,80.95 97.95,80.84 97.51,80.84 97.4,80.73 97.4,80.57 97.51,80.46 97.95,80.46 98.06,80.34 98.06,80.19 97.95,80.08 97.51,80.08 97.4,79.96 97.4,76.99 97.62,76.76 97.62,76.39 97.4,76.17 97.4,75.87 103.63,69.64 103.63,66.68 103.78,66.53 104,66.53 104.47,67 v3(104.47,67.06)
  BOTTOM w0.076: v1(96.26,123.87) U4555.BB10
  BOTTOM w0.109: CN4125.83 106.16,68.75 v3(104.47,67.06)
M_B_DQ<30>: length 66.4
  L3 w0.076: v3(100.77,67.21) 100.56,67.43 100.56,69.51 100.49,69.57 93.91,76.16 93.91,81.85 94.02,81.97 94.58,81.97 94.69,82.08 94.69,82.24 94.58,82.35 94.02,82.35 93.91,82.46 93.91,82.62 94.02,82.73 94.58,82.73 94.69,82.84 94.69,83 94.58,83.11 94.02,83.11 93.91,83.22 93.91,84.64 93.06,85.49 93.06,111.21 92.93,111.34 92.73,111.34 92.62,111.45 92.62,111.61 92.73,111.72 92.93,111.72 93.04,111.83 93.04,111.99 92.93,112.1 92.73,112.1 92.62,112.21 92.62,112.77 94.46,114.61 94.46,118.88 94.86,119.28 94.86,120.93 95.35,121.42 v1(95.35,121.92)
  BOTTOM w0.076: v1(95.35,121.92) U4555.BC7
  BOTTOM w0.109: v3(100.77,67.21) 100.79,67.21 102.16,68.58 CN4125.67
M_B_DQ<31>: length 68.5
  L3 w0.076: v3(104.44,64.27) 104.44,64.1 104.14,63.8 103.46,63.8 103.07,64.18 103.07,69.41 96.84,75.64 96.84,81.78 96.73,81.89 96.39,81.89 96.28,82 96.28,82.16 96.39,82.27 96.73,82.27 96.84,82.39 96.84,84.43 94.33,86.94 94.33,112.73 96.07,114.46 96.07,120.67 96.3,120.91 v1(96.3,121.87)
  BOTTOM w0.076: U4555.BB7 v1(96.3,121.87)
  BOTTOM w0.109: CN4125.80 105.41,63.3 v3(104.44,64.27)
M_B_DQ<32>: length 73
  L3 w0.076: v3(134.16,68.17) 133.67,68.17 133.52,68.32 133.52,68.72 133.63,68.83 133.97,68.83 134.09,68.94 134.09,69.1 133.97,69.21 133.63,69.21 133.52,69.32 133.52,69.48 133.63,69.59 133.97,69.59 134.09,69.71 134.09,69.86 133.97,69.98 133.63,69.98 133.52,70.09 133.52,70.24 133.63,70.36 133.97,70.36 134.09,70.47 134.09,70.63 133.97,70.74 133.63,70.74 133.52,70.85 133.52,71.01 133.63,71.12 133.97,71.12 134.09,71.23 134.09,71.39 133.97,71.5 133.63,71.5 133.52,71.61 133.52,71.77 133.63,71.88 133.97,71.88 134.09,71.99 134.09,72.15 133.97,72.26 133.63,72.26 133.52,72.37 133.52,72.57 133.64,72.69 133.84,72.69 133.95,72.79 133.95,73 130.71,76.23 130.71,81.64 131.11,82.03 131.11,82.98 119.38,94.71 119.38,110.21 117.6,111.98 117.6,112.26 113.98,115.89 113.98,120.99 113.53,121.44 113.53,122.13 113.26,122.41 113.26,123.99 v1(112.72,124.52)
  BOTTOM w0.076: v1(112.72,124.52) U4555.AA11
  BOTTOM w0.109: v3(134.16,68.17) CN4125.187
M_B_DQ<33>: length 72.4
  L3 w0.076: v3(133.38,66.44) 133.38,66.38 133.6,66.16 133.95,66.16 134.09,66.3 134.09,67.13 133.99,67.22 133.34,67.22 133.24,67.32 133.24,73.3 130.44,76.11 130.44,82.26 130.55,82.37 130.72,82.37 130.83,82.48 130.83,82.64 130.72,82.75 130.55,82.75 130.44,82.86 130.44,83.26 118.94,94.75 118.94,110.19 117.31,111.83 117.31,112.29 113.81,115.79 113.81,120.91 113.34,121.38 113.34,122.04 113.09,122.29 113.09,123.51 v1(112.72,123.87)
  BOTTOM w0.076: v1(112.72,123.87) U4555.AA10
  BOTTOM w0.109: CN4125.183 133.16,66.67 v3(133.38,66.44)
M_B_DQ<34>: length 71.6
  L3 w0.076: v1(111.81,124.52) 111.36,124.07 111.36,123.72 111.22,123.58 111.22,122.39 111,122.17 111,121 111.59,120.4 111.59,114.86 112.53,113.92 112.53,113.3 116.06,109.77 116.06,93.86 126.41,83.51 126.41,76.2 127.75,74.85 129.08,73.52 129.08,65.98 129.64,64.62 v3(129.64,64.01)
  BOTTOM w0.076: v1(111.81,124.52) U4555.AC11
  BOTTOM w0.109: v3(129.64,64.01) 129.66,63.99 129.66,63.97 129.91,63.73 CN4125.170
M_B_DQ<35>: length 70.7
  L3 w0.076: v1(111.81,123.87) 111.39,123.45 111.39,122.32 111.22,122.15 111.22,121.11 111.82,120.51 111.82,114.9 112.78,113.93 112.78,113.51 116.36,109.93 116.36,93.98 126.7,83.65 126.7,76.3 127.95,75.05 129.38,73.62 129.38,66.43 v3(129.91,65.91)
  BOTTOM w0.076: v1(111.81,123.87) U4555.AC10
  BOTTOM w0.109: CN4125.169 129.66,69.8 129.58,69.72 129.58,66.24 v3(129.91,65.91)
M_B_DQ<36>: length 70.1
  L3 w0.076: v3(133.91,63.97) 133.38,63.97 132.68,64.66 132.68,73.07 129.88,75.88 129.88,83.02 118.28,94.62 118.28,110.06 116.54,111.8 116.31,111.8 112.85,115.26 112.85,121.24 112.72,121.36 112.72,121.86 v1(112.71,121.87)
  BOTTOM w0.076: v1(112.71,121.87) 112.66,121.87 U4555.AA7
  BOTTOM w0.109: CN4125.186 133.91,63.9 133.91,63.9 v3(133.91,63.97)
M_B_DQ<37>: length 70.5
  L3 w0.076: v3(133.28,65.07) 133.14,65.07 132.96,65.24 132.96,73.19 130.16,76 130.16,83.14 118.56,94.74 118.56,110.17 117.03,111.7 117.03,112.32 113.64,115.7 113.64,120.81 113.13,121.32 113.13,122.01 112.7,122.44 v1(112.7,122.54)
  BOTTOM w0.076: U4555.AA8 112.67,122.54 v1(112.7,122.54)
  BOTTOM w0.109: CN4125.182 132.86,61.54 132.86,64.86 133.07,65.07 v3(133.28,65.07)
M_B_DQ<38>: length 68.8
  L3 w0.076: v1(111.78,122.52) 111.78,122.44 111.4,122.06 111.4,121.27 112.04,120.62 112.04,114.9 113.05,113.9 113.05,113.6 116.7,109.95 116.7,94.12 126.99,83.83 126.99,76.41 128.15,75.25 129.66,73.73 129.66,72.68 130.43,71.92 130.43,70.05 130.28,69.91 129.8,69.91 129.66,69.77 129.66,69.57 129.8,69.42 130.28,69.42 130.43,69.28 130.43,69.08 130.28,68.94 129.8,68.94 129.66,68.8 129.66,67.6 v3(129.99,67.27)
  BOTTOM w0.076: U4555.AC8 v1(111.78,122.52)
  BOTTOM w0.109: CN4125.173 130.76,69.85 130.76,68.03 v3(129.99,67.27)
M_B_DQ<39>: length 68.9
  L3 w0.076: v3(130.91,63.96) 130.71,64.17 130.71,72.07 130,72.77 130,74.07 128.49,75.58 128.18,75.89 128.18,83.04 116.98,94.24 116.98,110.04 113.34,113.67 113.34,113.9 112.24,115.01 112.24,115.2 112.24,120.85 111.78,121.3 v1(111.78,121.9)
  BOTTOM w0.076: v1(111.78,121.9) U4555.AC7
  BOTTOM w0.109: v3(130.91,63.96) 130.91,63.96 CN4125.174
M_B_DQ<40>: length 73.2
  L3 w0.076: v3(135.62,66.6) 135.49,66.47 135.25,66.47 135.13,66.59 135.13,68.3 135.31,68.48 135.31,73.33 133.24,75.4 133.24,79.59 133.09,79.75 132.48,79.75 132.3,79.93 132.3,83.33 124.58,91.05 124.58,91.21 124.75,91.38 124.75,91.54 124.64,91.65 124.48,91.65 124.31,91.48 124.15,91.48 124.04,91.59 124.04,91.75 124.21,91.92 124.21,92.08 124.1,92.19 123.94,92.19 123.77,92.02 123.61,92.02 123.5,92.13 123.5,92.29 123.67,92.46 123.67,92.62 123.56,92.73 123.41,92.73 123.23,92.56 123.07,92.56 122.96,92.67 122.96,92.83 123.14,93 123.14,93.16 123.02,93.27 122.87,93.27 122.69,93.1 122.53,93.1 122.42,93.21 122.42,93.36 122.6,93.54 122.6,93.7 120.44,95.85 120.44,110.22 114.54,116.13 114.54,121.29 114.18,121.65 114.18,122.07 114.56,122.45 v1(114.56,122.52)
  BOTTOM w0.076: v1(114.56,122.52) 114.48,122.52 U4555.W8
  BOTTOM w0.109: CN4125.195 136.16,68.65 136.54,68.27 136.54,67.51 v3(135.62,66.6)
M_B_DQ<41>: length 72.7
  L3 w0.076: v3(135.59,67.93) 135.59,73.45 133.52,75.51 133.52,79.77 133.26,80.03 132.78,80.03 132.58,80.24 132.58,83.45 130.45,85.57 130.45,85.73 130.63,85.91 130.63,86.06 130.51,86.17 130.36,86.17 130.18,86 130.02,86 129.91,86.11 129.91,86.27 130.09,86.44 130.09,86.6 129.98,86.71 129.82,86.71 129.64,86.54 129.49,86.54 129.37,86.65 129.37,86.81 129.55,86.98 129.55,87.14 129.44,87.25 129.28,87.25 129.1,87.08 128.95,87.08 128.83,87.19 128.83,87.35 129.01,87.52 129.01,87.68 128.9,87.79 128.74,87.79 128.56,87.62 128.41,87.62 128.3,87.73 128.3,87.89 128.47,88.06 128.47,88.22 128.36,88.33 128.2,88.33 128.03,88.16 127.87,88.16 127.76,88.27 127.76,88.43 127.93,88.6 127.93,88.76 127.82,88.87 127.66,88.87 127.49,88.69 127.33,88.69 127.22,88.81 127.22,88.96 127.39,89.14 127.39,89.3 127.28,89.41 127.12,89.41 126.95,89.23 126.79,89.23 126.68,89.35 126.68,89.5 126.85,89.68 126.85,89.84 126.74,89.95 126.58,89.95 126.41,89.77 126.25,89.77 126.14,89.88 126.14,90.04 126.31,90.22 126.31,90.37 126.2,90.49 126.04,90.49 125.87,90.31 125.71,90.31 125.6,90.42 125.6,90.58 125.78,90.76 125.78,90.91 125.66,91.03 125.51,91.03 125.33,90.85 125.17,90.85 125.06,90.96 125.06,91.12 125.24,91.3 125.24,91.45 120.73,95.96 120.73,110.32 119.94,111.1 119.83,111.1 114.71,116.22 114.71,120.87 114.7,121.39 114.56,121.53 v1(114.56,121.85)
  BOTTOM w0.076: U4555.W7 114.45,121.85 v1(114.56,121.85)
  BOTTOM w0.109: CN4125.191 135.16,68.36 v3(135.59,67.93)
M_B_DQ<42>: length 74.5
  L3 w0.076: v1(115.47,123.87) 115.85,123.49 115.85,122.36 116.14,122.08 116.14,121.2 116.37,120.97 116.37,116.84 120.84,112.36 121.19,112.36 122.6,110.96 122.6,96.57 135.8,83.37 135.8,82.54 135.99,82.35 136.82,82.35 136.95,82.22 136.95,81.94 136.84,81.83 136.42,81.83 136.31,81.72 136.31,81.56 136.42,81.45 136.84,81.45 136.95,81.34 136.95,81.18 136.84,81.07 136.42,81.07 136.31,80.96 136.31,80.8 136.42,80.69 136.84,80.69 136.95,80.58 136.95,74.65 138.51,73.08 138.51,68.2 138.89,67.82 138.89,66.55 v3(138.66,66.31)
  BOTTOM w0.076: v1(115.47,123.87) U4555.V10
  BOTTOM w0.109: CN4125.207 139.16,66.81 v3(138.66,66.31)
M_B_DQ<43>: length 75.5
  L3 w0.076: v1(115.47,124.52) 116.03,123.96 116.03,122.47 116.32,122.18 116.32,121.28 116.56,121.04 116.56,116.88 120.89,112.55 121.41,112.55 122.88,111.08 122.88,96.7 137.24,82.34 137.24,74.78 138.81,73.21 138.81,70.81 138.92,70.7 139.06,70.7 139.17,70.58 139.17,70.43 139.06,70.31 138.92,70.31 138.81,70.2 138.81,70.04 138.92,69.93 139.06,69.93 139.17,69.82 139.17,69.66 139.06,69.55 138.92,69.55 138.81,69.44 138.81,69.28 138.92,69.17 139.06,69.17 139.17,69.06 139.17,68.9 139.06,68.79 138.92,68.79 138.81,68.68 138.81,68.52 138.92,68.41 139.06,68.41 139.17,68.3 139.17,64.23 v3(138.55,63.61)
  BOTTOM w0.076: v1(115.47,124.52) U4555.V11
  BOTTOM w0.109: v3(138.55,63.61) 138.41,63.46 CN4125.204
M_B_DQ<44>: length 75.4
  L3 w0.076: v3(135.36,64.01) 135.22,63.87 134.64,63.87 134.45,64.06 134.45,64.35 134.56,64.46 134.8,64.46 134.91,64.57 134.91,64.73 134.8,64.84 134.56,64.84 134.46,64.94 134.46,65.14 134.3,65.3 134.03,65.3 133.95,65.38 133.95,65.6 134.03,65.68 134.49,65.68 134.57,65.76 134.57,68.53 134.75,68.71 134.75,73.02 131.68,76.09 131.68,83.09 119.86,94.91 119.86,110.29 114.2,115.94 114.2,121.01 113.81,121.41 113.81,122.18 114.01,122.38 114.01,123.98 v1(114.55,124.52)
  BOTTOM w0.076: v1(114.55,124.52) U4555.W11
  BOTTOM w0.109: CN4125.190 134.91,63.56 v3(135.36,64.01)
M_B_DQ<45>: length 74.8
  L3 w0.076: v1(114.55,123.87) 114.18,123.5 114.18,122.3 114.02,122.14 114.02,121.58 114.37,121.22 114.37,116.05 120.14,110.29 120.14,95.02 120.34,94.82 120.5,94.82 120.71,95.03 120.86,95.03 120.98,94.92 120.98,94.76 120.77,94.56 120.77,94.4 120.88,94.29 121.04,94.29 121.25,94.5 121.4,94.5 121.52,94.38 121.52,94.23 121.31,94.02 121.31,93.86 121.42,93.75 121.58,93.75 121.79,93.96 121.94,93.96 122.05,93.84 122.05,93.69 121.85,93.48 121.85,93.32 131.96,83.21 131.96,76.29 135.03,73.22 135.03,68.6 134.85,68.41 134.85,66.1 135.64,65.31 v3(135.8,65.31)
  BOTTOM w0.076: v1(114.55,123.87) U4555.W10
  BOTTOM w0.109: v3(135.8,65.31) 135.91,65.2 CN4125.194
M_B_DQ<46>: length 72.3
  L3 w0.076: v1(115.49,121.9) 115.45,121.9 115.31,121.77 115.31,116.5 119.92,111.9 120.77,111.9 121.94,110.72 121.94,96.44 135.23,83.15 135.23,81.37 135.32,81.28 135.62,81.28 135.75,81.15 135.75,75.05 136.9,73.9 136.9,73.9 136.95,73.85 136.95,67.66 137.69,66.92 137.69,65.26 138,64.95 v3(138.63,64.95)
  BOTTOM w0.076: v1(115.49,121.9) 115.45,121.91 U4555.V7
  BOTTOM w0.109: CN4125.208 139.41,62.81 139.59,62.99 139.59,63.98 v3(138.63,64.95)
M_B_DQ<47>: length 73.1
  L3 w0.076: v3(138.28,67.58) 137.68,67.58 137.25,68.02 137.25,68.3 137.36,68.41 137.92,68.41 138.03,68.53 138.03,68.68 137.92,68.79 137.36,68.79 137.25,68.91 137.25,69.06 137.36,69.18 137.92,69.18 138.03,69.29 138.03,69.45 137.92,69.56 137.36,69.56 137.25,69.67 137.25,69.83 137.36,69.94 137.92,69.94 138.03,70.05 138.03,70.21 137.92,70.32 137.36,70.32 137.25,70.43 137.25,70.59 137.36,70.7 137.92,70.7 138.03,70.81 138.03,70.97 137.92,71.08 137.36,71.08 137.25,71.19 137.25,73.95 136.03,75.17 136.03,81.32 135.52,81.83 135.52,83.25 122.27,96.5 122.27,110.88 121.07,112.08 120.88,112.08 116.17,116.8 116.17,120.81 115.9,121.08 115.9,122.05 115.48,122.48 v1(115.48,122.58)
  BOTTOM w0.076: v1(115.48,122.58) U4555.V8
  BOTTOM w0.109: CN4125.203 138.16,67.7 v3(138.28,67.58)
M_B_DQ<48>: length 76.7
  L3 w0.076: v3(140.36,66.06) 139.87,66.56 139.87,72.84 137.72,74.99 137.72,82.63 123.36,96.99 123.36,105.33 123.47,105.45 123.99,105.45 124.11,105.56 124.11,105.71 123.99,105.83 123.47,105.83 123.36,105.94 123.36,106.1 123.47,106.21 123.99,106.21 124.11,106.32 124.11,106.48 123.99,106.59 123.47,106.59 123.36,106.7 123.36,111.28 121.88,112.75 120.97,112.75 116.76,116.96 116.76,121.16 116.51,121.41 116.51,122.21 116.78,122.47 116.78,123.59 116.86,123.67 116.86,124.09 v1(117.3,124.52)
  BOTTOM w0.076: v1(117.3,124.52) U4555.R11
  BOTTOM w0.109: v3(140.36,66.06) 140.85,66.06 141.16,66.37 CN4125.215
M_B_DQ<49>: length 76.4
  L3 w0.076: v1(118.21,124.52) 118.67,124.06 118.67,123.71 118.75,123.63 118.75,122.93 118.97,122.71 118.97,122.7 118.98,122.69 118.98,121.52 119.56,120.95 119.56,117.34 122.25,114.65 124.17,114.65 127.05,111.76 127.05,97.42 142.08,82.39 142.08,81.55 142.23,81.4 142.64,81.4 142.79,81.25 142.79,74.43 144.35,72.87 144.35,71.86 144.24,71.74 143.53,71.74 143.42,71.63 143.42,71.48 143.53,71.36 144.24,71.36 144.35,71.25 144.35,71.09 144.24,70.98 143.53,70.98 143.42,70.87 143.42,70.71 143.53,70.6 144.24,70.6 144.35,70.49 144.35,70.33 144.24,70.22 143.53,70.22 143.42,70.11 143.42,69.95 143.53,69.84 144.24,69.84 144.35,69.73 144.35,68.15 144.63,67.86 v3(144.66,67.86)
  BOTTOM w0.076: v1(118.21,124.52) U4555.P11
  BOTTOM w0.109: CN4125.229 144.66,67.87 v3(144.66,67.86)
M_B_DQ<50>: length 72.4
  L3 w0.076: v1(118.23,121.87) 118.23,121.28 118.7,120.81 118.7,117.44 122.03,114.11 123.52,114.11 126.21,111.41 126.21,97.04 141.19,82.06 141.19,74.4 142.45,73.14 142.45,69.11 143.51,68.06 143.51,67.43 143.64,67.3 143.64,64.08 v3(143.52,63.96)
  BOTTOM w0.076: U4555.P7 118.14,121.87 v1(118.23,121.87)
  BOTTOM w0.109: CN4125.224 143.41,63.85 v3(143.52,63.96)
M_B_DQ<51>: length 73
  L3 w0.076: v3(140.32,64.05) 140.73,64.05 140.98,64.3 140.98,72.53 139.17,74.34 139.17,81.99 124.69,96.48 124.69,106.91 123.92,107.67 123.92,111.51 122.2,113.23 121,113.23 117.22,117.01 117.22,121.32 116.92,121.63 116.92,122.05 117.3,122.43 117.3,122.5 117.32,122.52 v1(117.32,122.54)
  BOTTOM w0.076: U4555.R8 117.25,122.54 v1(117.32,122.54)
  BOTTOM w0.109: CN4125.212 140.44,61.53 140.44,63.93 v3(140.32,64.05)
M_B_DQ<52>: length 74.8
  L3 w0.076: v1(117.3,123.87) 116.94,123.52 116.94,122.39 116.71,122.16 116.71,121.49 117.02,121.18 117.02,116.97 120.97,113.02 122.01,113.02 123.64,111.39 123.64,107.56 124.4,106.8 124.4,105.3 124.12,105.03 123.75,105.03 123.64,104.92 123.64,104.76 123.75,104.65 124.13,104.65 124.24,104.54 124.24,104.38 124.12,104.27 123.75,104.27 123.64,104.16 123.64,104 123.75,103.89 124.13,103.89 124.24,103.78 124.24,103.62 124.12,103.5 123.75,103.5 123.64,103.39 123.64,103.24 123.75,103.12 124.13,103.12 124.23,103.02 124.23,102.86 124.11,102.74 123.75,102.74 123.64,102.63 123.64,102.47 123.75,102.36 124.13,102.36 124.23,102.26 124.23,102.1 124.11,101.98 123.75,101.98 123.64,101.87 123.64,97.13 124.76,96.01 124.76,95.99 138,82.75 138,75.1 140.19,72.91 140.19,67.61 v3(140.36,67.44)
  BOTTOM w0.076: v1(117.3,123.87) U4555.R10
  BOTTOM w0.109: v3(140.36,67.44) 140.16,67.64 CN4125.211
M_B_DQ<53>: length 75.3
  L3 w0.076: v1(118.22,123.93) 118.22,123.93 118.22,123.9 118.58,123.54 118.58,122.86 118.8,122.64 118.8,121.4 119.27,120.93 119.27,117.35 122.14,114.48 123.94,114.48 126.77,111.65 126.77,97.3 141.8,82.28 141.8,81.15 141.9,81.05 142.41,81.05 142.51,80.94 142.51,80.65 142.4,80.54 141.86,80.54 141.75,80.43 141.75,80.27 141.86,80.16 142.4,80.16 142.51,80.05 142.51,73.87 143.01,73.37 143.01,69.35 144.07,68.29 144.07,67.66 144.2,67.53 144.2,66.75 144.39,66.55 v3(144.49,66.55)
  BOTTOM w0.076: U4555.P10 v1(118.22,123.93)
  BOTTOM w0.109: CN4125.225 143.66,67.38 v3(144.49,66.55)
