# Allegro board PH317-53 COVINI-6050A3087701-MB-AX2 (BDV)(.BRD).brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
TOUCHPAD_I2C_INT#: length 107.6
  L8 w0.102: v3(116.89,34.04) 117.38,33.54 122.87,33.54 127.12,29.3 157.71,29.3 157.94,29.06 172.95,29.06 174.01,30.13 185.71,30.13 191.78,36.2 196.71,36.2 197.27,36.76 211.72,36.76 213.04,38.08 214.19,38.08 215.34,39.22 v1(215.34,39.5)
  BOTTOM w0.102: R281.1 v3(116.89,34.04) ; v1(215.34,39.5) 215.62,39.78 215.62,40.69 216.05,41.12 R312.2
TP: length 1.8
  TOP w0.102: v1(252.61,47.5) 253,47.5 TP4702.1
  BOTTOM w0.089: U4710.AN35 253.21,48.1 v1(252.61,47.5)
TP1: length 1.3
  TOP w0.102: v1(252.61,48.26) 252.47,48.4 TP4601.1
  BOTTOM w0.089: U4710.AL35 252.14,48.31 252.55,48.31 252.6,48.26 v1(252.61,48.26)
TP_CLK: length 92.5
  L3 w0.076: v3(132.58,32.97) 133.58,31.98 153.39,31.98 154.03,32.63 158.66,32.63 158.67,32.62 158.69,32.62 160.19,31.12 168.09,31.12 168.54,30.68 173.65,30.68 174.4,31.42 175.27,31.42 175.38,31.42 177.67,33.71 191.63,33.71 192.47,34.55 194.83,34.55 195.25,34.97 208.01,34.97 v1(209.11,36.07)
  BOTTOM w0.109: CN280.2 132.2,29.75 132.2,30.58 133.03,31.41 D283.1 133.03,32.53 v3(132.58,32.97) ; R304.1 210.28,42.99 210.22,42.93 210.22,42.24 209.82,41.84 209.82,40.81 U1.89 209.87,40.72 209.87,37.92 209.11,37.16 v1(209.11,36.07)
TP_D+: length 216.5
  L10 w0.084: v1(240.19,62.85) 240.09,62.75 239.41,62.75 239.18,62.99 237.44,62.99 236.05,64.38 220.4,64.38 218.11,66.66 218.11,69.3 217.58,69.83 215.9,69.83 214.74,70.99 214.74,70.99 214.52,71.21 160.5,71.21 160.5,71.21 156.88,71.21 155.38,69.71 155.38,64.25 152.71,61.58 89.37,61.58 89.14,61.35 89.14,61.35 85.09,57.3 77.34,57.3 76.51,56.47 46.48,56.47 46.21,56.74 45.38,56.74 v3(45.21,56.57)
  BOTTOM w0.089: U4710.G5 v1(240.19,62.85)
  BOTTOM w0.107: L3001.2 41.12,59.94 41.25,59.82 41.24,59.81 41.24,58.94 43.41,56.77 45.01,56.77 v3(45.21,56.57)
TP_D-: length 216.4
  L10 w0.084: v1(239.93,63.38) 239.98,63.32 239.98,63.21 239.74,62.96 239.5,62.96 239.26,63.2 237.53,63.2 236.14,64.59 220.48,64.59 218.32,66.75 218.32,69.38 217.66,70.04 215.98,70.04 214.95,71.07 214.6,71.42 160.59,71.42 156.8,71.42 155.17,69.8 155.17,64.34 152.62,61.79 89.28,61.79 88.93,61.44 85,57.51 77.25,57.51 76.42,56.68 46.57,56.68 46.29,56.95 45.36,56.95 45.18,57.13 v1(45.18,57.23)
  BOTTOM w0.089: U4710.G4 240.2,63.3 240,63.3 v1(239.93,63.38)
  BOTTOM w0.107: v1(45.18,57.23) 44.93,56.98 43.49,56.98 41.45,59.02 41.45,59.72 41.67,59.94 L3001.1
TP_DATA: length 95.2
  L3 w0.076: v3(130.76,32.97) 132.2,31.52 153.58,31.52 154.22,32.17 158.49,32.17 160,30.66 167.9,30.66 168.36,30.2 173.82,30.2 174.59,30.97 175.08,30.97 175.08,30.97 175.57,30.97 177.86,33.25 191.82,33.25 192.66,34.09 195.02,34.09 195.39,34.46 208.21,34.46 v1(209.83,36.07)
  BOTTOM w0.109: CN280.3 131.2,30.87 131.13,30.94 D283.2 131.13,32.6 v3(130.76,32.97) ; v1(209.83,36.07) 209.83,37.18 210.37,37.72 210.37,40.05 210.29,40.13 U1.90 210.26,40.76 210.26,41.24 210.31,41.29 210.31,41.63 210.72,42.04 210.72,42.73 211.17,43.18 R306.1
TP_I2C_CLK: length 12.9
  BOTTOM w0.109: 123.68,32.56 123.68,31.79 123.4,31.51 R290.2 123.19,30.76 v2(123.14,30.71) 122.33,30.71 Q281.4 ; 123.68,32.56 123.68,33.39 123.15,33.92 123.15,34.6 R287.1 ; 123.68,32.56 123.71,32.53 127.62,32.53 127.82,32.32 D282.2 127.82,30.95 128.2,30.58 128.2,29.75 CN280.6
TP_I2C_DAT: length 16.6
  BOTTOM w0.109: R288.1 119.8,34.65 R289.1 ; R288.1 v2(120.6,35.49) 125.45,35.49 129.2,31.74 D282.1 129.72,30.87 129.2,30.35 CN280.5 ; R288.1 120.6,33.96 120.76,33.81 Q281.1
TP_I2C_INT#: length 13.5
  BOTTOM w0.102: R286.2 R285.1 118.98,30.43 v2(119.35,30.05) 119.61,29.8 123.57,29.8 124.71,28.66 127.1,28.66 127.2,28.76 CN280.7 127.2,30.05 126.42,30.83 D281.1
TPM_PIRQ#: length 69.3
  L10 w0.102: v1(231.24,26.55) 231.72,26.55 233.73,28.55 234.96,28.55 235.67,29.26 240.79,29.26 241.45,29.92 246.94,29.92 252.05,35.03 254.14,35.03 258.72,39.6 259.98,39.6 262.07,41.69 262.07,45.42 262.4,45.75 262.4,47.77 262.09,48.09 259.86,48.09 259.61,48.34 259.61,53.77 256.88,56.49 253.31,56.49 251.77,58.03 v1(251.77,59.2)
  BOTTOM w0.089: U4710.AL15 252.03,58.08 251.76,58.35 251.76,59.11 251.77,59.12 v1(251.77,59.2)
  BOTTOM w0.102: U3500.18 232.25,25.82 231.65,26.42 231.65,26.42 231.52,26.55 v1(231.24,26.55) 230.53,26.55 v2(229.56,25.58) 229.3,25.32 229.3,24.66 R3500.1
TPM_SPI_CLK: length 7.7
  BOTTOM w0.109: U3500.19 232.75,26.05 231.64,27.16 229.97,27.16 229.03,26.22 229.03,25.86 228.19,25.02 v2(228.01,25.02) R3503.2
TPM_SPI_CS2#: length 4.2
  BOTTOM w0.109: U3500.20 233.25,26.03 233.24,26.05 233.24,26.26 v2(232.18,27.31) 231.92,27.57 R3501.1 231.92,28.1 R3504.2
TPM_SPI_SI: length 3.1
  BOTTOM w0.109: R3506.2 232.81,27.41 v2(233.47,26.76) 233.75,26.48 U3500.21
TPM_SPI_SO: length 3.9
  BOTTOM w0.109: U3500.24 235.54,25.09 236.65,25.09 v2(237.11,24.64) 237.04,24.57 R3505.2 237.04,23.03 R3502.1
TS: length 8
  TOP w0.102: R7602.2 23.75,29.41 D7600.2 24.03,30.52 R7603.1 C7600.1 23.94,33.07 v3(23.18,33.07) 23.14,33.1 R7604.2
  BOTTOM w0.102: CN6050.5 24.36,32.81 24.11,33.07 v3(23.18,33.07)
TURBO_KEY: length 30.8
  TOP w0.102: CN2.2 285.48,151.66 D1.2 v2(284.35,151.65) 283.74,151.04 283.74,147.96 282.9,147.12 270.99,147.12 266.65,142.78 SW1.4 265.37,142.67 264.9,142.19 263.3,142.19 262.82,142.67 SW1.3
TYPEC_1A5: length 122.4
  L5 w0.102: v1(295.25,27.61) 295.25,27.77 294.54,28.48 290.98,28.48 289.4,30.05 277.95,30.05 277.67,29.77 272.81,29.77 272.68,29.9 265.48,29.9 264.16,28.58 252.04,28.58 250.59,27.13 241.78,27.13 238.88,24.23 224.05,24.23 221.1,27.18 211.86,27.18 210.16,28.88 207.92,28.88 v1(207.13,29.67)
  L10 w0.102: v1(300.33,20.73) 299.23,21.82 299.23,22.94 297.02,25.15 297.02,26.44 295.86,27.61 v1(295.25,27.61)
  BOTTOM w0.102: Q6.G 298.69,26.5 298.25,26.94 297.47,26.94 297.15,27.26 295.75,27.26 295.4,27.61 v1(295.25,27.61) ; U1.88 209.49,40.27 209.39,40.17 209.39,38.12 207.87,36.6 207.87,33.13 207.13,32.39 v1(207.13,29.67) ; R2400.2 300.33,20.59 v1(300.33,20.73) 300.33,21.12 299.85,21.59 U8.9
TYPEC_3A: length 118.7
  L5 w0.102: v1(200.34,27.57) 201.44,28.67 210.08,28.67 211.77,26.98 221.02,26.98 223.97,24.03 238.97,24.03 241.85,26.91 250.66,26.91 251.3,27.55 267.9,27.55 269.92,29.57 277.75,29.57 277.93,29.75 279.41,29.75 280.93,28.22 293.87,28.22 294.96,27.13 v3(298.78,27.13)
  L10 w0.102: v1(301.04,21.21) 299.56,22.69 299.56,26.04 298.78,26.83 v3(298.78,27.13)
  BOTTOM w0.102: v1(301.04,21.21) 300.97,21.28 R2401.1 300.81,22.1 U8.8 ; v3(298.78,27.13) 299.08,26.83 300.28,26.83 301.03,26.07 Q5.G ; U1.33 199.87,26.73 200.34,27.21 v1(200.34,27.57)
TYPEC_CC1: length 18.1
  L8 w0.254: v1(300.38,22.61) 300.96,22.61 307.97,15.6 v3(309.55,15.6)
  BOTTOM w0.203: CN2500.A5 311.18,15.35 310.91,15.09 310.06,15.09
  BOTTOM w0.254: D7503.4 D7503.7 308.93,15.01 309.52,15.6 v3(309.55,15.6) 310.06,15.09 ; U8.7 v1(300.38,22.61) 300.74,22.61 C88.1
TYPEC_CC2: length 22.9
  L8 w0.254: v1(300.45,23.32) 301.93,23.32 308.4,16.84 308.4,16.15 v3(308.4,16.14)
  L10 w0.076: 312.91,12.88 312.92,12.9 313.15,13.44 313.15,13.45 CN2500.B5
  L10 w0.127: 312.77,12.7 312.91,12.88
  L10 w0.254: v3(308.4,16.14) 310.58,16.14 311.53,15.19 311.53,13.08 311.96,12.65 312.57,12.65 312.77,12.7
  BOTTOM w0.254: v3(308.4,16.14) 308.43,16.11 D7503.6 D7503.5 ; U8.6 299.77,23.12 299.97,23.32 v1(300.45,23.32) 300.86,23.73 C87.1
TYPEC_SET: length 23.7
  TOP w0.102: v1(304.33,10.95) U2500.5
  L10 w0.102: v1(301.06,27.74) 301.34,27.46 301.34,24.29 303.5,22.13 303.5,13.36 304.77,12.09 304.77,11.4 v1(304.33,10.95)
  BOTTOM w0.102: R2681.2 298.16,27.67 Q6.D 298.05,27.55 Q5.D 300.87,27.55 v1(301.06,27.74)
U63_STATUS#: length 2.2
  TOP w0.102: R2500.2 287.88,30.38 v2(287.78,30.48) 287.34,30.93 U2501.9
UART0_RXD: length 2
  TOP w0.102: v1(260.01,54.41) 260.01,53.87 TP4801.1
  BOTTOM w0.089: U4710.BE23 259.41,54.74 259.64,54.74 259.97,54.41 v1(260.01,54.41)
UART0_TXD: length 1.8
  TOP w0.102: v1(257.1,54.44) 257.71,53.83 TP4800.1
  BOTTOM w0.089: v1(257.1,54.44) 257.1,54.4 U4710.BB24
UNNAMED_65_PI3EQX12902A_I64_TES: length 1.6
  BOTTOM w0.102: U1700.5 98.75,38.05 98.74,38.04 98.74,37.87 98.6,37.72 TP1700.1
UNNAMED_122_CSC0402_I126_B: length 6
  BOTTOM w0.254: S15.1 300.69,170.11 v2(298.83,168.25) C25.2
UNNAMED_129_BEADSINGLE_I11_INB: length 0.9
  BOTTOM w0.381: 12.78,77.2 C6035.1 ; 10.85,81.03 C6036.1
  vias: v2(11.33,77.83)
UNNAMED_130_BQ24780S_I45_17: length 3.3
  BOTTOM w0.254: R60012.1 60.47,47.53 v2(60.2,47.26) 60.19,47.26 60.19,47.17 59.14,46.11 U60000.17
UNNAMED_130_CAPALSP_I76_A:
  vias: v2(49.2,34.06)
UNNAMED_130_CSC0603_I106_A: length 31
  L5 w0.254: v3(41.63,30.89) 41.63,33.07 45.16,36.6 54.78,36.6 62.23,44.05 62.23,46.84 v1(62.38,46.99)
  BOTTOM w0.254: R60012.2 62.38,47.11 v1(62.38,46.99)
UNNAMED_130_RSC0805_I54_B: length 3.7
  BOTTOM w0.254: R60009.2 51.38,40.05 v2(51.38,39.25) 53.77,39.25 D60000.3
UNNAMED_131_CN082G_I95_3: length 5.8
  TOP w0.109: R6051.2 29.6,33.74 28.74,33.74 C7601.1 28.54,32.84 D7601.2 28.99,32.15 v3(28.14,31.29)
  BOTTOM w0.109: v3(28.14,31.29) 28.14,31.37 28.14,31.37 28.14,32.22 CN6050.3
UNNAMED_131_CSC0603_I65_A: length 3.4
  BOTTOM w0.102: C60013.1 37.18,42.84 D60002.3 ; C60013.1 38.08,44.03 v2(38.2,44.15) ; C60013.1 36.29,44.03 R60017.2
UNNAMED_131_DDUALSERIESA_I76_A1: length 2.8
  BOTTOM w0.102: v2(47.58,45.93) D6098.1 47.02,47.33 46.44,46.75 Q60003.6
UNNAMED_131_DDUALSERIESA_I76_C: length 3.3
  BOTTOM w0.102: R6098.2 v2(47.62,50.96) 48.21,50.96 48.53,50.64 D6098.3
UNNAMED_131_NMOSDUALC_I67_D1: length 3.4
  BOTTOM w0.102: Q60002.5 Q60002.6 35.38,46.2 35.35,46.18 v2(35.35,45.7) 35.33,45.67 R60018.1 R60017.1
UNNAMED_131_NMOSDUALC_I67_D2: length 2.1
  BOTTOM w0.102: Q60002.3 36.73,48.55 36.97,48.31 R60026.2 v2(37.66,49.31)
UNNAMED_131_NMOSDUALC_I84_G1: length 4.4
  BOTTOM w0.102: v2(47.62,43.36) 47.58,43.41 R60023.1 R60024.1 47.1,45.57 46,45.57 45.79,45.37 Q60003.2
UNNAMED_131_NMOSDUALC_I84_G2: length 3.1
  BOTTOM w0.102: v2(46.28,49.61) 45.99,49.33 R60019.1 45.99,48.67 R60020.2 45.99,46.91 Q60003.5
UNNAMED_132_RSC0402_I42_B: length 2.7
  TOP w0.102: U60200.11 243.59,22.79 243.13,22.33 v2(243.13,21.9) 243.13,21.86 R60204.2
UNNAMED_132_RSCSHORT_I26_A: length 2
  TOP w0.254: U60200.14 245.34,21.44 245.11,21.21 R60203.1
UNNAMED_133_CSC0402_I21_A: length 4.3
  BOTTOM w0.254: v2(63.14,74.68) 63.42,74.95 C60281.1 63.42,75.81 62.42,76.81 62.23,76.81 61.62,77.42 U60250.13
UNNAMED_133_CSC0402_I21_B: length 1.6
  BOTTOM w0.254: R60289.1 v2(61.77,75.52) C60281.2
UNNAMED_133_POWERPAD40610_I32_3: length 10.2
  BOTTOM w0.254: PAD60250.3 52.36,76.12 v2(52.94,75.53) 53.36,75.11 59.69,75.11 R60289.2 R60253.2
UNNAMED_133_RSC0402_I17_B: length 2.7
  BOTTOM w0.254: v2(64.61,77.21) R60254.2 63.78,77.69 63.47,78 U60250.11
UNNAMED_133_RSCSHORT_I25_A: length 1.7
  BOTTOM w0.254: R60253.1 60.95,77.1 61.17,77.32 U60250.14
UNNAMED_134_CSC0402_I21_A: length 3.5
  TOP w0.254: U60100.10 193.78,27.19 193.3,27.68 C60109.1 193.3,28.54 R60110.1 194,28.64 R60199.1
UNNAMED_135_CSC0402_I18_B: length 13.8
  L10 w0.254: v1(75.08,86.59) 75.71,85.96 75.71,81.64 v1(74.06,79.99)
  BOTTOM w0.254: v1(75.08,86.59) 74.65,86.17 R60349.1 74.19,86.01 74.59,85.61 74.59,85.35 C60309.1 74.59,85.3 74.59,84.53 74.34,84.27 74.27,84.27 C60350.1 73.73,84.3 73.48,84.04 73.48,83.7 73.15,83.37 72.72,83.37 U60300.4 ; v1(74.06,79.99) 74.06,80.02 74.55,80.5 C60351.2
UNNAMED_135_CSC0402_I39_A: length 2.3
  BOTTOM w0.102: R60347.2 65.82,77.87 C60348.1 66.65,78.7 R60344.2
UNNAMED_135_RSC0402_I33_A: length 0.9
  BOTTOM w0.102: R60302.2 65.69,81.16 R60301.1
UNNAMED_139_CSC0402_I29_A: length 5.9
  BOTTOM w0.254: U60500.10 69.25,102.73 C60509.1 69.44,102.5 69.44,101.26 R60505.1 70.04,100.66 v2(70.81,100.66) 70.97,100.5 R60506.2
UNNAMED_140_CSC0402_I108_B: length 3.7
  TOP w0.254: U66000.48 83.98,161.61 84.45,161.14 v2(84.45,160.91) 84.49,160.88 C66652.2 84.49,159.21 R66651.1
UNNAMED_140_RSC0402_I179_B: length 54.2
  TOP w0.254: v1(85.98,155.65) R66652.2
  L5 w0.254: v3(135.38,160.28) 135.38,160.07 130.91,155.6 95.73,155.6 94.43,156.9 88.41,156.9 87.17,155.65 v1(85.98,155.65)
  BOTTOM w0.254: R66650.2 v3(135.38,160.28)
UNNAMED_141_CSC0402_I27_A: length 2.6
  BOTTOM w0.254: R66047.1 128.88,174.53 129.73,174.53 C66048.1 129.78,174.48 U66040.3
UNNAMED_141_CSC0402_I45_A: length 2.7
  BOTTOM w0.254: R66037.1 118.56,174.48 C66038.1
  BOTTOM w0.305: U66030.3 119.42,173.54 119.41,173.55 119.41,173.97 119.42,173.97 C66038.1
UNNAMED_141_CSC0402_I73_A: length 2.6
  BOTTOM w0.254: U66010.3 98.64,174.44 C66018.1 97.79,174.45 R66017.1
UNNAMED_141_CSC0402_I86_A: length 2.6
  BOTTOM w0.254: U66020.3 109,174.48 C66028.1 108.16,174.49 R66027.1
UNNAMED_141_NCP302035MNTXG_I3_G: length 0.8
  BOTTOM w0.254: U66030.33 117.79,170.33 U66030.27
UNNAMED_141_NCP302035MNTXG_I53_: length 0.8
  BOTTOM w0.254: U66010.33 97.7,170.3 U66010.27
UNNAMED_141_NCP302035MNTXG_I150: length 0.8
  BOTTOM w0.254: U66040.27 128.16,170.38 U66040.33
UNNAMED_141_NCP302035MNTXG_I151: length 0.8
  BOTTOM w0.254: U66020.33 107.38,170.33 U66020.27
UNNAMED_142_CSC0603_I5_A:
  vias: v2(83.08,145.88)
UNNAMED_142_NCP81151MNTBGDFN_I9: length 2.1
  BOTTOM w0.102: U66310.3 81.2,147.63 81.63,148.06 v2(82.29,148.06) 82.29,148.16 R66311.2
UNNAMED_144_J44894_I9_VSS1: length 5.5
  BOTTOM w0.089: U4710.A2 236.09,64.64 235.4,65.33
  BOTTOM w0.102: 235.4,65.33 235.4,67.92 TP4711.1
UNNAMED_144_J44894_I9_VSS10: length 4.2
  BOTTOM w0.089: 235.7,39.89 U4710.A48
  BOTTOM w0.102: 235.7,39.89 235.34,39.53 TP4710.1
UNNAMED_144_J44894_I9_VSS135: length 5.8
  BOTTOM w0.102: TP4708.1 264.21,66.3 262.91,66.3 262.18,65.56 260.91,65.56 260.34,65 U4710.BF1
UNNAMED_144_J44894_I11_VSS149: length 4.4
  BOTTOM w0.102: TP4709.1 263.15,39.41 263.03,39.41 260.71,41.72 U4710.BG48
UNNAMED_145_J44894_I27_GPPB18: length 7.7
  BOTTOM w0.102: U4710.BE30 259.58,50.82 259.72,50.68 261.7,50.68 262.06,51.03 264.28,51.03 264.73,51.48 264.73,51.91 v2(264.97,52.15) 265.69,52.15 R4802.2
UNNAMED_145_J44894_I27_GPPC10: length 2.3
  TOP w0.102: v1(256.51,54.44) 256.51,54.97 TP4803.1
  BOTTOM w0.089: U4710.BA24 256.65,53.76 256.51,53.9 v1(256.51,54.44)
UNNAMED_145_J44894_I27_GPPC11: length 3.1
  TOP w0.102: TP4802.1 254.35,56.01 v1(254.35,55.99)
  BOTTOM w0.089: v1(254.35,55.99) 254.35,54.19 U4710.AP24
UNNAMED_151_CN282G_I20_28: length 5.5
  BOTTOM w0.254: R254.2 R255.2 106.64,35.13 106.62,35.11 106.6,35.11 106.6,35.11 C251.1 D258.1 105.25,35.11 v2(105.25,34.01) CN250.28
UNNAMED_151_CSC0402_I5_A: length 3
  BOTTOM w0.102: R253.2 153.7,35.08 v2(152.98,35.08) 153.01,35.06 C255.1 153.49,34.29 153.66,34.12 Q250.1
UNNAMED_151_NMOSC_I3_D: length 7.9
  BOTTOM w0.102: Q251.D 158.17,32.25 157.73,32.69 157.73,34.95 v2(157.36,35.33) 156.87,35.82 155.7,35.82 155.48,35.6 R251.2 R253.1
UNNAMED_152_RSC0402_I29_A: length 3.7
  BOTTOM w0.102: R286.1 117.38,31.48 117.8,31.91 R280.2 R281.2 116.43,32.57 116.43,32.57 R282.1
UNNAMED_153_1222UYOSUBCS530A4_1: length 42.9
  TOP w0.254: v1(311.08,95.9) 311.08,93.47 312.34,92.21 312.34,88.72 D101.3
  L8 w0.254: v3(286.38,105.77) 288.74,105.77 290.06,104.45 290.06,97.08 291.36,95.79 310.97,95.79 v1(311.08,95.9)
  BOTTOM w0.254: R100.2 285.67,105.06 v3(286.38,105.77)
UNNAMED_153_1222UYOSUBCS530A4TR: length 44.8
  TOP w0.254: v1(312.05,95.55) 312.05,93.31 313.35,92.01 D101.2
  L8 w0.254: v1(280.6,102.86) 281.1,103.36 285.78,103.36 286.69,102.45 286.69,99.45 287.12,99.01 287.25,99.01 290.86,95.39 311.89,95.39 v1(312.05,95.55)
  BOTTOM w0.254: v2(280.67,100.87) 280.6,100.94 R103.2 280.6,102.86 v1(280.6,102.86)
UNNAMED_153_LEDSINGLE_I35_A1: length 49.1
  TOP w0.254: v3(273.12,101.63) 273.35,101.85 R105.2 ; v1(312.87,95.65) 313.16,95.65 D102.1
  L8 w0.254: v3(273.12,101.63) 274.82,99.92 274.82,98.87 274.8,98.85 274.8,94.55 275.22,94.14 275.23,94.14 275.26,94.11 277.16,94.11 277.69,94.64 289.99,94.64 290.34,94.29 292.15,94.29 292.86,95 312.22,95 v1(312.87,95.65)
UNNAMED_153_NMOSC_I26_D: length 2.4
  TOP w0.254: v2(273.1,99.55) 273.66,99.55 274.19,100.08 Q102.D 274.26,100.68 R105.1
UNNAMED_153_NMOSDUALC_I22_D1: length 2
  BOTTOM w0.254: R103.1 281.45,102.27 v2(281.2,102.52) 281.1,102.62 281.1,103.41 Q101.6
UNNAMED_153_NMOSDUALC_I22_D2: length 2.1
  BOTTOM w0.254: Q101.3 v2(283.49,105.37) 283.8,105.06 R100.1
UNNAMED_155_CN102G_I26_1: length 0.4
  BOTTOM w0.381: C1701.1 266.29,28.89
  vias: v2(266.47,29.8)
UNNAMED_158_CSC0402_I363_A: length 2
  TOP w0.102: U1300.6 267.56,21.98 v2(267.74,21.8) 268.43,21.8 C1301.1
UNNAMED_158_NMOS_I353_D: length 9.4
  TOP w0.102: U1300.3 264.11,21.98 v1(263.93,21.8) 263.75,21.62 R1300.1 ; Q1300.3 270.01,20.97 269.87,20.83 269.03,20.83 v1(268.63,21.24)
  L3 w0.102: v1(268.63,21.24) 268.07,21.8 266.9,21.8 266.52,21.42 264.31,21.42 v1(263.93,21.8)
UNNAMED_158_NPND_I59_B: length 2.1
  TOP w0.102: R1360.1 280.97,20.81 v2(280.97,20.19) Q1314.1
UNNAMED_160_APCI0020P003A_I103_: length 2
  BOTTOM w0.381: C1933.1 65.02,34.76 ; C1932.1 65.91,34.76 ; 65.66,53.51 C1913.1 ; C1936.1 66.99,53.91 ; C1931.1 66.82,34.76
  vias: v2(65.25,35.54) v2(66.39,52.61)
UNNAMED_160_NMOS_I89_G: length 20.7
  BOTTOM w0.102: CN1901.69 81.2,52.05 82.42,50.83 87.27,50.83 v2(88.46,52.01) 88.82,52.38 R1905.1 89.33,52.83 88.58,53.58 88.58,54.55 88.78,54.76 Q1900.1 92.17,54.76 R1906.2
UNNAMED_161_APCI0020P003A_I118_: length 2.2
  BOTTOM w0.381: 178.76,40.42 C1902.1 ; C1900.1 180.2,40.82 ; 178.85,22.1 C1937.1 ; 177.43,40.82 C1901.1 ; 179.94,22.11 C1908.1
  vias: v2(177.82,23.3) v2(179.83,39.81)
UNNAMED_162_CSC0402_I53_A: length 2.1
  BOTTOM w0.107: R2505.1 303.6,22.12 303.6,22.68 R2507.1 303.4,22.88 C2509.1
UNNAMED_162_CSC0402_I54_A: length 2.1
  BOTTOM w0.107: R2504.1 304.09,22.12 304.09,22.68 R2506.1 304.29,22.88 C2510.1
UNNAMED_162_CSC0402_I124_A: length 2
  TOP w0.107: R2512.1 304.64,22.82 R2508.1 304.82,23.79 C2500.1
UNNAMED_162_CSC0402_I125_A: length 2
  TOP w0.107: R2513.1 305.79,22.82 R2509.1 305.61,23.79 C2511.1
UNNAMED_162_G518B1TP1U_I112_4: length 29.1
  TOP w0.102: R2411.2 304.06,12.24 304.33,11.97 v1(304.33,11.9) U2500.4
  L10 w0.102: v1(304.33,11.9) 304.33,11.97 303.3,13 303.3,19.64 302.61,20.32 299.67,20.32 298.9,21.09 298.9,22.69 295.65,25.94 295.65,26.57 294.69,27.54 294.69,28.78 295.09,29.19 v3(295.09,30.31)
  BOTTOM w0.102: U2502.4 295.96,32.62 295.45,32.11 295.45,30.66 v3(295.09,30.31)
UNNAMED_162_NMOSC_I83_S: length 2
  BOTTOM w0.102: R2649.2 300.33,24.54 v2(299.67,24.54) 299.73,24.6 Q5.S
UNNAMED_162_NMOSC_I84_S: length 2.1
  BOTTOM w0.102: R2680.2 297.61,24.21 v2(297.25,24.57) 297.39,24.71 Q6.S
UNNAMED_162_RSC0402_I41_B: length 3.1
  BOTTOM w0.102: U8.2 296.01,21.59 295.68,21.26 295.68,20.2 v2(295.55,20.07) R2410.2
UNNAMED_162_RSC0402_I90_A: length 2.3
  BOTTOM w0.102: R2402.1 298.49,19.99 298.59,19.89 v2(299.31,19.89) 299.54,20.12 U8.10
UNNAMED_164_PS8713BTQFN24GTR2_1: length 3.4
  BOTTOM w0.102: U2401.3 281.01,116.26 v2(280.77,116.51) 281.2,116.93 R2418.1
UNNAMED_164_PS8713BTQFN24GTR2_2: length 2.8
  BOTTOM w0.102: R2417.1 281.99,117.42 v2(281.99,116.86) 282.09,116.76 U2401.4
UNNAMED_164_PS8713BTQFN24GTR2_3: length 2.8
  BOTTOM w0.102: R2415.1 281.99,118.62 v2(281.99,118.13) 281.99,118.01 282.74,117.26 U2401.5
UNNAMED_164_PS8713BTQFN24GTR2_4: length 2.9
  BOTTOM w0.102: U2401.6 283.11,118.53 v2(282.27,119.37) 281.94,119.7 R2416.1
UNNAMED_164_PS8713BTQFN24GTR2_5: length 2.3
  BOTTOM w0.102: U2401.7 283.86,118.68 283.51,119.03 v2(283.51,119.64) 283.51,119.78 R2414.1
UNNAMED_164_PS8713BTQFN24GTR2_6: length 2.7
  BOTTOM w0.102: R2412.2 289.05,117.04 v2(288.39,117.69) 287.96,117.26 U2401.14
UNNAMED_164_PS8713BTQFN24GTR2_7: length 2.7
  BOTTOM w0.102: U2401.15 287.91,116.76 v2(288.24,116.43) 289.03,115.64 R2413.2
UNNAMED_164_PS8713BTQFN24GTR2_8: length 2.7
  BOTTOM w0.102: U2401.16 287.43,116.26 288.24,115.45 v2(288.24,115.16) 288.24,114.94 R2406.2
UNNAMED_164_PS8713BTQFN24GTR2_9: length 3.3
  BOTTOM w0.102: R2407.2 288.26,113.54 v2(287.84,113.96) 287.75,114.05 287.75,115.57 287.56,115.76 U2401.17
UNNAMED_164_PS8713BTQFN24GTR2A2: length 2.1
  BOTTOM w0.102: U2401.2 282.15,115.76 v2(281.96,115.57) 281.86,115.68 R2409.1
UNNAMED_164_PS8713BTQFN24GTR_10: length 3.8
  BOTTOM w0.102: R2408.2 288.19,112.65 288.13,112.7 v2(287.65,112.7) 287.11,113.24 U2401.18
UNNAMED_165_PS8713BTQFN24GTR2_1: length 7.5
  TOP w0.102: R2427.1 289.35,118.98 289.79,118.55 290.98,118.55 291.56,119.13 v2(291.56,119.46) 292.35,119.46 292.71,119.1 293.65,119.1 293.85,119.31 293.85,119.76 293.51,120.11 U2403.3
UNNAMED_165_PS8713BTQFN24GTR2_2: length 6.8
  TOP w0.102: U2403.4 294.01,119.99 294.15,119.84 294.15,119.18 294.97,118.37 295.56,118.37 295.66,118.47 297.56,118.47 R2426.1
UNNAMED_165_PS8713BTQFN24GTR2_3: length 6.1
  TOP w0.102: U2403.5 294.51,119.59 v2(294.66,119.43) 294.74,119.36 295.65,119.36 295.83,119.18 297.91,119.18 298.25,119.52 298.25,120.05 R2420.1
UNNAMED_165_PS8713BTQFN24GTR2_4: length 5.5
  TOP w0.102: R2421.1 297.91,121.34 297.46,120.88 297.46,119.89 v2(297.66,119.69) 297.43,119.46 295.93,119.46 295.01,120.38 U2403.6
UNNAMED_165_PS8713BTQFN24GTR2_5: length 2.8
  TOP w0.102: R2419.1 298.15,122.19 297.26,121.3 296.91,121.3 ; U2403.7 296.91,121.3 ; 296.91,121.3 v2(296.92,121.29)
UNNAMED_165_PS8713BTQFN24GTR2_6: length 3.2
  TOP w0.102: R2404.2 296.03,126 v2(296.03,125.63) 295.55,125.15 294.69,125.15 294.51,124.97 U2403.14
UNNAMED_165_PS8713BTQFN24GTR2_7: length 2.3
  TOP w0.102: U2403.15 294.01,124.95 294.71,125.66 294.76,125.66 v2(294.76,125.66) 294.76,126.38 R2405.2
UNNAMED_165_PS8713BTQFN24GTR2_8: length 2
  TOP w0.102: U2403.16 293.51,125.64 v2(293.49,125.66) 293.81,125.97 R2422.2
UNNAMED_165_PS8713BTQFN24GTR2_9: length 2.6
  TOP w0.102: U2403.17 293.01,125 292.35,125.66 v2(292.22,125.66) 292.92,126.35 R2423.2
UNNAMED_165_PS8713BTQFN24GTR2A2: length 4.4
  TOP w0.102: U2403.2 293.01,120.19 292.76,119.94 291.94,119.94 291.54,120.35 290.57,120.35 v2(290.45,120.48) 290.42,120.45 R2428.1
UNNAMED_165_PS8713BTQFN24GTR_10: length 3.4
  TOP w0.102: U2403.18 291.65,124.55 v2(291.06,125.14) 291.64,125.72 291.64,126.06 R2424.2
UNNAMED_166_CHOKE4PINC_I129_INB: length 7.4
  BOTTOM w0.107: CN5.17 37.45,65.21 37.6,65.07 37.6,63.88 39.09,62.39 41.15,62.39 41.29,62.25 41.29,62.14 41.12,61.97 L3001.3
UNNAMED_166_CHOKE4PINC_I129_IND: length 7.4
  BOTTOM w0.107: CN5.16 37.95,65.21 37.8,65.07 37.8,63.96 39.17,62.59 41.24,62.59 41.5,62.33 41.5,62.14 41.67,61.97 L3001.4
UNNAMED_166_CHOKE4PINC_I150_INB: length 7.3
  BOTTOM w0.107: L3002.3 34.77,62.86 34.94,63.03 34.94,63.15 34.84,63.25 34.27,63.25 33.93,62.91 32.36,62.91 31.09,64.18 31.09,65.07 30.95,65.21 CN5.30
UNNAMED_166_CHOKE4PINC_I150_IND: length 7.3
  BOTTOM w0.107: L3002.4 35.32,62.86 35.15,63.03 35.15,63.23 34.92,63.46 34.18,63.46 33.84,63.12 32.45,63.12 31.3,64.27 31.3,65.07 31.45,65.21 CN5.29
UNNAMED_166_CN405G_I84_34: length 0.9
  TOP w0.381: v1(27.89,64.88) 27.68,64.67 C3012.1
UNNAMED_166_CN405G_I84_39: length 30.5
  TOP w0.381: v5(23.77,65.5) C3010.1 24.87,65.68 C3009.1
  BOTTOM w0.102: CN5.39 CN5.40
  BOTTOM w2.032: 22.43,70.42 24.36,72.34 36.65,72.34 42.59,78.28 FUSE3000.2
  vias: v2(21.23,67.14)
UNNAMED_166_CSC0402_I36_A: length 3.1
  BOTTOM w0.102: R40.1 17.09,76.38 v2(17.09,77.09) ; U3000.3 17.11,77.11 v2(17.09,77.09) ; v2(17.09,77.09) 17.72,77.09 C3003.1
UNNAMED_166_FUSE_I171_1:
  vias: v2(47.77,85.2)
UNNAMED_166_NCT3521U_I118_4: length 4.9
  BOTTOM w0.102: U3000.4 17.11,80.29 17.28,80.12 20.18,80.12 v2(20.27,80.04) 20.83,80.6 R3004.1
UNNAMED_166_NCT3521U_I118_OUT: length 1.7
  BOTTOM w0.381: v2(21.33,79.2) 21.68,79.55 R3004.2
UNNAMED_169_C17711120A9L_I187_1: length 4.4
  TOP w0.102: R56202.2 306.14,48.46 307.03,49.35 v2(308.1,49.35) CN56200.19
UNNAMED_169_C17711120A9L_I187_6: length 1.8
  BOTTOM w0.102: R56201.2 305.97,53.67 306.09,53.55 CN56200.6
UNNAMED_169_NCT3521U_I119_3: length 3.2
  BOTTOM w0.102: R56251.1 299.77,33.91 v2(299.51,34.17) 299.04,34.64 R56290.1 298.4,34.37 U56250.3
UNNAMED_171_AZ104504FR7G_I85_1: length 10.1
  TOP w0.076: v1(305.79,74.72) 305.58,74.5 304.95,74.5 304.84,74.61 D56650.10 D56650.1 302.98,74.61 302.79,74.43 302.27,74.43 R56681.2
  L3 w0.076: CN56600.1 308.43,76.31 308.22,76.31 308.07,76.46 308.07,76.72 307.72,77.07 306.8,77.07 306.41,76.68 306.41,74.68 306.29,74.55 305.96,74.55 v1(305.79,74.72)
UNNAMED_171_AZ104504FR7G_I85_2: length 10.1
  TOP w0.076: R56682.2 302.37,74.19 302.89,74.19 302.89,74.19 302.98,74.11 D56650.2 D56650.9 304.84,74.11 305,74.27 305.59,74.27 v1(305.79,74.06)
  L3 w0.076: CN56600.3 308.44,76.08 308.12,76.08 307.84,76.36 307.84,76.62 307.63,76.83 306.9,76.83 306.65,76.58 306.65,74.58 306.39,74.32 306.05,74.32 v1(305.79,74.06)
UNNAMED_171_AZ104504FR7G_I85_4: length 9.1
  TOP w0.076: v1(305.82,73.17) 305.6,72.95 305,72.95 304.84,73.11 D56650.7 D56650.4 303.08,73.11 302.9,72.93 300.67,72.93 R56683.2
  L8 w0.076: v1(305.82,73.17) 306.03,72.95 306.21,72.95 306.36,73.1 306.36,74.58 306.62,74.83 306.9,74.83 CN56600.4
UNNAMED_171_AZ104504FR7G_I85_5: length 9.1
  TOP w0.076: v1(305.82,72.51) 305.61,72.72 304.95,72.72 304.84,72.61 D56650.6 D56650.5 303,72.61 302.92,72.7 300.78,72.7 R56684.2
  L8 w0.076: CN56600.6 306.87,74.6 306.72,74.6 306.6,74.48 306.6,73 306.31,72.72 306.03,72.72 v1(305.82,72.51)
UNNAMED_171_AZ104504FR7G_I86_1: length 17.9
  TOP w0.076: R56685.2 300.72,71.08 302.95,71.08 303.13,71.26 D56651.1 D56651.10 304.87,71.26 304.95,71.18 305.6,71.18 v1(305.79,71.37)
  L8 w0.076: CN56600.7 308.43,73.31 308.23,73.31 307.95,73.03 307.95,67.7 307.7,67.45 306.85,67.45 306.6,67.69 306.6,70.86 306.32,71.15 306.01,71.15 v1(305.79,71.37)
UNNAMED_171_AZ104504FR7G_I86_2: length 18
  TOP w0.076: R56686.2 300.72,70.84 302.92,70.84 303,70.76 D56651.2 D56651.9 304.87,70.76 305.05,70.94 305.59,70.94 305.79,70.74 v1(305.79,70.71)
  L8 w0.076: v1(305.79,70.71) 305.79,70.79 305.91,70.91 306.22,70.91 306.36,70.77 306.36,67.6 306.75,67.21 307.8,67.21 308.18,67.6 308.18,72.93 308.32,73.07 308.45,73.07 CN56600.9
UNNAMED_171_AZ104504FR7G_I86_4: length 7.8
  TOP w0.076: R56687.2 302.01,69.93 302.32,69.62 302.87,69.62 303,69.76 D56651.4 D56651.7 304.87,69.76 304.98,69.65 305.58,69.65 v1(305.79,69.86)
  L3 w0.076: v1(305.79,69.86) 306.03,69.63 306.24,69.63 306.34,69.73 306.34,71.53 306.65,71.83 306.9,71.83 CN56600.10
UNNAMED_171_AZ104504FR7G_I86_5: length 7.8
  TOP w0.076: v1(305.79,69.2) 305.58,69.42 305.03,69.42 304.87,69.26 D56651.6 D56651.5 303.03,69.26 302.9,69.39 302.35,69.39 302,69.04 R56688.2
  L3 w0.076: CN56600.12 306.87,71.6 306.74,71.6 306.57,71.43 306.57,69.63 306.34,69.4 305.99,69.4 v1(305.79,69.2)
UNNAMED_171_CN194G_I167_13: length 9.2
  BOTTOM w0.102: TP56630.1 305.05,63.58 308.12,66.65 308.12,70 CN56600.13
UNNAMED_171_CN194G_I167_14: length 3.9
  BOTTOM w0.102: CN56600.14 306.37,69.3 306.37,68.96 305.66,68.25 304.77,68.25 TP56631.1
UNNAMED_171_NMOS2D2SDIODE_I12_1: length 3.2
  TOP w0.102: Q56670.5 301.63,67.25 v1(301.34,66.96) 301.63,66.67 Q56670.2
  BOTTOM w0.102: R56670.1 300.98,67.65 v2(301.07,67.56) 301.34,67.29 v1(301.34,66.96)
UNNAMED_171_NMOS2D2SDIODE_I12_2: length 3
  TOP w0.109: R56679.1 302.19,66.18 Q56670.3 302.13,65.31 v2(302.21,65.23) 301.8,64.82 R56680.1
UNNAMED_171_NMOS2D2SDIODE_I12_3: length 6.2
  TOP w0.109: Q56670.4 302.13,67.02 v1(302.04,66.93)
  BOTTOM w0.109: v1(302.04,66.93) 302.04,68.31 R56675.1 301.92,68.47 300.66,69.73 v2(300.4,69.73) R56674.2 R56676.2
UNNAMED_171_NMOS2D2SDIODE_I12_4: length 3.3
  TOP w0.109: Q56670.6 300.13,67.63 v2(300.02,67.75) 299.08,67.75 R56677.1 R56678.1
UNNAMED_171_NMOS2D2SDIODE_I126_: length 3.9
  TOP w0.109: Q56670.1 301.13,65.42 v2(300.93,65.22) 300.89,65.18 R56672.1 300,64.44 R56671.2 299.54,64.89 299.54,65.21 R56673.2
UNNAMED_171_NMOS2D2SDIODE_I170_: length 6.1
  BOTTOM w0.102: R56690.1 304.23,72.85 v2(304.59,72.85) 304.95,72.5 304.95,70.87 304.16,70.08 Q56690.2 Q56690.5
UNNAMED_172_CSC0402_I14_A: length 28.8
  TOP w0.254: v1(228.11,20.45) 228.11,20.25 228.5,19.87 235.86,19.87 236.45,20.45 236.45,25.58 236.78,25.91 v1(236.8,25.91)
  BOTTOM w0.254: 235.33,28.1 C3504.1 C3505.1 233.7,27.84 234.16,27.38 234.16,26.22 234.25,26.13 U3500.22 ; 235.33,28.1 236.12,28.89 v2(236.12,29.7) PAD3500.2 ; 235.33,28.1 236.7,26.73 236.7,26.01 v1(236.8,25.91) ; U3500.8 230.19,20.39 229.97,20.18 C3500.1 C3503.1 228.39,20.18 v1(228.11,20.45)
UNNAMED_206_CSC0402_I359_A: length 3.3
  TOP w0.107: U400.36 280.68,100.31 280.58,100.41 280.07,100.41 279.97,100.51 279.81,100.51 279.05,101.27 278.91,101.27 C402.1
UNNAMED_206_CSC0402_I360_A: length 3.3
  TOP w0.107: C400.1 278.91,101.48 279.14,101.48 279.9,100.72 280.05,100.72 280.15,100.62 280.59,100.62 280.68,100.71 U400.35
UNNAMED_206_E2500RIV1RL_I357_10: length 6.2
  TOP w0.254: U400.10 286.05,97.59 v2(287.17,97.59) 287.29,97.59 287.85,97.03 288.21,97.03 288.49,96.75 289.79,96.75 290.31,96.22 290.31,95.89 290.36,95.84 R407.2
UNNAMED_206_NPND_I342_B: length 2.4
  BOTTOM w0.102: v2(292.07,94.62) 291.51,94.05 R416.1 290.87,94.05 290.21,93.4 Q402.1
UNNAMED_259_CSC0402_I133_A: length 1.8
  BOTTOM w0.381: 288.1,98.89 C401.1 288.1,99.34 ; 288.1,98 C433.1 287.7,97.55
  vias: v2(287.92,101.44)
UNNAMED_259_CSC0402_I152_A: length 3.3
  BOTTOM w0.381: C478.1 C479.1 297.74,93.75 v2(297.68,93.81) 297.17,94.32 C429.2
UNNAMED_259_CSC1206_I129_A: length 10.8
  TOP w0.508: v1(299.87,96.53) 299.87,98.83 R412.2 299.03,100.91 299.02,100.92 R413.2 v2(299.02,103.28) R414.2 R415.2
  BOTTOM w0.381: C429.1 v1(299.87,96.53)
UNNAMED_259_NA0069RLF_I116_16: length 4.9
  TOP w0.508: R414.1 v3(296.87,104.5)
  BOTTOM w0.508: v3(296.87,104.5) 296.87,106.3 297.91,107.34 U401.16
UNNAMED_259_NA0069RLF_I116_21: length 2.7
  TOP w0.508: v3(297.18,100.99) 297.82,101.63 R413.1
  BOTTOM w0.508: U401.21 v3(297.18,100.99)
UNNAMED_259_NA0069RLF_I116_22: length 3.3
  TOP w0.508: v3(297.3,98.61) 297.3,99.15 R412.1
  BOTTOM w0.508: v3(297.3,98.61) 297.3,99.06 297.96,99.72 U401.22
UNNAMED_259_NA0069RLF_I116_TXTC: length 4.3
  TOP w0.508: v1(297.13,107.67) v2(297.13,106.86) 297.13,106.34 R415.1
  BOTTOM w0.508: U401.15 297.91,108.61 297.13,107.83 v1(297.13,107.67)
UNNAMED_262_RSC0402_I121_B: length 4
  BOTTOM w0.102: R4454.1 144.57,119.49 145.78,120.69 R4452.2 146.41,120.34 146.56,120.19 U4450.6
UNNAMED_263_CSC0402_I83_A: length 3.2
  BOTTOM w0.102: Q701.1 136.42,31.66 v2(136.42,30.86) ; v2(136.42,30.86) 136.78,30.51 C700.1 ; v2(136.42,30.86) 136.2,31.09 R702.2
UNNAMED_263_NMOSC_I75_D: length 3.9
  BOTTOM w0.102: R705.2 135.12,30.24 135.12,30.24 R702.1 135.6,30.24 136.29,29.54 v2(136.85,29.54) 136.9,29.54 137.32,29.12 Q702.D
UNNAMED_263_RSC0402_I11_B: length 2.4
  BOTTOM w0.102: v2(141.53,42.67) R704.2 141.54,41.83 U702.30
UNNAMED_263_RSC0402_I17_A: length 2.7
  BOTTOM w0.102: R703.1 136.7,38.67 137.05,39.02 v2(137.05,39.5) U702.24
UNNAMED_264_CSC0402_I125_B: length 4.3
  BOTTOM w0.102: U1.12 208.28,25.12 208.28,24.66 208.36,24.58 208.36,24.3 208.38,24.28 208.38,24.16 208.96,23.57 209.39,23.57 v2(209.52,23.45) 209.78,23.19 210.53,23.19 C303.2
UNNAMED_264_CSC0402_I634_A: length 4.1
  BOTTOM w0.109: R331.2 210.18,22.66 C315.1 209.11,22.66 207.87,23.9 207.87,25.12 U1.13
UNNAMED_264_IT8987ECX_I608_ADC1: length 8.6
  BOTTOM w0.102: U1.67 201.09,41.56 200.58,42.07 199.39,42.07 198.52,42.93 194.97,42.93 v2(194.81,42.78) 194.61,42.57 R307.1
UNNAMED_264_IT8987ECX_I608_ID5: length 3
  BOTTOM w0.102: R312.1 216,40.17 216,39.17 v2(215.77,38.94) 215.56,38.73 U1.98
UNNAMED_264_IT8987ECX_I608_LPCP: length 2.9
  BOTTOM w0.102: R315.1 R316.1 206.63,23.64 206.29,23.98 U1.17
UNNAMED_264_IT8987ECX_I608_LPCR: length 1.7
  BOTTOM w0.102: R347.2 204.59,23.92 204.29,24.22 U1.22
UNNAMED_264_IT8987ECX_I608_PWRS: length 2.8
  BOTTOM w0.102: U1.107 215.72,35.13 v2(215.77,35.08) 216.18,35.49 R333.1
UNNAMED_265_ANDGATE_I549_1: length 2.3
  BOTTOM w0.102: U7006.1 68.95,89.5 R7063.2 R7068.2
UNNAMED_265_ANDGATE_I549_4: length 3.6
  BOTTOM w0.102: R7069.1 71.2,90.91 U7006.4 71.18,91.55 71.07,91.65 70.17,91.65 69.72,92.1 R7070.1
UNNAMED_265_APL3523A_I456_8:
  vias: v2(225.57,33.89)
UNNAMED_265_APL3523A_I456_10: length 2.1
  BOTTOM w0.102: C7012.1 228.3,35.77 v2(228.3,35.11) 228.3,34.82 228.29,34.82 228.29,34.3 228.3,34.3 U2.10
UNNAMED_265_APL3523A_I456_12: length 3.2
  BOTTOM w0.102: v2(230.39,36.16) 230.1,35.87 C7013.1 229.1,35.42 229.1,34.3 229.1,34.3 U2.12
UNNAMED_265_APL3523A_I456_13:
  vias: v2(231.01,34.55)
UNNAMED_265_APL3523A_I457_3: length 2.4
  BOTTOM w0.102: R7029.2 278.46,65.59 278.72,65.33 U7002.3
UNNAMED_265_APL3523A_I457_5: length 3.6
  BOTTOM w0.102: U7002.5 279.52,63.88 279.7,64.07 279.7,65.54 R38.2 v2(280.9,65.94)
UNNAMED_265_APL3523A_I457_10: length 3.1
  BOTTOM w0.102: U7002.10 279.52,61 279.6,60.91 279.6,60.45 279.86,60.19 279.86,59.33 C7014.1 v2(280.67,59.33)
UNNAMED_265_APL3523A_I457_12: length 2.2
  BOTTOM w0.102: C131.1 278.96,60.07 v2(278.92,60.11) 278.72,60.31 U7002.12
UNNAMED_265_APL3523A_I457_13:
  vias: v2(276.65,61.42)
UNNAMED_265_APL3523A_I458_5: length 5.7
  TOP w0.102: R37.2 231.03,48.74 C7032.1 ; C7032.1 229.74,49.15 229.74,51.71 229.58,51.87 U7003.5 ; C7032.1 229.63,48.74 v2(229.31,48.42)
UNNAMED_265_APL3523A_I458_10: length 4.2
  TOP w0.102: C17.1 230.93,56.47 v2(229.83,56.47) 229.58,56.22 U7003.10
UNNAMED_265_APL3523A_I458_12: length 4.1
  TOP w0.102: U7003.12 228.78,55.08 v2(229.03,55.32) 229.05,55.35 229.05,56.42 229.69,57.06 C7035.1
UNNAMED_265_CSC0402_I502_B: length 4
  BOTTOM w0.102: v2(71.04,96.24) 71.02,96.23 C4626.2 ; C4626.2 71,95.43 R7038.1 69.49,95.43 Q7006.6 ; C4626.2 71.26,95.17 Q7007.G
UNNAMED_265_NMOSDUALC_I506_D2: length 4.3
  BOTTOM w0.102: R7039.1 69.74,92.59 68.65,92.59 68.48,92.76 Q7006.2 Q7006.3 67.11,93.16 v2(66.67,93.6)
UNNAMED_266_CSC0402_I474_A: length 3.7
  BOTTOM w0.102: v2(190.45,33.86) 190.62,33.68 R6900.1 191.08,33.07 191.08,33.07 R6901.1 191.47,33.07 R7037.2 191.87,31.78 C7023.1
UNNAMED_266_NMOSC_I493_D: length 3.3
  BOTTOM w0.102: R7033.1 v2(188.87,30.41) 188.79,30.41 188.08,31.12 Q7003.D
UNNAMED_266_RSC0402_I167_A: length 1.6
  TOP w0.102: R7017.2 v2(212.47,19.92) R7002.1
UNNAMED_266_RSC0402_I374_A: length 2.5
  BOTTOM w0.102: R7014.2 221.36,29.21 v2(221.38,29.19) 221.48,29.09 R7019.1 R7021.1
UNNAMED_266_RSC0402_I529_A: length 2.5
  BOTTOM w0.102: R7027.1 94.56,56.04 v2(94.56,55.73) 94.96,55.34 D7001.3
UNNAMED_275_NMOSDUALC_I208_D2: length 2.6
  BOTTOM w0.102: Q4751.3 Q4751.2 65,67.07 R4742.2 64.76,66.16 v2(64.61,66.02)
UNNAMED_277_J43242_I59_RSVD6: length 9.5
  TOP w0.102: TP4528.1 126.69,109.15 126.69,117.25 v1(126.62,117.33)
  BOTTOM w0.076: U4555.B2 126.62,117.88 v1(126.62,117.33)
UNNAMED_277_J43242_I59_RSVD8: length 3.1
  TOP w0.102: v1(127.83,143.34) 127.99,143.18 TP4527.1
  BOTTOM w0.076: U4555.B38 127.54,144.31 127.83,144.02 v1(127.83,143.34)
UNNAMED_277_J43242_I59_RSVD16: length 11.4
  TOP w0.102: v1(85.05,116.78) 83.05,114.78 TP4526.1
  BOTTOM w0.076: U4555.BP1 87.48,117.34 86.99,116.86 86.58,116.86 86.58,116.85 85.13,116.85 v1(85.05,116.78)
UNNAMED_280_J43242_I30_VSSBR38: length 3.2
  TOP w0.102: v1(84.96,143.26) TP4525.1
  BOTTOM w0.254: U4555.BR38 85.61,144.31 84.96,143.67 v1(84.96,143.26)
UNNAMED_281_J44894_I301_GPPH12: length 7.9
  BOTTOM w0.089: 245.36,39.09 245.69,39.42 245.69,39.65 246.94,40.9 247.29,40.9 247.48,41.09 247.48,41.41 247.42,41.47 247.42,42.25 U4710.AB47
  BOTTOM w0.102: R4835.1 244.95,36.42 244.93,36.44 v2(244.93,36.86) 244.93,37.14 245.11,37.32 245.11,38.84 245.36,39.09
UNNAMED_281_J44894_I301_GPPH15: length 10.2
  BOTTOM w0.089: U4710.AC47 248.17,42.3 248.08,42.21 248.08,41.85 247.83,41.61 247.83,40.53 247.16,39.86 246.5,39.86 245.74,39.09
  BOTTOM w0.102: R4834.1 246.36,34.93 v2(245.79,34.93) 245.51,35.21 245.51,38.87 245.74,39.09
UNNAMED_281_J44894_I301_SPI0CLK: length 6.2
  BOTTOM w0.089: U4710.AW47 256.11,42.63 255.73,42.25 255.73,40.14
  BOTTOM w0.109: 255.73,40.14 255.73,39.83 254.89,38.99 v2(254.89,38.33) 254.48,37.93 R136.2
UNNAMED_281_J44894_I301_SPI0CS0: length 5.2
  BOTTOM w0.109: U4710.AY47 256.29,42.15 256.29,38.42 v2(256.19,38.31) 256.18,38.3 R135.2
UNNAMED_281_J44894_I301_SPI0IO2: length 6.8
  BOTTOM w0.109: U4710.AY48 256.49,41.85 256.49,40.03 256.97,39.55 256.97,37.28 256.99,37.26 v2(256.99,36.91) 256.65,36.57 256.65,36.13 256.33,35.81 R4701.2
UNNAMED_281_J44894_I301_SPI0IO3: length 7.9
  BOTTOM w0.109: R4721.2 257.22,36.27 257.49,36.53 257.49,37.81 257.46,37.85 v2(257.46,38.33) 257.46,39.47 256.69,40.24 256.69,41.62 257.09,42.01 257.09,42.64 U4710.BA46
UNNAMED_281_J44894_I301_SPI0MIS: length 12.3
  TOP w0.109: v1(256.54,43.57) 256.99,43.12 256.99,33.21 v2(257.25,32.95) 257.17,32.87 R134.2
  BOTTOM w0.109: U4710.BA45 256.81,43.57 v1(256.54,43.57)
UNNAMED_281_J44894_I301_SPI0MOS: length 13
  TOP w0.109: R133.2 256.45,33.87 v2(256.23,34.09) 256.1,34.22 256.1,42.07 254.75,43.42 254.75,44.09 254.88,44.22 v1(254.88,44.23)
  BOTTOM w0.109: v1(254.88,44.23) 254.89,44.24 254.89,44.28 255.13,44.52 255.13,44.52 255.27,44.66 U4710.AU41
UNNAMED_282_J44894_I161_GPPF15: length 7
  BOTTOM w0.089: U4710.AV47 255.55,42.5 255.55,40.24 254.41,39.09
  BOTTOM w0.102: R4720.1 253.62,37.06 v2(253.62,38.23) 253.62,38.3 254.41,39.09
UNNAMED_282_J44894_I161_GPPF16: length 2.4
  TOP w0.089: v3(255.24,49.09) 255.3,49.09 R4726.1
  BOTTOM w0.089: U4710.AR35 254.57,48.53 254.92,48.53 255.24,48.85 v3(255.24,49.09)
UNNAMED_282_J44894_I161_GPPF17: length 2
  TOP w0.089: R4727.1 254.45,48.46 v3(255.11,47.81)
  BOTTOM w0.089: U4710.AR37 254.81,47.5 v3(255.11,47.81)
UNNAMED_282_J44894_I161_GPPF18: length 12.7
  TOP w0.102: v1(256.51,44.2) 257.02,43.69 257.02,43.49 257.22,43.29 257.22,34.7 v2(257.83,34.09) 258.21,33.71 R4728.1
  BOTTOM w0.089: v1(256.51,44.2) 256.5,44.19 256.02,44.19 U4710.AV43
UNNAMED_283_CSC0402_I158_B: length 5.1
  BOTTOM w0.089: U4710.B38 237.97,46.85 237.74,46.85 237.23,46.34 237.21,46.34 237.19,46.32
  BOTTOM w0.107: C4960.2 234.15,45.55 234.31,45.4 234.86,45.4 235.01,45.55 235.22,45.55 235.36,45.4 235.57,45.4 235.72,45.55 235.93,45.55 236.07,45.4 236.27,45.4 236.46,45.59 236.46,45.81 236.61,45.96 236.83,45.96 237.19,46.32
UNNAMED_283_CSC0402_I159_B: length 5.2
  BOTTOM w0.089: 237.34,46.17 237.35,46.19 237.35,46.21 237.81,46.67 238.18,46.67 U4710.C38
  BOTTOM w0.107: 237.34,46.17 236.35,45.19 234.51,45.19 C4961.2
UNNAMED_284_CSC0402_I129_A: length 186
  L5 w0.076: v1(257.63,41.41) 256.31,40.1 251.65,40.1 250.99,40.76 246.92,40.76 246.16,40 238.8,40 237.22,38.41 232.45,38.41 232.37,38.48 227.71,38.48 227.64,38.42 212.53,38.42 211.72,37.61 208.27,37.61 207.33,38.55 203.06,38.55 202.9,38.7 199.53,38.7 197.39,40.83 190.4,40.83 189.52,41.72 187.9,41.72 187.58,41.41 185.56,41.41 184.05,42.92 167.33,42.92 167.24,42.83 148.69,42.83 147.29,41.43 143.71,41.43 142.86,42.28 141.87,42.28 141.54,42.61 131.58,42.61 131.3,42.33 107.65,42.33 v1(104.14,45.85)
  BOTTOM w0.089: U4710.BB46 257.73,42.11
  BOTTOM w0.102: v1(257.63,41.41) 257.73,41.51 257.73,42.11
  BOTTOM w0.109: v1(104.14,45.85) 102.05,47.94 102.05,57.12 103.15,58.22 111.14,58.22 C4802.1 R4770.1 R4771.1
UNNAMED_284_J44894_I164_GPPA8: length 1.5
  TOP w0.089: R4909.1 255.2,50.76 v1(255.32,50.63)
  BOTTOM w0.089: U4710.AV32 255.32,50.15 v1(255.32,50.63)
UNNAMED_285_J44894_I143_GPPA10: length 2.1
  TOP w0.109: R4800.1 258.73,48.79 v2(258.65,48.71) 258.51,48.57 v1(258.01,48.57)
  BOTTOM w0.109: v1(258.01,48.57) 257.65,48.93 U4710.BB34
UNNAMED_285_RSC0402_I265_B: length 1.1
  TOP w0.089: R4800.2 260.09,50.07 TP4804.1
UNNAMED_285_RSC0402_I283_B: length 4.1
  TOP w0.102: R4813.2 R4723.2 266.95,48.48 266.96,48.49 R4873.1 267.31,49.13 v2(267.11,49.33) 267.08,49.36 v1(267.08,49.99)
  BOTTOM w0.102: R4908.1 266.75,49.71 267.03,49.99 v1(267.08,49.99)
UNNAMED_286_CSC0402_I598_A: length 3.1
  TOP w0.254: R4906.1 253.21,50.96 v3(252.91,50.65) 252.91,50.07 C4871.1
  BOTTOM w0.254: v3(252.91,50.65) 253.25,50.31 U4710.AN32
UNNAMED_289_ALC255CG_I118_CBN: length 2.8
  TOP w0.254: U500.35 21.21,52.93 22.07,52.07 v2(22.07,52) C511.2
UNNAMED_289_ALC255CG_I118_CBP: length 5.7
  TOP w0.254: v1(22.12,53.7) 22.12,53.72 22.31,53.92 U500.37 ; v1(22.62,49.8) C511.1
  L3 w0.254: v1(22.12,53.7) 22.12,53.68 22.81,52.99 22.81,49.99 v1(22.62,49.8)
UNNAMED_289_ALC255CG_I118_CPVEE: length 2.6
  TOP w0.254: C503.2 21.15,51.23 21.15,52.43 20.81,52.78 U500.34
UNNAMED_289_ALC255CG_I118_HP: length 3.2
  TOP w0.254: U500.13 15.72,58.72 v2(15.36,59.08) 14.39,59.08 R504.1 14.35,59.04 R502.1
UNNAMED_289_ALC255CG_I118_LDO1: length 4.6
  TOP w0.254: U500.27 18.01,52.95 17.56,52.49 16.79,52.49 16.59,52.29 v2(16.55,52.29) 16.15,52.29 15.8,51.95 R531.1
  TOP w0.381: R531.1 15.77,51.47 16.17,51.07 C501.1
UNNAMED_289_ALC255CG_I118_LDO2: length 4.5
  TOP w0.254: C512.2 24.46,52.58 v2(23.82,53.21) 23.82,53.54 23.57,53.8 23.57,54.48 22.92,55.12 U500.39
UNNAMED_289_ALC255CG_I118_LDO3: length 3.2
  TOP w0.102: U500.7 19.28,59.49 19.28,59.88 19.28,60.07 19.28,60.57 18.89,60.95 18.89,60.95 v2(18.87,60.98) 18.87,61.02 18.67,61.22 18.67,61.74 C530.1
UNNAMED_289_ALC255CG_I118_MIC: length 2.9
  TOP w0.254: U500.19 15.6,56.32 15.22,55.95 v2(14.83,55.95) 13.77,55.95 C531.1
UNNAMED_289_ALC255CG_I118_NC: length 3.3
  TOP w0.254: R514.1 14.52,54.72 15.73,55.92 U500.20
UNNAMED_289_ALC255CG_I118_PCBEE: length 2.7
  TOP w0.102: U500.12 17.21,59.7 16.58,60.33 v2(16.02,60.33) 15.59,60.33 C507.1
UNNAMED_289_ALC255CG_I118_SPDIF: length 3.6
  TOP w0.102: R501.1 13.83,57.59 15.01,57.59 v2(15.24,57.81) 15.35,57.92 U500.15
UNNAMED_289_ALC255CG_I118_VREF: length 2.8
  TOP w0.254: U500.28 18.41,52.79 17.8,52.18 v2(17.8,51.92) 17.8,51.9 17.6,51.7 C502.2
UNNAMED_289_CSC0402_I68_B: length 4.4
  TOP w0.102: v2(13.38,63.38) 13.58,63.18 C506.2 13.58,62.54 R503.1 R505.1 14.28,60.76 R521.1 14.35,60.07 14.36,60.07 C507.2
UNNAMED_314_CSC0402_I14_A: length 3.4
  TOP w0.254: R67009.2 135.86,59.14 C67009.1 135.61,58.89 135.61,58.07 v2(135.66,58.02) 135.25,57.61 U67000.12
UNNAMED_314_CSC0402_I47_A: length 4.5
  TOP w0.102: U67000.40 136.25,52.01 v2(137.07,51.19) 137.29,50.96 C67082.1 R67013.1 138.88,50.89 R67012.2
UNNAMED_314_CSC0402_I55_A: length 5.3
  TOP w0.102: U67000.33 132.85,51.3 132.51,50.96 132.51,50.02 v2(132.15,49.66) 131.98,49.49 C67081.1 R67004.1 R67005.2
UNNAMED_314_CSC0402_I81_A: length 1.9
  TOP w0.102: C67080.1 127,52.28 v2(127.58,51.69) 128.06,52.17 R67080.2
UNNAMED_314_MP2886AGUZ_I21_PSI: length 3.5
  TOP w0.102: U67000.37 134.45,51.6 134.86,51.18 135.1,51.18 135.3,50.98 v2(135.3,49.94) 135.68,49.56 R67008.2
UNNAMED_314_MP2886AGUZ_I21_PWMV: length 3.9
  TOP w0.102: U67000.39 135.25,51.65 135.51,51.39 136.24,51.39 136.6,51.03 v2(136.6,49.94) R67010.2
UNNAMED_314_MP2886AGUZ_I21_VFB: length 4
  TOP w0.102: U67000.29 130.95,53.06 130.76,52.86 130.76,52.45 v2(130.12,51.82) 129.62,51.32 R67094.2 128.5,51.32 128.5,51.32 R67080.1
UNNAMED_314_RSC0402_I74_B: length 0.8
  TOP w0.102: R67092.1 127,53.94 127.49,53.94 127.52,53.91 R67091.2
UNNAMED_315_NMOS_I101_D: length 5.3
  TOP w0.254: v1(157.86,44.89) 157.6,44.63 Q5000.4
  BOTTOM w0.254: v1(157.86,44.89) 156.45,43.48 R5000.2 156.73,42.9 v2(157.22,42.9) 157.94,42.9 Q5001.3
UNNAMED_315_NMOS_I101_G: length 1.3
  BOTTOM w0.102: R5001.2 158.35,39.97 Q5001.1
UNNAMED_318_RSC0402_I4_A: length 0.7
  BOTTOM w0.102: R67212.1 R67206.2
UNNAMED_318_RSC0603_I39_A: length 3.1
  BOTTOM w0.254: U67200.15 239,75.67 238.74,75.42 238.1,75.42 v2(237.59,74.91) 237.16,74.48 R67225.1
UNNAMED_318_RSC0603_I40_A: length 3
  BOTTOM w0.254: R67215.1 236.84,80.38 v2(237.69,79.53) 237.82,79.4 238.19,79.4 239,78.59 U67200.1
UNNAMED_319_CSC0402_I39_A: length 20.8
  L3 w0.254: v3(153.8,173.51) 153.23,172.95 153.23,163.2 152.45,162.41 147.52,162.41 147.12,162.81 v1(147.12,164.95)
  BOTTOM w0.254: v3(153.8,173.51) C67601.1 153.8,172.92 R67600.1
UNNAMED_319_CSC0603_I29_A:
  vias: v2(154.81,168.79)
UNNAMED_398_CSC0402_I129_A: length 7.3
  TOP w0.091: C51631.1 300.93,53.41 300.93,55.94 Q51661.2 300.93,57.27 300.93,57.28 300.77,57.44 300.77,59.16 Q51660.3
UNNAMED_398_CSC0402_I130_A: length 7.4
  TOP w0.091: C51630.1 300.73,53.6 300.73,57.2 300.01,57.93 Q51641.2 300.58,58.56 300.58,59.09 Q51640.3
UNNAMED_399_N18EG1KDQSA1_I74__1: length 1.9
  TOP w0.102: v6(160.93,119.43) 160.76,119.26 160.76,118.6 R51751.2
  BOTTOM w0.102: U50000.AW10 160.6,119.1 v6(160.93,119.43) 160.6,119.77 U50000.AW11
UNNAMED_399_N18EG1KDQSA1_I74__2: length 31.7
  TOP w0.102: v1(156.05,120.12) 156.05,118.56 157.23,117.39 157.23,115.75 157.07,115.58 157.07,108.41 161.96,103.52 161.96,99.53 159.79,97.36 159.04,97.36 157.93,96.24 v2(157.93,94.8) R51753.2
  BOTTOM w0.102: U50000.BE12 156.05,120.14 v1(156.05,120.12)
UNNAMED_399_N18EG1KDQSA1_I74_US: length 1.8
  TOP w0.102: v6(158.13,122.9) 158.24,123.02 R51750.2
  BOTTOM w0.102: U50000.BC15 158.12,122.9 v6(158.13,122.9) 158.45,122.58 U50000.BB15
UNNAMED_400_IT66317FN0003R_I566: length 3.2
  TOP w0.102: v2(293.23,69.45) R56412.2 293.23,70.71 293.18,70.76 293.18,70.8 292.38,71.6 U56400.13
UNNAMED_402_CSC0201_I296_A: length 3.3
  BOTTOM w0.254: U52000.27 147.42,51.17 v2(148.14,51.89)
  BOTTOM w0.279: v2(148.14,51.89) 148.14,51.9 C52000.1 R52000.1
UNNAMED_402_CSC0402_I282_B: length 4.5
  BOTTOM w0.102: R52014.2 146,44.53 R52013.1 146,46.31 C52014.2 146,47.28 v2(146.21,47.48) 145.66,48.03 U52000.3
UNNAMED_402_CSC0402_I285_B: length 13.7
  L8 w0.102: v1(142.52,46.84) 142.16,46.84 v3(140.13,48.87)
  BOTTOM w0.102: R52081.1 139.86,52.33 139.86,49.14 v3(140.13,48.87) 140.21,48.79 R52080.1 ; R52024.2 142.3,44.63 C52024.2 142.3,45.54 142.29,45.54 R52023.1 142.29,46.62 v1(142.52,46.84) 143.66,47.98 144.14,47.98 144.46,48.3 U52000.6
UNNAMED_402_NCP45491XMNTWG_I2_1: length 3
  BOTTOM w0.102: R52081.2 141.8,52.71 v2(141.93,52.58) 142.34,52.18 142.34,51.71 142.87,51.17 U52000.14
UNNAMED_402_NCP45491XMNTWG_I2_3: length 3
  BOTTOM w0.102: U52000.9 143.02,49.18 142.19,48.34 v2(142.19,48.29) 141.17,47.27 R52001.2
UNNAMED_402_NCP45491XMNTWG_I2_4: length 4.1
  BOTTOM w0.102: R52011.2 148.84,47.73 v2(148.43,48.14) 148.31,48.14 147.73,48.71 U52000.1
UNNAMED_402_NCP45491XMNTWG_I2_5: length 2.6
  BOTTOM w0.102: R52021.2 145.18,46.87 v2(145.01,47.04) 145.26,47.3 U52000.4
UNNAMED_402_NCP45491XMNTWG_I2_6: length 3.3
  BOTTOM w0.102: R52012.2 147.95,46.82 v2(147.52,47.25) 146.63,48.14 146.3,48.14 146.06,48.38 U52000.2
UNNAMED_402_NCP45491XMNTWG_I2_7: length 3.2
  BOTTOM w0.102: R52022.2 144.29,46.66 v2(143.74,47.22) 143.88,47.22 144.86,48.19 U52000.5
UNNAMED_402_NCP45491XMNTWG_I2_8: length 4.2
  BOTTOM w0.102: R52006.1 R52007.1 148,53.98 v2(147.6,53.57) 147.6,53.19 146.92,52.51 U52000.25
UNNAMED_402_NCP45491XMNTWG_I267: length 3.4
  BOTTOM w0.102: R52080.2 141.06,48.99 v2(141.14,49.08) 141.91,49.08 142.81,49.98 U52000.11
UNNAMED_402_NMOSC_I297_G: length 5.5
  BOTTOM w0.102: R52070.1 151.99,42.22 R52071.2 v2(152.78,42.22) 152.78,39.88 Q52070.G
UNNAMED_402_NPND_I214_C: length 2.4
  BOTTOM w0.102: R52054.1 146.4,59.49 146.44,59.44 v2(146.99,59.44) 146.99,58.58 Q52060.3
UNNAMED_403_APL3537BHAI_I10_A1: length 39.7
  TOP w0.254: v4(157.48,121.5) 157.63,121.65 C52102.2
  L8 w0.381: v3(160.55,88.57) 160.7,88.73 160.7,90.82 161.45,91.57 161.45,93.18 160.77,93.87 160.77,94.54 162.01,95.79 162.01,105.7 160.29,107.42 160.29,112.35 160.93,112.98 160.93,116.77 159.58,118.11 159.58,119.48 158.87,120.2 158.65,120.2 157.91,120.94 157.91,121.11 157.52,121.5 v4(157.48,121.5)
  BOTTOM w0.102: 160.55,88.42 v3(160.55,88.57)
  BOTTOM w0.2: v4(157.48,121.5) U50000.BD14
  BOTTOM w0.381: 160.9,88.45 R52102.2
  BOTTOM w0.432: 160.92,88.13 161.26,87.79 C52101.2 ; R52102.2 160.65,88.67 v3(160.55,88.57)
UNNAMED_409_74LVC1G32_I108_1: length 5.6
  BOTTOM w0.102: R53551.1 102.99,56.77 v2(103.22,57) 103.39,57.17 U53550.1 104.94,57.45 105.29,57.8 106.84,57.8 R53550.2
UNNAMED_409_ANDGATE_I103_4: length 10.7
  BOTTOM w0.102: R53571.1 123.92,51.24 R53570.1 122.83,51.49 122.59,51.73 U53570.4 122.59,52.67 123.29,53.37 123.29,54.05 123.72,54.49 D53571.3 126.04,56.18 v2(125.55,56.67) 125.45,56.57 R53574.1
UNNAMED_410_NMOSC_I216_D: length 5.2
  BOTTOM w0.254: v2(208.78,169.7) 208.56,169.93 R55220.1 208.03,169.97 Q55220.D 208.01,172.06 Q55225.G
UNNAMED_410_NMOSC_I250_D: length 6.7
  TOP w0.254: R55230.1 203.4,168.08 v2(202.79,168.08) 202.71,168.08 201.93,168.86 Q55230.D 204.1,171.29 Q55235.G
UNNAMED_410_NMOSC_I395_D:
  vias: v2(204.26,176.33)
UNNAMED_410_NMOSC_I397_D:
  vias: v2(213.56,171.17)
UNNAMED_410_NMOSC_I444_D:
  vias: v2(200.3,88.75)
UNNAMED_410_NMOSC_I444_G: length 7.2
  BOTTOM w0.254: v2(201.57,88.75) 201.6,88.78 R55210.1 202.37,88.24 202.56,88.05 Q55215.G 201.29,86.21 201.29,83.93 Q55210.D
USB2_CHR_3N: length 12.5
  TOP w0.107: U2501.11 287.24,31.93 287.39,31.78 287.75,31.78 288.4,31.14 297.86,31.14 298.03,31.31 L2501.1 298.56,31.31 R2523.1
USB2_CHR_3P: length 12.5
  TOP w0.107: U2501.10 287.24,31.43 287.39,31.57 287.66,31.57 288.31,30.93 297.86,30.93 298.03,30.76 L2501.2 298.51,30.76 R2524.1
USB2_CN_1N: length 10.1
  TOP w0.107: CN2500.B7 310.92,15 310.8,15.12 310.28,15.12 309.93,15.12 309.58,14.77 309.58,14.42 309.58,14.42 309.58,14.1 v1(309.83,13.52)
  BOTTOM w0.107: CN2500.A7 310.84,14.35 310.23,13.74 310.05,13.74 v1(309.83,13.52) 309.82,13.51 D7503.10 D7503.1 307.03,13.51 306.88,13.65 306.73,13.65 306.54,13.46 L2500.4
USB2_CN_1P: length 9.8
  TOP w0.107: v3(310.07,14.21) 309.91,14.21 309.79,14.33 309.79,14.68 310.02,14.91 310.19,14.91 310.71,14.91 310.84,14.79 312.03,14.79 312.55,14.27 CN2500.B6
  BOTTOM w0.107: L2500.3 306.58,14.01 306.73,13.86 306.88,13.86 307.03,14.01 D7503.2 D7503.9 308.83,14.01 309.12,13.71 309.34,13.71 309.62,14 309.85,14 v3(310.07,14.21) 310.18,14.1 310.29,14.1 311.04,14.85 CN2500.A6
USB2_CN_3N: length 8.1
  TOP w0.107: v3(304.16,31.75) 304.03,31.63 303.61,31.63 303.56,31.58 303.41,31.43 303.03,31.43 302.98,31.38 301.03,31.38 D7500.4 300.85,31.36 300.63,31.36 300.38,31.11 299.9,31.11 R2523.2
  L8 w0.084: v3(304.16,31.75) 304.11,31.75 304.01,31.86 304.01,32.03 304.75,32.77 305.18,32.77 305.52,32.43 CN2501.2
USB2_CN_3P: length 8.1
  TOP w0.107: R2524.2 299.9,30.9 300.46,30.9 300.72,31.15 301.33,31.15 301.35,31.17 302.84,31.17 D7500.7 303.12,31.22 303.78,31.22 v1(303.78,31.22)
  L8 w0.084: v1(303.78,31.22) 303.78,31.58 303.76,31.59 303.76,32.09 304.66,32.98 305.16,32.98 305.52,33.34 CN2501.3
USB2_COMP: length 5.9
  BOTTOM w0.102: R4756.1 238.3,68.48 v2(238.45,68.33) 238.48,68.3 238.58,68.3 239.89,67 239.89,64.72 239.86,64.69 239.86,64.14 U4710.F4
USB2_ID: length 5.6
  BOTTOM w0.102: R4759.1 239.19,68.89 v2(239.72,68.36) 240.08,68 240.08,64.64 240.05,64.62 240.05,64.2 U4710.G3
