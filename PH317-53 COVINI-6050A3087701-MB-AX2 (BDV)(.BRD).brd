# Allegro board PH317-53 COVINI-6050A3087701-MB-AX2 (BDV)(.BRD).brd (continued)
## Nets (continued)
M2_SSD1_DET#: Q1900.3(D) R1906.1(A) R4707.2(B) U4710.AJ43(GPP_E1/SATAXPCIE1/SATAGP1)
M2_SSD1_SUSCLK: CN1901.68(SUSCLK) R4750.2(B)
M2_SSD2_SUSCLK: CN1900.68(SUSCLK) R4710.2(B)
M2_WLAN_SUSCLK: CN1300.50(SSCLK) R4706.2(B)
M.2_W_DISABLE1#: CN1300.56(W_DISABLE1*) Q1312.2(S) R1350.2(B)
M.2_W_DISABLE2#: CN1300.54(RSRVD/W_DISABLE2*) Q1313.2(S) R1351.2(B)
M_A_A_0: CN4100.144(A0) U4555.AH3(DDR0_CAB_9/DDR0_MA_0)
M_A_A_1: CN4100.133(A1) U4555.AP4(DDR0_CAB_8/DDR0_MA_1)
M_A_A_2: CN4100.132(A2) U4555.AN4(DDR0_CAB_5/DDR0_MA_2)
M_A_A_3: CN4100.131(A3) U4555.AP5(NC/DDR0_MA_3)
M_A_A_4: CN4100.128(A4) U4555.AP2(NC/DDR0_MA_4)
M_A_A_5: CN4100.126(A5) U4555.AP1(DDR0_CAA_0/DDR0_MA_5)
M_A_A_6: CN4100.127(A6) U4555.AP3(DDR0_CAA_2/DDR0_MA_6)
M_A_A_7: CN4100.122(A7) U4555.AN1(DDR0_CAA_4/DDR0_MA_7)
M_A_A_8: CN4100.125(A8) U4555.AN3(DDR0_CAA_3/DDR0_MA_8)
M_A_A_9: CN4100.121(A9) U4555.AT4(DDR0_CAA_1/DDR0_MA_9)
M_A_A_10: CN4100.146(A10/AP) U4555.AH2(DDR0_CAB_7/DDR0_MA_10)
M_A_A_11: CN4100.120(A11) U4555.AN2(DDR0_CAA_7/DDR0_MA_11)
M_A_A_12: CN4100.119(A12) U4555.AU4(DDR0_CAA_6/DDR0_MA_12)
M_A_A_13: CN4100.158(A13) U4555.AE3(DDR0_CAB_0/DDR0_MA_13)
M_A_ACT#: CN4100.114(ACT#) U4555.AU3(DDR0_CAA_8/DDR0_ACT#)
M_A_ALERT#: CN4100.116(ALERT#) U4555.AU5(NC/DDR0_ALERT#)
M_A_BG0: CN4100.115(BG0) U4555.AU1(DDR0_CAA_5/DDR0_BG_0)
M_A_BG1: CN4100.113(BG1) U4555.AU2(DDR0_CAA_9/DDR0_BG_1)
M_A_BS0: CN4100.150(BA0) U4555.AH5(DDR0_CAB_4/DDR0_BA_0)
M_A_BS1: CN4100.145(BA1) U4555.AH1(DDR0_CAB_6/DDR0_BA_1)
M_A_CAS#: CN4100.156(A15/CAS#) U4555.AD1(DDR0_CAB_1/DDR0_MA_15)
M_A_DQ<0>: CN4100.4(DQ_4) U4555.BR6(DDR0_DQ_0/DDR0_DQ_0)
M_A_DQ<1>: CN4100.7(DQ_1) U4555.BT6(DDR0_DQ_1/DDR0_DQ_1)
M_A_DQ<2>: CN4100.17(DQ_7) U4555.BP3(DDR0_DQ_2/DDR0_DQ_2)
M_A_DQ<3>: CN4100.16(DQ_6) U4555.BR3(DDR0_DQ_3/DDR0_DQ_3)
M_A_DQ<4>: CN4100.3(DQ_5) U4555.BN5(DDR0_DQ_4/DDR0_DQ_4)
M_A_DQ<5>: CN4100.8(DQ_0) U4555.BP6(DDR0_DQ_5/DDR0_DQ_5)
M_A_DQ<6>: CN4100.21(DQ_3) U4555.BP2(DDR0_DQ_6/DDR0_DQ_6)
M_A_DQ<7>: CN4100.20(DQ_2) U4555.BN3(DDR0_DQ_7/DDR0_DQ_7)
M_A_DQ<8>: CN4100.28(DQ_8) U4555.BL4(DDR0_DQ_8/DDR0_DQ_8)
M_A_DQ<9>: CN4100.24(DQ_12) U4555.BL5(DDR0_DQ_9/DDR0_DQ_9)
M_A_DQ<10>: CN4100.42(DQ_11) U4555.BL2(DDR0_DQ_10/DDR0_DQ_10)
M_A_DQ<11>: CN4100.41(DQ_10) U4555.BM1(DDR0_DQ_11/DDR0_DQ_11)
M_A_DQ<12>: CN4100.25(DQ_13) U4555.BK4(DDR0_DQ_12/DDR0_DQ_12)
M_A_DQ<13>: CN4100.29(DQ_9) U4555.BK5(DDR0_DQ_13/DDR0_DQ_13)
M_A_DQ<14>: CN4100.38(DQ_14) U4555.BK1(DDR0_DQ_14/DDR0_DQ_14)
M_A_DQ<15>: CN4100.37(DQ_15) U4555.BK2(DDR0_DQ_15/DDR0_DQ_15)
M_A_DQ<16>: CN4100.50(DQ_16) U4555.BG4(DDR0_DQ_16/DDR0_DQ_32)
M_A_DQ<17>: CN4100.46(DQ_20) U4555.BG5(DDR0_DQ_17/DDR0_DQ_33)
M_A_DQ<18>: CN4100.62(DQ_18) U4555.BF4(DDR0_DQ_18/DDR0_DQ_34)
M_A_DQ<19>: CN4100.58(DQ_22) U4555.BF5(DDR0_DQ_19/DDR0_DQ_35)
M_A_DQ<20>: CN4100.49(DQ_17) U4555.BG2(DDR0_DQ_20/DDR0_DQ_36)
M_A_DQ<21>: CN4100.45(DQ_21) U4555.BG1(DDR0_DQ_21/DDR0_DQ_37)
M_A_DQ<22>: CN4100.59(DQ_23) U4555.BF1(DDR0_DQ_22/DDR0_DQ_38)
M_A_DQ<23>: CN4100.63(DQ_19) U4555.BF2(DDR0_DQ_23/DDR0_DQ_39)
M_A_DQ<24>: CN4100.70(DQ_24) U4555.BD2(DDR0_DQ_24/DDR0_DQ_40)
M_A_DQ<25>: CN4100.66(DQ_28) U4555.BD1(DDR0_DQ_25/DDR0_DQ_41)
M_A_DQ<26>: CN4100.84(DQ_27) U4555.BC4(DDR0_DQ_26/DDR0_DQ_42)
M_A_DQ<27>: CN4100.80(DQ_31) U4555.BC5(DDR0_DQ_27/DDR0_DQ_43)
M_A_DQ<28>: CN4100.67(DQ_29) U4555.BD5(DDR0_DQ_28/DDR0_DQ_44)
M_A_DQ<29>: CN4100.71(DQ_25) U4555.BD4(DDR0_DQ_29/DDR0_DQ_45)
M_A_DQ<30>: CN4100.79(DQ_30) U4555.BC1(DDR0_DQ_30/DDR0_DQ_46)
M_A_DQ<31>: CN4100.83(DQ_26) U4555.BC2(DDR0_DQ_31/DDR0_DQ_47)
M_A_DQ<32>: CN4100.170(DQ_36) U4555.AB1(DDR0_DQ_32/DDR1_DQ_0)
M_A_DQ<33>: CN4100.173(DQ_33) U4555.AB2(DDR0_DQ_33/DDR1_DQ_1)
M_A_DQ<34>: CN4100.183(DQ_38) U4555.AA4(DDR0_DQ_34/DDR1_DQ_2)
M_A_DQ<35>: CN4100.182(DQ_39) U4555.AA5(DDR0_DQ_35/DDR1_DQ_3)
M_A_DQ<36>: CN4100.174(DQ_32) U4555.AB5(DDR0_DQ_36/DDR1_DQ_4)
M_A_DQ<37>: CN4100.169(DQ_37) U4555.AB4(DDR0_DQ_37/DDR1_DQ_5)
M_A_DQ<38>: CN4100.187(DQ_34) U4555.AA2(DDR0_DQ_38/DDR1_DQ_6)
M_A_DQ<39>: CN4100.186(DQ_35) U4555.AA1(DDR0_DQ_39/DDR1_DQ_7)
M_A_DQ<40>: CN4100.190(DQ_45) U4555.V5(DDR0_DQ_40/DDR1_DQ_8)
M_A_DQ<41>: CN4100.191(DQ_44) U4555.V2(DDR0_DQ_41/DDR1_DQ_9)
M_A_DQ<42>: CN4100.204(DQ_47) U4555.U1(DDR0_DQ_42/DDR1_DQ_10)
M_A_DQ<43>: CN4100.203(DQ_46) U4555.U2(DDR0_DQ_43/DDR1_DQ_11)
M_A_DQ<44>: CN4100.195(DQ_40) U4555.V1(DDR0_DQ_44/DDR1_DQ_12)
M_A_DQ<45>: CN4100.194(DQ_41) U4555.V4(DDR0_DQ_45/DDR1_DQ_13)
M_A_DQ<46>: CN4100.208(DQ_43) U4555.U5(DDR0_DQ_46/DDR1_DQ_14)
M_A_DQ<47>: CN4100.207(DQ_42) U4555.U4(DDR0_DQ_47/DDR1_DQ_15)
M_A_DQ<48>: CN4100.212(DQ_53) U4555.R2(DDR0_DQ_48/DDR1_DQ_32)
M_A_DQ<49>: CN4100.224(DQ_54) U4555.P5(DDR0_DQ_49/DDR1_DQ_33)
M_A_DQ<50>: CN4100.215(DQ_49) U4555.R4(DDR0_DQ_50/DDR1_DQ_34)
M_A_DQ<51>: CN4100.228(DQ_50) U4555.P4(DDR0_DQ_51/DDR1_DQ_35)
M_A_DQ<52>: CN4100.211(DQ_52) U4555.R5(DDR0_DQ_52/DDR1_DQ_36)
M_A_DQ<53>: CN4100.225(DQ_55) U4555.P2(DDR0_DQ_53/DDR1_DQ_37)
M_A_DQ<54>: CN4100.216(DQ_48) U4555.R1(DDR0_DQ_54/DDR1_DQ_38)
M_A_DQ<55>: CN4100.229(DQ_51) U4555.P1(DDR0_DQ_55/DDR1_DQ_39)
M_A_DQ<56>: CN4100.237(DQ_56) U4555.M4(DDR0_DQ_56/DDR1_DQ_40)
M_A_DQ<57>: CN4100.232(DQ_60) U4555.M1(DDR0_DQ_57/DDR1_DQ_41)
M_A_DQ<58>: CN4100.249(DQ_58) U4555.L4(DDR0_DQ_58/DDR1_DQ_42)
M_A_DQ<59>: CN4100.250(DQ_59) U4555.L2(DDR0_DQ_59/DDR1_DQ_43)
M_A_DQ<60>: CN4100.233(DQ_61) U4555.M5(DDR0_DQ_60/DDR1_DQ_44)
M_A_DQ<61>: CN4100.236(DQ_57) U4555.M2(DDR0_DQ_61/DDR1_DQ_45)
M_A_DQ<62>: CN4100.245(DQ_62) U4555.L5(DDR0_DQ_62/DDR1_DQ_46)
M_A_DQ<63>: CN4100.246(DQ_63) U4555.L1(DDR0_DQ_63/DDR1_DQ_47)
M_A_DQS0_DN: CN4100.11(DQS0_C) U4555.BR5(DDR0_DQSN_0/DDR0_DQSN_0)
M_A_DQS0_DP: CN4100.13(DQS0_T) U4555.BP5(DDR0_DQSP_0/DDR0_DQSP_0)
M_A_DQS1_DN: CN4100.32(DQS1_C) U4555.BL3(DDR0_DQSN_1/DDR0_DQSN_1)
M_A_DQS1_DP: CN4100.34(DQS1_T) U4555.BK3(DDR0_DQSP_1/DDR0_DQSP_1)
M_A_DQS2_DN: CN4100.53(DQS2_C) U4555.BG3(DDR0_DQSN_2/DDR0_DQSN_4)
M_A_DQS2_DP: CN4100.55(DQS2_T) U4555.BF3(DDR0_DQSP_2/DDR0_DQSP_4)
M_A_DQS3_DN: CN4100.74(DQS3_C) U4555.BD3(DDR0_DQSN_3/DDR0_DQSN_5)
M_A_DQS3_DP: CN4100.76(DQS3_T) U4555.BC3(DDR0_DQSP_3/DDR0_DQSP_5)
M_A_DQS4_DN: CN4100.177(DQS4_C) U4555.AA3(DDR0_DQSN_4/DDR1_DQSN_0)
M_A_DQS4_DP: CN4100.179(DQS4_T) U4555.AB3(DDR0_DQSP_4/DDR1_DQSP_0)
M_A_DQS5_DN: CN4100.198(DQS5_C) U4555.U3(DDR0_DQSN_5/DDR1_DQSN_1)
M_A_DQS5_DP: CN4100.200(DQS5_T) U4555.V3(DDR0_DQSP_5/DDR1_DQSP_1)
M_A_DQS6_DN: CN4100.219(DQS6_C) U4555.P3(DDR0_DQSN_6/DDR1_DQSN_4)
M_A_DQS6_DP: CN4100.221(DQS6_T) U4555.R3(DDR0_DQSP_6/DDR1_DQSP_4)
M_A_DQS7_DN: CN4100.240(DQS7_C) U4555.L3(DDR0_DQSN_7/DDR1_DQSN_5)
M_A_DQS7_DP: CN4100.242(DQS7_T) U4555.M3(DDR0_DQSP_7/DDR1_DQSP_5)
M_A_PARITY: CN4100.143(PARITY) U4555.AG3(NC/DDR0_PAR)
M_A_RAS#: CN4100.152(A16/RAS#) U4555.AH4(DDR0_CAB_3/DDR0_MA_16)
M_A_WE#: CN4100.151(A14/WE#) U4555.AG4(DDR0_CAB_2/DDR0_MA_14)
M_B_A_0: CN4125.144(A0) U4555.AJ9(DDR1_CAB_9/DDR1_MA_0)
M_B_A_1: CN4125.133(A1) U4555.AK6(DDR1_CAB_8/DDR1_MA_1)
M_B_A_2: CN4125.132(A2) U4555.AK5(DDR1_CAB_5/DDR1_MA_2)
M_B_A_3: CN4125.131(A3) U4555.AL5(NC/DDR1_MA_3)
M_B_A_4: CN4125.128(A4) U4555.AL6(NC/DDR1_MA_4)
M_B_A_5: CN4125.126(A5) U4555.AM6(DDR1_CAA_0/DDR1_MA_5)
M_B_A_6: CN4125.127(A6) U4555.AN7(DDR1_CAA_2/DDR1_MA_6)
M_B_A_7: CN4125.122(A7) U4555.AN10(DDR1_CAA_4/DDR1_MA_7)
M_B_A_8: CN4125.125(A8) U4555.AN8(DDR1_CAA_3/DDR1_MA_8)
M_B_A_9: CN4125.121(A9) U4555.AR11(DDR1_CAA_1/DDR1_MA_9)
M_B_A_10: CN4125.146(A10/AP) U4555.AH7(DDR1_CAB_7/DDR1_MA_10)
M_B_A_11: CN4125.120(A11) U4555.AN11(DDR1_CAA_7/DDR1_MA_11)
M_B_A_12: CN4125.119(A12) U4555.AR10(DDR1_CAA_6/DDR1_MA_12)
M_B_A_13: CN4125.158(A13) U4555.AF9(DDR1_CAB_0/DDR1_MA_13)
M_B_ACT#: CN4125.114(ACT#) U4555.AT9(DDR1_CAA_8/DDR1_ACT#)
M_B_ALERT#: CN4125.116(ALERT#) U4555.AR8(NC/DDR1_ALERT#)
M_B_BG0: CN4125.115(BG0) U4555.AR9(DDR1_CAA_5/DDR1_BG_0)
M_B_BG1: CN4125.113(BG1) U4555.AR7(DDR1_CAA_9/DDR1_BG_1)
M_B_BS0: CN4125.150(BA0) U4555.AH8(DDR1_CAB_4/DDR1_BA_0)
M_B_BS1: CN4125.145(BA1) U4555.AH9(DDR1_CAB_6/DDR1_BA_1)
M_B_CAS#: CN4125.156(A15/CAS#) U4555.AF8(DDR1_CAB_1/DDR1_MA_15)
M_B_DQ<0>: CN4125.3(DQ_5) U4555.BT11(DDR1_DQ_0/DDR0_DQ_16)
M_B_DQ<1>: CN4125.7(DQ_1) U4555.BR11(DDR1_DQ_1/DDR0_DQ_17)
M_B_DQ<2>: CN4125.16(DQ_6) U4555.BT9(DDR1_DQ_2/DDR0_DQ_18)
M_B_DQ<3>: CN4125.21(DQ_3) U4555.BR8(DDR1_DQ_3/DDR0_DQ_19)
M_B_DQ<4>: CN4125.8(DQ_0) U4555.BP11(DDR1_DQ_4/DDR0_DQ_20)
M_B_DQ<5>: CN4125.4(DQ_4) U4555.BN11(DDR1_DQ_5/DDR0_DQ_21)
M_B_DQ<6>: CN4125.17(DQ_7) U4555.BP8(DDR1_DQ_6/DDR0_DQ_22)
M_B_DQ<7>: CN4125.20(DQ_2) U4555.BN8(DDR1_DQ_7/DDR0_DQ_23)
M_B_DQ<8>: CN4125.24(DQ_12) U4555.BL12(DDR1_DQ_8/DDR0_DQ_24)
M_B_DQ<9>: CN4125.28(DQ_8) U4555.BL11(DDR1_DQ_9/DDR0_DQ_25)
M_B_DQ<10>: CN4125.29(DQ_9) U4555.BL8(DDR1_DQ_10/DDR0_DQ_26)
M_B_DQ<11>: CN4125.41(DQ_10) U4555.BJ8(DDR1_DQ_11/DDR0_DQ_27)
M_B_DQ<12>: CN4125.38(DQ_14) U4555.BJ11(DDR1_DQ_12/DDR0_DQ_28)
M_B_DQ<13>: CN4125.42(DQ_11) U4555.BJ10(DDR1_DQ_13/DDR0_DQ_29)
M_B_DQ<14>: CN4125.25(DQ_13) U4555.BL7(DDR1_DQ_14/DDR0_DQ_30)
M_B_DQ<15>: CN4125.37(DQ_15) U4555.BJ7(DDR1_DQ_15/DDR0_DQ_31)
M_B_DQ<16>: CN4125.46(DQ_20) U4555.BG11(DDR1_DQ_16/DDR0_DQ_48)
M_B_DQ<17>: CN4125.49(DQ_17) U4555.BG10(DDR1_DQ_17/DDR0_DQ_49)
M_B_DQ<18>: CN4125.45(DQ_21) U4555.BG8(DDR1_DQ_18/DDR0_DQ_50)
M_B_DQ<19>: CN4125.62(DQ_18) U4555.BF8(DDR1_DQ_19/DDR0_DQ_51)
M_B_DQ<20>: CN4125.59(DQ_23) U4555.BF11(DDR1_DQ_20/DDR0_DQ_52)
M_B_DQ<21>: CN4125.63(DQ_19) U4555.BF10(DDR1_DQ_21/DDR0_DQ_53)
M_B_DQ<22>: CN4125.50(DQ_16) U4555.BG7(DDR1_DQ_22/DDR0_DQ_54)
M_B_DQ<23>: CN4125.58(DQ_22) U4555.BF7(DDR1_DQ_23/DDR0_DQ_55)
M_B_DQ<24>: CN4125.79(DQ_30) U4555.BB11(DDR1_DQ_24/DDR0_DQ_56)
M_B_DQ<25>: CN4125.66(DQ_28) U4555.BC11(DDR1_DQ_25/DDR0_DQ_57)
M_B_DQ<26>: CN4125.84(DQ_27) U4555.BB8(DDR1_DQ_26/DDR0_DQ_58)
M_B_DQ<27>: CN4125.71(DQ_25) U4555.BC8(DDR1_DQ_27/DDR0_DQ_59)
M_B_DQ<28>: CN4125.70(DQ_24) U4555.BC10(DDR1_DQ_28/DDR0_DQ_60)
M_B_DQ<29>: CN4125.83(DQ_26) U4555.BB10(DDR1_DQ_29/DDR0_DQ_61)
M_B_DQ<30>: CN4125.67(DQ_29) U4555.BC7(DDR1_DQ_30/DDR0_DQ_62)
M_B_DQ<31>: CN4125.80(DQ_31) U4555.BB7(DDR1_DQ_31/DDR0_DQ_63)
M_B_DQ<32>: CN4125.187(DQ_34) U4555.AA11(DDR1_DQ_32/DDR1_DQ_16)
M_B_DQ<33>: CN4125.183(DQ_38) U4555.AA10(DDR1_DQ_33/DDR1_DQ_17)
M_B_DQ<34>: CN4125.170(DQ_36) U4555.AC11(DDR1_DQ_34/DDR1_DQ_18)
M_B_DQ<35>: CN4125.169(DQ_37) U4555.AC10(DDR1_DQ_35/DDR1_DQ_19)
M_B_DQ<36>: CN4125.186(DQ_35) U4555.AA7(DDR1_DQ_36/DDR1_DQ_20)
M_B_DQ<37>: CN4125.182(DQ_39) U4555.AA8(DDR1_DQ_37/DDR1_DQ_21)
M_B_DQ<38>: CN4125.173(DQ_33) U4555.AC8(DDR1_DQ_38/DDR1_DQ_22)
M_B_DQ<39>: CN4125.174(DQ_32) U4555.AC7(DDR1_DQ_39/DDR1_DQ_23)
M_B_DQ<40>: CN4125.195(DQ_40) U4555.W8(DDR1_DQ_40/DDR1_DQ_24)
M_B_DQ<41>: CN4125.191(DQ_44) U4555.W7(DDR1_DQ_41/DDR1_DQ_25)
M_B_DQ<42>: CN4125.207(DQ_42) U4555.V10(DDR1_DQ_42/DDR1_DQ_26)
M_B_DQ<43>: CN4125.204(DQ_47) U4555.V11(DDR1_DQ_43/DDR1_DQ_27)
M_B_DQ<44>: CN4125.190(DQ_45) U4555.W11(DDR1_DQ_44/DDR1_DQ_28)
M_B_DQ<45>: CN4125.194(DQ_41) U4555.W10(DDR1_DQ_45/DDR1_DQ_29)
M_B_DQ<46>: CN4125.208(DQ_43) U4555.V7(DDR1_DQ_46/DDR1_DQ_30)
M_B_DQ<47>: CN4125.203(DQ_46) U4555.V8(DDR1_DQ_47/DDR1_DQ_31)
M_B_DQ<48>: CN4125.215(DQ_49) U4555.R11(DDR1_DQ_48/DDR1_DQ_48)
M_B_DQ<49>: CN4125.229(DQ_51) U4555.P11(DDR1_DQ_49/DDR1_DQ_49)
M_B_DQ<50>: CN4125.224(DQ_54) U4555.P7(DDR1_DQ_50/DDR1_DQ_50)
M_B_DQ<51>: CN4125.212(DQ_53) U4555.R8(DDR1_DQ_51/DDR1_DQ_51)
M_B_DQ<52>: CN4125.211(DQ_52) U4555.R10(DDR1_DQ_52/DDR1_DQ_52)
M_B_DQ<53>: CN4125.225(DQ_55) U4555.P10(DDR1_DQ_53/DDR1_DQ_53)
M_B_DQ<54>: CN4125.216(DQ_48) U4555.R7(DDR1_DQ_54/DDR1_DQ_54)
M_B_DQ<55>: CN4125.228(DQ_50) U4555.P8(DDR1_DQ_55/DDR1_DQ_55)
M_B_DQ<56>: CN4125.249(DQ_58) U4555.L11(DDR1_DQ_56/DDR1_DQ_56)
M_B_DQ<57>: CN4125.232(DQ_60) U4555.M11(DDR1_DQ_57/DDR1_DQ_57)
M_B_DQ<58>: CN4125.250(DQ_59) U4555.L7(DDR1_DQ_58/DDR1_DQ_58)
M_B_DQ<59>: CN4125.233(DQ_61) U4555.M8(DDR1_DQ_59/DDR1_DQ_59)
M_B_DQ<60>: CN4125.245(DQ_62) U4555.L10(DDR1_DQ_60/DDR1_DQ_60)
M_B_DQ<61>: CN4125.237(DQ_56) U4555.M10(DDR1_DQ_61/DDR1_DQ_61)
M_B_DQ<62>: CN4125.236(DQ_57) U4555.M7(DDR1_DQ_62/DDR1_DQ_62)
M_B_DQ<63>: CN4125.246(DQ_63) U4555.L8(DDR1_DQ_63/DDR1_DQ_63)
M_B_DQS0_DN: CN4125.11(DQS0_C) U4555.BN9(DDR1_DQSN_0/DDR0_DQSN_2)
M_B_DQS0_DP: CN4125.13(DQS0_T) U4555.BP9(DDR1_DQSP_0/DDR0_DQSP_2)
M_B_DQS1_DN: CN4125.32(DQS1_C) U4555.BL9(DDR1_DQSN_1/DDR0_DQSN_3)
M_B_DQS1_DP: CN4125.34(DQS1_T) U4555.BJ9(DDR1_DQSP_1/DDR0_DQSP_3)
M_B_DQS2_DN: CN4125.53(DQS2_C) U4555.BG9(DDR1_DQSN_2/DDR0_DQSN_6)
M_B_DQS2_DP: CN4125.55(DQS2_T) U4555.BF9(DDR1_DQSP_2/DDR0_DQSP_6)
M_B_DQS3_DN: CN4125.74(DQS3_C) U4555.BC9(DDR1_DQSN_3/DDR0_DQSN_7)
M_B_DQS3_DP: CN4125.76(DQS3_T) U4555.BB9(DDR1_DQSP_3/DDR0_DQSP_7)
M_B_DQS4_DN: CN4125.177(DQS4_C) U4555.AC9(DDR1_DQSN_4/DDR1_DQSN_2)
M_B_DQS4_DP: CN4125.179(DQS4_T) U4555.AA9(DDR1_DQSP_4/DDR1_DQSP_2)
M_B_DQS5_DN: CN4125.198(DQS5_C) U4555.W9(DDR1_DQSN_5/DDR1_DQSN_3)
M_B_DQS5_DP: CN4125.200(DQS5_T) U4555.V9(DDR1_DQSP_5/DDR1_DQSP_3)
M_B_DQS6_DN: CN4125.219(DQS6_C) U4555.R9(DDR1_DQSN_6/DDR1_DQSN_6)
M_B_DQS6_DP: CN4125.221(DQS6_T) U4555.P9(DDR1_DQSP_6/DDR1_DQSP_6)
M_B_DQS7_DN: CN4125.240(DQS7_C) U4555.M9(DDR1_DQSN_7/DDR1_DQSN_7)
M_B_DQS7_DP: CN4125.242(DQS7_T) U4555.L9(DDR1_DQSP_7/DDR1_DQSP_7)
M_B_PARITY: CN4125.143(PARITY) U4555.AJ7(NC/DDR1_PAR)
M_B_RAS#: CN4125.152(A16/RAS#) U4555.AH10(DDR1_CAB_3/DDR1_MA_16)
M_B_WE#: CN4125.151(A14/WE#) U4555.AH11(DDR1_CAB_2/DDR1_MA_14)
M_CKE0: CN4100.109(CKE0) U4555.AT1(DDR0_CKE_0/DDR0_CKE_0)
M_CKE1: CN4100.110(CKE1) U4555.AT2(DDR0_CKE_1/DDR0_CKE_1)
M_CKE2: CN4125.109(CKE0) U4555.AT8(DDR1_CKE_0/DDR1_CKE_0)
M_CKE3: CN4125.110(CKE1) U4555.AT10(DDR1_CKE_1/DDR1_CKE_1)
M_CLK_DDR0_DN: CN4100.139(CK0_C) U4555.AG2(DDR0_CKN_0/DDR0_CKN_0)
M_CLK_DDR0_DP: CN4100.137(CK0_T) U4555.AG1(DDR0_CKP_0/DDR0_CKP_0)
M_CLK_DDR1_DN: CN4100.140(CK1_C) U4555.AK1(DDR0_CKN_1/DDR0_CKN_1)
M_CLK_DDR1_DP: CN4100.138(CK1_T) U4555.AK2(DDR0_CKP_1/DDR0_CKP_1)
M_CLK_DDR2_DN: CN4125.139(CK0_C) U4555.AN9(DDR1_CKN_0/DDR1_CKN_0)
M_CLK_DDR2_DP: CN4125.137(CK0_T) U4555.AM9(DDR1_CKP_0/DDR1_CKP_0)
M_CLK_DDR3_DN: CN4125.140(CK1_C) U4555.AM8(DDR1_CKN_1/DDR1_CKN_1)
M_CLK_DDR3_DP: CN4125.138(CK1_T) U4555.AM7(DDR1_CKP_1/DDR1_CKP_1)
M_CS#0: CN4100.149(CS0#) U4555.AD5(DDR0_CS#_0/DDR0_CS#_0)
M_CS#1: CN4100.157(CS1#) U4555.AE2(DDR0_CS#_1/DDR0_CS#_1)
M_CS#2: CN4125.149(CS0#) U4555.AF11(DDR1_CS#_0/DDR1_CS#_0)
M_CS#3: CN4125.157(CS1#) U4555.AE7(DDR1_CS#_1/DDR1_CS#_1)
M_ODT0: CN4100.155(ODT0) U4555.AD3(DDR0_ODT_0/DDR0_ODT_0)
M_ODT1: CN4100.161(ODT1) U4555.AE4(NC/DDR0_ODT_1)
M_ODT2: CN4125.155(ODT0) U4555.AF7(DDR1_ODT_0/DDR1_ODT_0)
M_ODT3: CN4125.161(ODT1) U4555.AE8(NC/DDR1_ODT_1)
MB_SHUTDOWN#: R323.1(A) U1.69(ADC3/GPI3<3>)
ME_FLASH_EN: R4861.1(A) U1.81(DAC5/RIG0#/GPJ5<3>)
MIC2_REF: CN603.7 U500.29(MIC2-VREFO)
MODEM_CLKREQ_R: CN1300.14(PCM_OUT) R1334.2(B) R4772.2(B)
NV3V3_DPP_DIS: R56250.1(A) U56250.4
NVHS_DVDD: R51900.2(B) U50000.AT9(NVHS_DVDD_2) U50000.AT10(NVHS_DVDD_1) U50000.AV10(NVHS_DVDD_3) U50000.AV11(NVHS_DVDD_4)
NVHS_HVDD: R51902.2(B) U50000.AM10(NVHS_HVDD_1) U50000.AM11(NVHS_HVDD_2) U50000.AN10(NVHS_HVDD_3) U50000.AN11(NVHS_HVDD_4) U50000.AR11(NVHS_HVDD_5)
NVHS_PLL_HVDD: R51903.2(B) U50000.AN9(NVHS_PLL_HVDD)
NVVDD_CURRENT_MONITOR_N: R52021.1(A) R67199.4
NVVDD_CURRENT_MONITOR_P: R52022.1(A) R52024.1(A) R67199.3
NVVDD_GND_SENSE: R52111.1(A) TP52121.1 U50000.BL45(GND_SENSE)
NVVDD_PG: R53531.2(B) U53540.2 U53585.2
NVVDD_PSI: R51583.1(A) R51584.2(B) R51585.2(B) R67008.1(A)
NVVDD_PWMID: R51579.2(B) R67010.1(A)
NVVDD_TALERT#: R67014.2(B) U67000.1(TALERT#)
NVVDD_VCC_SENSE: R52110.1(A) TP52120.1 U50000.BK45(VDD_SENSE)
OVERT_RST#: Q51510.G R51512.2(B)
OVRM_EN: Q52070.D R52002.1(A) R52072.1(A) U52000.28(ENABLE)
OVRM_EN_EC: R52002.2(B) U1.70(ADC4/GPI4<3>)
PCH2CPU_TRIGGER: R4792.2(B) U4555.H23(PROC_TRIGIN)
PCH_3A_SMCLK: Q4702.6(D1) R4828.2(B) U4710.BE26(GPP_C0/SMBCLK)
PCH_3A_SMDATA: Q4702.3(D2) R4913.2(B) U4710.BF26(GPP_C1/SMBDATA)
PCH_3S_SMCLK: CN4100.253(SCL) CN4125.253(SCL) Q4702.1(S1) R4705.2(B)
PCH_3S_SMDATA: CN4100.254(SDA) CN4125.254(SDA) Q4702.4(S2) R4775.2(B)
PCH_BATLOW#: R4804.2(B) U4710.BF44(GPD0/BATLOW#)
PCH_CIO_PLUG_EVENT: R4711.1(A) U4710.BC33(GPP_B4/CPU_GP3)
PCH_CNVI_PWR_EN#: R4733.1(A) U4710.BE29(GPP_B0/GSPI0_CS1#)
PCH_DGPU_PWR_EN#: Q4.1(G) R4815.2(B) R4859.2(B) U4710.BD30(GPP_B21/GSPI1_MISO)
PCH_HOLD_RST#: R4803.2(B) R4823.2(B) U4710.AU26(GPP_B20/GSPI1_CLK)
PCH_I2C1_CLK: Q281.3(D2) R290.1(A) R4810.2(B) U4710.BE21(GPP_C19/I2C1_SCL)
PCH_I2C1_DATA: Q281.6(D1) R289.2(B) R4812.2(B) U4710.BF21(GPP_C18/I2C1_SDA)
PCH_I2C_CLK: CN5.25 R4825.2(B) U4710.BC22(GPP_C17/I2C0_SCL)
PCH_I2C_DATA: CN5.26 R4827.2(B) U4710.BF23(GPP_C16/I2C0_SDA)
PCH_JTAGX: R4532.1(A) R4890.1(A) U4710.AH4(PCH_JTAGX)
PCH_PECI: R79.2(B) R300.2(B) R4514.1(A)
PCH_PLTRST#_BUF: R4776.2(B) R50022.2(B) TP50022.1 U50020.1
PCH_PRDY#: R4799.1(A) U4710.AM5(PRDY#)
PCH_PREQ#: R4798.1(A) U4710.AL2(PREQ#)
PCH_PWROK: C140.1(A) R7009.2(B) R7010.2(B) U4710.AY42(PCH_PWROK)
PCH_R_PECI: R79.1(A) U4710.AF2(PECI)
PCH_SPI_CLK: R136.1(A) R311.2(B) R3503.1(A) U300.6 XU300.6(SCK)
PCH_SPI_CS0#: R7.2(B) R13.2(B) R135.1(A) U300.1 XU300.1(CE#)
PCH_SPI_CS2#: R3504.1(A) U4710.AT40(SPI0_CS2#)
PCH_SPI_SI: R12.2(B) R56.1(A) R133.1(A) R3506.1(A) U300.5 XU300.5(SI)
PCH_SPI_SO: R11.2(B) R134.1(A) R3505.1(A) U300.2 XU300.2(SO)
PCH_SPI_SO2: R330.2(B) R4701.1(A) U300.3 XU300.3(WP#)
PCH_SPI_SO3: R55.1(A) R4721.1(A) U300.7 XU300.7(HOLD#)
PCH_SPKR: R521.2(B) U4710.AW29(GPP_B14/SPKR)
PCH_TCK: R4881.1(A) U4710.AJ3(PCH_JTAG_TCK)
PCH_TDI: R4797.1(A) R4879.1(A) U4710.AH2(PCH_JTAG_TDI)
PCH_TDO: R4796.1(A) R4876.1(A) U4710.AH3(PCH_JTAG_TDO)
PCH_THERMTRIP#: Q4758.3(C) R4785.2(B) R4786.1(A)
PCH_THERMTRIP#_R: R4785.1(A) U4710.AD3(THRMTRIP#)
PCH_TMS: R4794.1(A) R4880.1(A) U4710.AJ4(PCH_JTAG_TMS)
PCH_TP_I2C_INT#: R280.1(A) U4710.Y47(GPP_K16/GSXCLK)
PCH_TRIGOUTGGER: R4792.1(A) U4710.AK3(TRIGGER_OUT)
PCH_TRST#: R4801.1(A) U4710.AM4(CPU_TRST#)
PCH_VCCPRIM_1P8: R4900.1(A) R4918.2(B) U4710.AF19(VCCPRIM_1P81) U4710.AF20(VCCPRIM_1P82)
PCH_VCCPRIM_1P8_R: R4918.1(A) R4920.2(B) U4710.AG19(VCCPRIM_1P83) U4710.AG20(VCCPRIM_1P84) U4710.AN24(VCCPGPPD)
PCH_W_DISABLE2#: Q1313.3(D) R4708.1(A) U4710.BF32(GPP_B3/CPU_GP2)
PCH_WAKE#: CN603.17 Q1314.3(C) R4747.1(A) U4710.BB47(WAKE#)
PCIE17_HDD_RX_C_DN: C1703.2(B) CN1700.6
PCIE17_HDD_RX_C_DP: C1702.2(B) CN1700.5
PCIE17_HDD_RX_DN: C1703.1(A) U4710.K43(PCIE17_RXN/SATA4_RXN)
PCIE17_HDD_RX_DP: C1702.1(A) U4710.K44(PCIE17_RXP/SATA4_RXP)
PCIE17_HDD_TX_C_DN: C4954.2(B) CN1700.8
PCIE17_HDD_TX_C_DP: C4955.2(B) CN1700.9
PCIE17_SSD_TX_DN: C4954.1(A) U4710.A42(PCIE17_TXN/SATA4_TXN)
PCIE17_SSD_TX_DP: C4955.1(A) U4710.B42(PCIE17_TXP/SATA4_TXP)
PCIE_DGPU_RX0N: C55731.1(A) U4555.D25(PEG_RXN_0)
PCIE_DGPU_RX0P: C55730.1(A) U4555.E25(PEG_RXP_0)
PCIE_DGPU_RX1N: C55729.1(A) U4555.F24(PEG_RXN_1)
PCIE_DGPU_RX1P: C55728.1(A) U4555.E24(PEG_RXP_1)
PCIE_DGPU_RX2N: C55727.1(A) U4555.D23(PEG_RXN_2)
PCIE_DGPU_RX2P: C55726.1(A) U4555.E23(PEG_RXP_2)
PCIE_DGPU_RX3N: C55725.1(A) U4555.F22(PEG_RXN_3)
PCIE_DGPU_RX3P: C55724.1(A) U4555.E22(PEG_RXP_3)
PCIE_DGPU_RX4N: C55723.1(A) U4555.D21(PEG_RXN_4)
PCIE_DGPU_RX4P: C55722.1(A) U4555.E21(PEG_RXP_4)
PCIE_DGPU_RX5N: C55721.1(A) U4555.F20(PEG_RXN_5)
PCIE_DGPU_RX5P: C55720.1(A) U4555.E20(PEG_RXP_5)
PCIE_DGPU_RX6N: C55719.1(A) U4555.D19(PEG_RXN_6)
PCIE_DGPU_RX6P: C55718.1(A) U4555.E19(PEG_RXP_6)
PCIE_DGPU_RX7N: C55717.1(A) U4555.F18(PEG_RXN_7)
PCIE_DGPU_RX7P: C55716.1(A) U4555.E18(PEG_RXP_7)
PCIE_DGPU_RX8N: C55715.1(A) U4555.E17(PEG_RXN_8)
PCIE_DGPU_RX8P: C55714.1(A) U4555.D17(PEG_RXP_8)
PCIE_DGPU_RX9N: C55713.1(A) U4555.E16(PEG_RXN_9)
PCIE_DGPU_RX9P: C55712.1(A) U4555.F16(PEG_RXP_9)
PCIE_DGPU_RX10N: C55711.1(A) U4555.E15(PEG_RXN_10)
PCIE_DGPU_RX10P: C55710.1(A) U4555.D15(PEG_RXP_10)
PCIE_DGPU_RX11N: C55709.1(A) U4555.E14(PEG_RXN_11)
PCIE_DGPU_RX11P: C55708.1(A) U4555.F14(PEG_RXP_11)
PCIE_DGPU_RX12N: C55707.1(A) U4555.E13(PEG_RXN_12)
PCIE_DGPU_RX12P: C55706.1(A) U4555.D13(PEG_RXP_12)
PCIE_DGPU_RX13N: C55705.1(A) U4555.E12(PEG_RXN_13)
PCIE_DGPU_RX13P: C55704.1(A) U4555.F12(PEG_RXP_13)
PCIE_DGPU_RX14N: C55703.1(A) U4555.E11(PEG_RXN_14)
PCIE_DGPU_RX14P: C55702.1(A) U4555.D11(PEG_RXP_14)
PCIE_DGPU_RX15N: C55701.1(A) U4555.E10(PEG_RXN_15)
PCIE_DGPU_RX15P: C55700.1(A) U4555.F10(PEG_RXP_15)
PCIE_DGPU_TX0N: C4836.1(A) U50000.BK42(PEX_RX15*)
PCIE_DGPU_TX0P: C4835.1(A) U50000.BL42(PEX_RX15)
PCIE_DGPU_TX1N: C4838.1(A) U50000.BM42(PEX_RX14*)
PCIE_DGPU_TX1P: C4837.1(A) U50000.BM41(PEX_RX14)
PCIE_DGPU_TX2N: C4840.1(A) U50000.BL41(PEX_RX13*)
PCIE_DGPU_TX2P: C4839.1(A) U50000.BK41(PEX_RX13)
PCIE_DGPU_TX3N: C4842.1(A) U50000.BK39(PEX_RX12*)
PCIE_DGPU_TX3P: C4841.1(A) U50000.BL39(PEX_RX12)
PCIE_DGPU_TX4N: C4882.1(A) U50000.BM39(PEX_RX11*)
PCIE_DGPU_TX4P: C4883.1(A) U50000.BM38(PEX_RX11)
PCIE_DGPU_TX5N: C4834.1(A) U50000.BL38(PEX_RX10*)
PCIE_DGPU_TX5P: C4879.1(A) U50000.BK38(PEX_RX10)
PCIE_DGPU_TX6N: C4812.1(A) U50000.BK36(PEX_RX9*)
PCIE_DGPU_TX6P: C4831.1(A) U50000.BL36(PEX_RX9)
PCIE_DGPU_TX7N: C4810.1(A) U50000.BM36(PEX_RX8*)
PCIE_DGPU_TX7P: C4811.1(A) U50000.BM35(PEX_RX8)
PCIE_DGPU_TX8N: C4820.1(A) U50000.BL35(PEX_RX7*)
PCIE_DGPU_TX8P: C4818.1(A) U50000.BK35(PEX_RX7)
PCIE_DGPU_TX9N: C4822.1(A) U50000.BK33(PEX_RX6*)
PCIE_DGPU_TX9P: C4819.1(A) U50000.BL33(PEX_RX6)
PCIE_DGPU_TX10N: C4821.1(A) U50000.BM33(PEX_RX5*)
PCIE_DGPU_TX10P: C4823.1(A) U50000.BM32(PEX_RX5)
PCIE_DGPU_TX11N: C4833.1(A) U50000.BL32(PEX_RX4*)
PCIE_DGPU_TX11P: C4832.1(A) U50000.BK32(PEX_RX4)
PCIE_DGPU_TX12N: C4878.1(A) U50000.BK30(PEX_RX3*)
PCIE_DGPU_TX12P: C4880.1(A) U50000.BL30(PEX_RX3)
PCIE_DGPU_TX13N: C4881.1(A) U50000.BM30(PEX_RX2*)
PCIE_DGPU_TX13P: C4884.1(A) U50000.BM29(PEX_RX2)
PCIE_DGPU_TX14N: C4886.1(A) U50000.BL29(PEX_RX1*)
PCIE_DGPU_TX14P: C4885.1(A) U50000.BK29(PEX_RX1)
PCIE_DGPU_TX15N: C4888.1(A) U50000.BK27(PEX_RX0*)
PCIE_DGPU_TX15P: C4887.1(A) U50000.BL27(PEX_RX0)
PCIE_LAN_C_RX13N: C1710.2(B) U1700.8(BON)
PCIE_LAN_C_RX13P: C1706.2(B) U1700.9(BOP)
PCIE_LAN_RX13N: C1710.1(A) U4710.C45(PCIE13_RXN/SATA0B_RXN)
PCIE_LAN_RX13P: C1706.1(A) U4710.C46(PCIE13_RXP/SATA0B_RXP)
PCIE_LAN_TX13N: C4960.1(A) U1700.3(AIN)
PCIE_LAN_TX13P: C4961.1(A) U1700.2(AIP)
PCIE_RCOMPN: R4608.2(B) U4710.B12(PCIE_RCOMPN)
PCIE_RCOMPP: R4608.1(A) U4710.A13(PCIE_RCOMPP)
PCIE_REP_EN#: R1700.2(B) R1701.2(B) U1700.11(EN#)
PCIE_SSD_RX9N: CN1901.5(PERN3) U4710.G36(PCIE9_RXN)
PCIE_SSD_RX9P: CN1901.7(PERP3) U4710.F36(PCIE9_RXP)
PCIE_SSD_RX10N: CN1901.17(PERN2) U4710.K37(PCIE10_RXN)
PCIE_SSD_RX10P: CN1901.19(PERP2) U4710.J37(PCIE10_RXP)
PCIE_SSD_RX11N: CN1901.29(PERN1) U4710.G38(PCIE11_RXN/SATA0A_RXN)
PCIE_SSD_RX11P: CN1901.31(PERP1) U4710.F39(PCIE11_RXP/SATA0A_RXP)
PCIE_SSD_RX12N: CN1901.43(PERP0/SATA-B-) U4710.H42(PCIE12_RXN/SATA1A_RXN)
PCIE_SSD_RX12P: CN1901.41(PERN0/SATA-B+) U4710.J41(PCIE12_RXP/SATA_1A_RXP)
PCIE_SSD_RX21N: CN1900.5(PERN3) U4710.T43(PCIE21_RXN)
PCIE_SSD_RX21P: CN1900.7(PERP3) U4710.R44(PCIE21_RXP)
PCIE_SSD_RX22N: CN1900.17(PERN2) U4710.U40(PCIE22_RXN)
PCIE_SSD_RX22P: CN1900.19(PERP2) U4710.U41(PCIE22_RXP)
PCIE_SSD_RX23N: CN1900.29(PERN1) U4710.W43(PCIE23_RXN)
PCIE_SSD_RX23P: CN1900.31(PERP1) U4710.W44(PCIE23_RXP)
PCIE_SSD_RX24N: CN1900.41(PERN0/SATA-B+) U4710.Y40(PCIE24_RXN)
PCIE_SSD_RX24P: CN1900.43(PERP0/SATA-B-) U4710.Y41(PCIE24_RXP)
PCIE_SSD_TX9N: C1916.1(A) U4710.C34(PCIE9_TXN)
PCIE_SSD_TX9P: C1919.1(A) U4710.D34(PCIE9_TXP)
PCIE_SSD_TX10N: C1917.1(A) U4710.C35(PCIE10_TXN)
PCIE_SSD_TX10P: C1918.1(A) U4710.B35(PCIE10_TXP)
PCIE_SSD_TX11N: C1920.1(A) U4710.B36(PCIE11_TXN/SATA0A_TXN)
PCIE_SSD_TX11P: C1921.1(A) U4710.C36(PCIE11_TXP/SATA0A_TXP)
PCIE_SSD_TX12N: C1922.1(A) U4710.D38(PCIE12_TXN/SATA1A_TXN)
PCIE_SSD_TX12P: C1923.1(A) U4710.E37(PCIE12_TXP/SATA1A_TXP)
PCIE_SSD_TX21N: C1925.1(A) U4710.G47(PCIE21_TXN)
PCIE_SSD_TX21P: C1924.1(A) U4710.F46(PCIE21_TXP)
PCIE_SSD_TX22N: C1927.1(A) U4710.H47(PCIE22_TXN)
PCIE_SSD_TX22P: C1926.1(A) U4710.H48(PCIE22_TXP)
PCIE_SSD_TX23N: C1928.1(A) U4710.G49(PCIE23_TXN)
PCIE_SSD_TX23P: C1909.1(A) U4710.G48(PCIE23_TXP)
PCIE_SSD_TX24N: C1930.1(A) U4710.G46(PCIE24_TXN)
PCIE_SSD_TX24P: C1929.1(A) U4710.G45(PCIE24_TXP)
PCIE_WLAN_CTX6N: C1322.2(B) CN1300.37(PETN0)
PCIE_WLAN_CTX6P: C1323.2(B) CN1300.35(PETP0)
PCIE_WLAN_RX14N: CN1300.43(PERN0) U4710.D46(PCIE14_RXN/SATA1B_RXN)
PCIE_WLAN_RX14P: CN1300.41(PERP0) U4710.C47(PCIE14_RXP/SATA1B_RXP)
PCIE_WLAN_TX14N: C1322.1(A) U4710.C39(PCIE14_TXN/SATA1B_TXN)
PCIE_WLAN_TX14P: C1323.1(A) U4710.D39(PCIE14_TXP/SATA1B_TXP)
PCSPKR_EC_3: R505.2(B) U1.34(PWM7/RIG1#/GPA7)
PEG_CPU_RX0N_C: C55731.2(B) U50000.BG41(PEX_TX15*)
PEG_CPU_RX0P_C: C55730.2(B) U50000.BH41(PEX_TX15)
PEG_CPU_RX1N_C: C55729.2(B) U50000.BG39(PEX_TX14*)
PEG_CPU_RX1P_C: C55728.2(B) U50000.BF39(PEX_TX14)
PEG_CPU_RX2N_C: C55727.2(B) U50000.BE38(PEX_TX13*)
PEG_CPU_RX2P_C: C55726.2(B) U50000.BF38(PEX_TX13)
PEG_CPU_RX3N_C: C55725.2(B) U50000.BH38(PEX_TX12*)
PEG_CPU_RX3P_C: C55724.2(B) U50000.BG38(PEX_TX12)
PEG_CPU_RX4N_C: C55723.2(B) U50000.BG36(PEX_TX11*)
PEG_CPU_RX4P_C: C55722.2(B) U50000.BF36(PEX_TX11)
PEG_CPU_RX5N_C: C55721.2(B) U50000.BE35(PEX_TX10*)
PEG_CPU_RX5P_C: C55720.2(B) U50000.BF35(PEX_TX10)
PEG_CPU_RX6N_C: C55719.2(B) U50000.BH35(PEX_TX9*)
PEG_CPU_RX6P_C: C55718.2(B) U50000.BG35(PEX_TX9)
PEG_CPU_RX7N_C: C55717.2(B) U50000.BG33(PEX_TX8*)
PEG_CPU_RX7P_C: C55716.2(B) U50000.BF33(PEX_TX8)
PEG_CPU_RX8N_C: C55715.2(B) U50000.BE32(PEX_TX7*)
PEG_CPU_RX8P_C: C55714.2(B) U50000.BF32(PEX_TX7)
PEG_CPU_RX9N_C: C55713.2(B) U50000.BH32(PEX_TX6*)
PEG_CPU_RX9P_C: C55712.2(B) U50000.BG32(PEX_TX6)
PEG_CPU_RX10N_C: C55711.2(B) U50000.BG30(PEX_TX5*)
PEG_CPU_RX10P_C: C55710.2(B) U50000.BF30(PEX_TX5)
PEG_CPU_RX11N_C: C55709.2(B) U50000.BE29(PEX_TX4*)
PEG_CPU_RX11P_C: C55708.2(B) U50000.BF29(PEX_TX4)
PEG_CPU_RX12N_C: C55707.2(B) U50000.BH29(PEX_TX3*)
PEG_CPU_RX12P_C: C55706.2(B) U50000.BG29(PEX_TX3)
PEG_CPU_RX13N_C: C55705.2(B) U50000.BG27(PEX_TX2*)
PEG_CPU_RX13P_C: C55704.2(B) U50000.BF27(PEX_TX2)
PEG_CPU_RX14N_C: C55703.2(B) U50000.BE26(PEX_TX1*)
PEG_CPU_RX14P_C: C55702.2(B) U50000.BF26(PEX_TX1)
PEG_CPU_RX15N_C: C55701.2(B) U50000.BH26(PEX_TX0*)
PEG_CPU_RX15P_C: C55700.2(B) U50000.BG26(PEX_TX0)
PEG_RCOMP: R4501.2(B) U4555.G2(PEG_RCOMP)
PEG_TX0_DN: C4836.2(B) U4555.A25(PEG_TXN_0)
PEG_TX0_DP: C4835.2(B) U4555.B25(PEG_TXP_0)
PEG_TX1_DN: C4838.2(B) U4555.C24(PEG_TXN_1)
PEG_TX1_DP: C4837.2(B) U4555.B24(PEG_TXP_1)
PEG_TX2_DN: C4840.2(B) U4555.A23(PEG_TXN_2)
PEG_TX2_DP: C4839.2(B) U4555.B23(PEG_TXP_2)
PEG_TX3_DN: C4842.2(B) U4555.C22(PEG_TXN_3)
PEG_TX3_DP: C4841.2(B) U4555.B22(PEG_TXP_3)
PEG_TX4_DN: C4882.2(B) U4555.A21(PEG_TXN_4)
PEG_TX4_DP: C4883.2(B) U4555.B21(PEG_TXP_4)
PEG_TX5_DN: C4834.2(B) U4555.C20(PEG_TXN_5)
PEG_TX5_DP: C4879.2(B) U4555.B20(PEG_TXP_5)
PEG_TX6_DN: C4812.2(B) U4555.A19(PEG_TXN_6)
PEG_TX6_DP: C4831.2(B) U4555.B19(PEG_TXP_6)
PEG_TX7_DN: C4810.2(B) U4555.C18(PEG_TXN_7)
PEG_TX7_DP: C4811.2(B) U4555.B18(PEG_TXP_7)
PEG_TX8_DN: C4820.2(B) U4555.B17(PEG_TXN_8)
PEG_TX8_DP: C4818.2(B) U4555.A17(PEG_TXP_8)
PEG_TX9_DN: C4822.2(B) U4555.B16(PEG_TXN_9)
PEG_TX9_DP: C4819.2(B) U4555.C16(PEG_TXP_9)
PEG_TX10_DN: C4821.2(B) U4555.B15(PEG_TXN_10)
PEG_TX10_DP: C4823.2(B) U4555.A15(PEG_TXP_10)
PEG_TX11_DN: C4833.2(B) U4555.B14(PEG_TXN_11)
PEG_TX11_DP: C4832.2(B) U4555.C14(PEG_TXP_11)
PEG_TX12_DN: C4878.2(B) U4555.B13(PEG_TXN_12)
PEG_TX12_DP: C4880.2(B) U4555.A13(PEG_TXP_12)
PEG_TX13_DN: C4881.2(B) U4555.B12(PEG_TXN_13)
PEG_TX13_DP: C4884.2(B) U4555.C12(PEG_TXP_13)
PEG_TX14_DN: C4886.2(B) U4555.B11(PEG_TXN_14)
PEG_TX14_DP: C4885.2(B) U4555.A11(PEG_TXP_14)
PEG_TX15_DN: C4888.2(B) U4555.B10(PEG_TXN_15)
PEG_TX15_DP: C4887.2(B) U4555.C10(PEG_TXP_15)
PEX_CLKREQ#: Q50010.D R50012.1(A) TP50010.1 U4710.BE31(GPP_B6/SRCCLKREQ1#)
PEX_DGPU_RST#: R50020.1(A) R51512.1(A) R51526.1(A) U50000.BK26(PEX_RST*) U50020.4
PEX_GPU_CLKREQ#: Q50010.S R50011.1(A) U50000.BL26(PEX_CLKREQ*)
PEX_PLL_HVDD_SVDD: C50090.1(A) C50091.1(A) C50092.1(A) R50090.1(A) U50000.BB30(PEX_PLL_HVDD)
PFM_BG_REF_OUT: C52055.1(A) R52050.2(B) R52053.1(A) U52000.23(BG_REF_OUT)
PFM_BS_REF: C52053.1(A) R52053.2(B) R52054.2(B) R52055.2(B) U52000.24(BS_REF)
PFM_CM_REF_IN: C52050.1(A) R52050.1(A) R52051.1(A) U52000.22(CM_REF_IN)
PFM_PF_BSOK_RC: Q52060.1(B) R52060.2(B)
PFM_PF_R_BSOK: R52060.1(A) R52061.1(A) U52000.30(BS_OK)
PHASE_ID: R322.2(B) R337.2(B) U1.68(ADC2/GPI2<3>)
PLT_ID0: R4784.1(A) R4791.2(B) U4710.AR42(GPP_F10/SATA_SCLOCK)
PLT_ID1: R4782.1(A) R4790.2(B) U4710.AR48(GPP_F11/SATA_SLOAD)
PLT_ID2: R4780.1(A) R4788.2(B) U4710.AU46(GPP_F12/SATA_SDATAOUT1)
PLT_ID3: R4781.1(A) R4789.2(B) U4710.AU47(GPP_F13/SATA_SDATAOUT0)
PLT_RST#: U4700.1 U4700.2 U4710.AV29(GPP_B13/PLTRST#)
PLTRST_CPU#: U4555.BP35(RESET#) U4710.AG5(PLTRST_CPU#)
PM_EXTTS#0_R: CN4100.134(EVENT#) R4201.2(B)
PM_EXTTS#1_R: CN4125.134(EVENT#) R4200.2(B)
POLARITY: R2403.1(A) TP2400.1 U8.5(DIR)
PROC_SELECT#: R4520.2(B) U4555.BN1(PROC_SELECT#)
PROCHOT#: R60021.2(B) U60000.10
PUSB3_PWR2: C2547.1(A) C2548.1(A) C2551.1(A) C2552.1(A) CN2500.A4 CN2500.A9 CN2500.B4 CN2500.B9 U2500.1
PV_RGLI: C56452.2(B) R56452.2(B) R56453.2(B) U56400.26(RGLI)
PV_RGLRO: C56404.2(B) R56440.1(A) U56400.27(RGLRO)
PVADPTR: C6037.1(A) C6038.1(A) C60002.1(A) D60000.1(A1) L6035.1(INA) L6036.1(INA) Q60010.5(D3) Q60010.6(D2) Q60010.7(D1) Q60010.8(D0) R6098.1(A) R60002.2(B)
PVCORE: C4500.1(A) C4501.1(A) C4502.1(A) C4503.1(A) C4509.1(A) C4510.1(A) C4511.1(A) C4512.1(A) C4513.1(A) C4514.1(A) C4515.1(A) C4516.1(A) C4517.1(A) C4518.1(A) C4519.1(A) C4520.1(A) C4521.1(A) C4522.1(A) C4523.1(A) C4524.1(A) C4525.1(A) C4526.1(A) C4527.1(A) C4528.1(A) C4529.1(A) C4530.1(A) C4531.1(A) C4532.1(A) C4533.1(A) C4534.1(A) C4535.1(A) C4536.1(A) C4537.1(A) C4538.1(A) C4539.1(A) C4549.1(A) C4551.1(A) C4552.1(A) C4556.1(A) C4557.1(A) C4558.1(A) C4559.1(A) C4560.1(A) C4561.1(A) C4562.1(A) C4563.1(A) C4566.1(A) C4568.1(A) C4598.1(A) C4599.1(A) C4614.1(A) C4667.1(A) C4669.1(A) C4670.1(A) C4679.1(A) C4684.1(A) C4685.1(A) C4686.1(A) C4689.1(A) C4690.1(A) C4691.1(A) C4692.1(A) C4693.1(A) C4694.1(A) C4695.1(A) C4696.1(A) C4697.1(A) C4698.1(A) C4699.1(A) C4710.1(A) C4711.1(A) C4715.1(A) C4720.1(A) C4721.1(A) C4722.1(A) C4723.1(A) C4744.1(A) C4745.1(A) C4746.1(A) C4753.1(A) C4758.1(A) C4800.1(A) C4807.1(A) C4808.1(A) C7512.2(B) C7513.2(B) C66000.1(A) C66001.1(A) C66002.1(A) C66003.1(A) C66004.1(A) C66006.1(A) C66007.1(A) C66008.1(A) C66009.1(A) L66010.2 L66020.2 L66030.2 L66040.2 R21.2(B) TP66000.1 U4555.AA13(VCC1) U4555.AA31(VCC2) U4555.AA32(VCC3) U4555.AA33(VCC4) U4555.AA34(VCC5) U4555.AA35(VCC6) U4555.AA36(VCC7) U4555.AA37(VCC8) U4555.AA38(VCC9) U4555.AB29(VCC10) U4555.AB30(VCC11) U4555.AB31(VCC12) U4555.AB32(VCC13) U4555.AB35(VCC14) U4555.AB36(VCC15) U4555.AB37(VCC16) U4555.AB38(VCC17) U4555.AC13(VCC18) U4555.AC14(VCC19) U4555.AC29(VCC20) U4555.AC30(VCC21) U4555.AC31(VCC22) U4555.AC32(VCC23) U4555.AC33(VCC24) U4555.AC34(VCC25) U4555.AC35(VCC26) U4555.AC36(VCC27) U4555.AD13(VCC28) U4555.AD14(VCC29) U4555.AD31(VCC30) U4555.AD32(VCC31) U4555.AD33(VCC32) U4555.AD34(VCC33) U4555.AD35(VCC34) U4555.AD36(VCC35) U4555.AD37(VCC36) U4555.AD38(VCC37) U4555.AE13(VCC38) U4555.AE14(VCC39) U4555.AE30(VCC40) U4555.AE31(VCC41) U4555.AE32(VCC42) U4555.AE35(VCC43) U4555.AE36(VCC44) U4555.AE37(VCC45) U4555.AE38(VCC46) U4555.AF29(VCC47) U4555.AF30(VCC48) U4555.AF31(VCC49) U4555.AF32(VCC50) U4555.AF33(VCC51) U4555.AF34(VCC52) U4555.AF35(VCC53) U4555.AF36(VCC54) U4555.AF37(VCC55) U4555.AF38(VCC56) U4555.AG14(VCC57) U4555.AG31(VCC58) U4555.AG32(VCC59) U4555.AG33(VCC60) U4555.AG34(VCC61) U4555.AG35(VCC62) U4555.AG36(VCC63) U4555.AH13(VCC64) U4555.AH14(VCC65) U4555.AH29(VCC66) U4555.AH30(VCC67) U4555.AH31(VCC68) U4555.AH32(VCC69) U4555.AJ14(VCC70) U4555.AJ29(VCC71) U4555.AJ30(VCC72) U4555.AJ31(VCC73) U4555.AJ32(VCC74) U4555.AJ33(VCC75) U4555.AJ34(VCC76) U4555.AJ35(VCC77) U4555.AJ36(VCC78) U4555.AK31(VCC79) U4555.AK32(VCC80) U4555.AK33(VCC81) U4555.AK34(VCC82) U4555.AK35(VCC83) U4555.AK36(VCC84) U4555.AK37(VCC85) U4555.AK38(VCC86) U4555.AL13(VCC87) U4555.AL29(VCC88) U4555.AL30(VCC89) U4555.AL31(VCC90) U4555.AL32(VCC91) U4555.AL35(VCC92) U4555.AL36(VCC93) U4555.AL37(VCC94) U4555.AL38(VCC95) U4555.AM13(VCC96) U4555.AM14(VCC97) U4555.AM29(VCC98) U4555.AM30(VCC99) U4555.AM31(VCC100) U4555.AM32(VCC101) U4555.AM33(VCC102) U4555.AM34(VCC103) U4555.AM35(VCC104) U4555.AM36(VCC105) U4555.AN13(VCC106) U4555.AN14(VCC107) U4555.AN31(VCC108) U4555.AN32(VCC109) U4555.AN33(VCC110) U4555.AN34(VCC111) U4555.AN35(VCC112) U4555.AN36(VCC113) U4555.AN37(VCC114) U4555.AN38(VCC115) U4555.AP13(VCC116) U4555.AP30(VCC117) U4555.AP31(VCC118) U4555.AP32(VCC119) U4555.AP35(VCC120) U4555.AP36(VCC121) U4555.AP37(VCC122) U4555.AP38(VCC123) U4555.K13(VCC124) U4555.K14(VCC1) U4555.L13(VCC2) U4555.L14(VCC3) U4555.N13(VCC4) U4555.N14(VCC5) U4555.N30(VCC6) U4555.N31(VCC7) U4555.N32(VCC8) U4555.N35(VCC9) U4555.N36(VCC10) U4555.N37(VCC11) U4555.N38(VCC12) U4555.P13(VCC13) U4555.P14(VCC14) U4555.P29(VCC15) U4555.P30(VCC16) U4555.P31(VCC17) U4555.P32(VCC18) U4555.P33(VCC19) U4555.P34(VCC20) U4555.P35(VCC21) U4555.P36(VCC22) U4555.R13(VCC23) U4555.R31(VCC24) U4555.R32(VCC25) U4555.R33(VCC26) U4555.R34(VCC27) U4555.R35(VCC28) U4555.R36(VCC29) U4555.R37(VCC30) U4555.R38(VCC31) U4555.T29(VCC32) U4555.T30(VCC33) U4555.T31(VCC34) U4555.T32(VCC35) U4555.T35(VCC36) U4555.T36(VCC37) U4555.T37(VCC38) U4555.T38(VCC39) U4555.U29(VCC40) U4555.U30(VCC41) U4555.U31(VCC42) U4555.U32(VCC43) U4555.U33(VCC44) U4555.U34(VCC45) U4555.U35(VCC46) U4555.U36(VCC47) U4555.V13(VCC48) U4555.V14(VCC49) U4555.V31(VCC50) U4555.V32(VCC51) U4555.V33(VCC52) U4555.V34(VCC53) U4555.V35(VCC54) U4555.V36(VCC55) U4555.V37(VCC56) U4555.V38(VCC57) U4555.W13(VCC58) U4555.W14(VCC59) U4555.W29(VCC60) U4555.W30(VCC61) U4555.W31(VCC62) U4555.W32(VCC63) U4555.W35(VCC64) U4555.W36(VCC65) U4555.W37(VCC66) U4555.W38(VCC67) U4555.Y29(VCC68) U4555.Y30(VCC69) U4555.Y31(VCC70) U4555.Y32(VCC71) U4555.Y33(VCC72) U4555.Y34(VCC73) U4555.Y35(VCC74) U4555.Y36(VCC75)
PVCORE_DGPU: C7504.2(B) C7505.2(B) C7564.1(A) C7566.1(A) C7567.1(A) C7568.1(A) C52002.1(A) C52003.1(A) C52004.1(A) C52005.1(A) C52400.1(A) C52401.1(A) C52402.1(A) C52403.1(A) C52404.1(A) C52405.1(A) C52406.1(A) C52407.1(A) C52408.1(A) C52409.1(A) C52410.1(A) C52411.1(A) C52412.1(A) C52413.1(A) C52414.1(A) C52415.1(A) C52416.1(A) C52417.1(A) C52418.1(A) C52419.1(A) C52420.1(A) C52421.1(A) C52422.1(A) C52423.1(A) C52424.1(A) C52425.1(A) C52426.1(A) C52427.1(A) C52428.1(A) C52429.1(A) C52430.1(A) C52431.1(A) C52432.1(A) C52433.1(A) C52434.1(A) C52435.1(A) C52436.1(A) C52437.1(A) C52438.1(A) C52439.1(A) C52440.1(A) C52441.1(A) C52442.1(A) C52443.1(A) C52444.1(A) C52445.1(A) C52446.1(A) C52447.1(A) C52448.1(A) C52449.1(A) C52450.1(A) C52451.1(A) C52452.1(A) C52453.1(A) C52454.1(A) C52455.1(A) C52456.1(A) C52457.1(A) C52458.1(A) C52459.1(A) C52460.1(A) C52461.1(A) C52462.1(A) C52463.1(A) C52464.1(A) C52465.1(A) C52466.1(A) C52467.1(A) C52468.1(A) C52469.1(A) C52470.1(A) C52471.1(A) C52472.1(A) C52473.1(A) C52474.1(A) C52475.1(A) C52476.1(A) C52477.1(A) C52478.1(A) C52479.1(A) C52480.1(A) C52481.1(A) C52482.1(A) C52483.1(A) C52484.1(A) C52485.1(A) C52486.1(A) C52487.1(A) C52488.1(A) C52489.1(A) C52490.1(A) C52491.1(A) C52492.1(A) C52493.1(A) C52494.1(A) C52495.1(A) C52496.1(A) C52497.1(A) C52498.1(A) C52499.1(A) C52500.1(A) C52501.1(A) C52502.1(A) C52503.1(A) C52504.1(A) C52505.1(A) C52506.1(A) C52507.1(A) C52508.1(A) C52509.1(A) C52510.1(A) C52511.1(A) C52512.1(A) C52513.1(A) C52514.1(A) C52515.1(A) C52516.1(A) C52517.1(A) C52518.1(A) C52519.1(A) C52520.1(A) C52521.1(A) C52522.1(A) C52523.1(A) C52524.1(A) C52525.1(A) C52526.1(A) C52527.1(A) C52528.1(A) C52529.1(A) C52530.1(A) C52531.1(A) C52532.1(A) C52533.1(A) C52534.1(A) C52535.1(A) C52536.1(A) C52537.1(A) C52538.1(A) C52539.1(A) C52540.1(A) C52541.1(A) C52542.1(A) C52543.1(A) C52544.1(A) C52545.1(A) C52546.1(A) C52547.1(A) C52548.1(A) C52549.1(A) C52550.1(A) C52551.1(A) C52552.1(A) C52553.1(A) C52554.1(A) C52555.1(A) C52556.1(A) C52557.1(A) C52558.1(A) C52559.1(A) C52560.1(A) C52561.1(A) C52562.1(A) C52563.1(A) C52564.1(A) C52565.1(A) C52566.1(A) C52567.1(A) C52568.1(A) C52569.1(A) C52570.1(A) C52571.1(A) C52572.1(A) C52573.1(A) C52574.1(A) C52575.1(A) C52576.1(A) C52577.1(A) C52578.1(A) C52579.1(A) C52580.1(A) C52581.1(A) C52582.1(A) C52583.1(A) C52584.1(A) C52600.1(A) C52601.1(A) C52602.1(A) C52603.1(A) C52604.1(A) C52605.1(A) C52606.1(A) C52607.1(A) C52608.1(A) C52609.1(A) C52610.1(A) C52611.1(A) C52612.1(A) C52613.1(A) C52614.1(A) C52615.1(A) C52616.1(A) C52617.1(A) C52618.1(A) C52619.1(A) C52620.1(A) C52621.1(A) C52622.1(A) C52630.1(A) C52631.1(A) C52632.1(A) C52633.1(A) C52640.1(A) C52641.1(A) C52642.1(A) C52650.1(A) C52651.1(A) C67000.1(A) C67001.1(A) C67002.1(A) C67003.1(A) C67004.1(A) C67005.1(A) C67006.1(A) C67090.1(A) C67091.1(A) C67092.1(A) C67093.1(A) C67094.1(A) C67095.1(A) C67096.1(A) C67097.1(A) L67010.2 L67010.4 L67020.2 L67020.4 L67030.2 L67030.4 L67040.2 L67040.4 L67050.2 L67050.4 L67060.2 L67060.4 R55215.2(B) R55216.2(B) R55217.2(B) R55218.2(B) R67002.2(B) TP67000.1 U50000.AA13(VDD_001) U50000.AA14(VDD_002) U50000.AA15(VDD_003) U50000.AA16(VDD_004) U50000.AA17(VDD_005) U50000.AA18(VDD_006) U50000.AA19(VDD_007) U50000.AA20(VDD_008) U50000.AA21(VDD_009) U50000.AA22(VDD_010) U50000.AA23(VDD_011) U50000.AA24(VDD_012) U50000.AA25(VDD_013) U50000.AA26(VDD_014) U50000.AA27(VDD_015) U50000.AA28(VDD_016) U50000.AA29(VDD_017) U50000.AA30(VDD_018) U50000.AA31(VDD_019) U50000.AA32(VDD_020) U50000.AA33(VDD_021) U50000.AA34(VDD_022) U50000.AA35(VDD_023) U50000.AA36(VDD_024) U50000.AA37(VDD_025) U50000.AA38(VDD_026) U50000.AA39(VDD_027) U50000.AA40(VDD_028) U50000.AB13(VDD_029) U50000.AB40(VDD_030) U50000.AC13(VDD_031) U50000.AC14(VDD_032) U50000.AC15(VDD_033) U50000.AC16(VDD_034) U50000.AC17(VDD_035) U50000.AC18(VDD_036) U50000.AC19(VDD_037) U50000.AC20(VDD_038) U50000.AC21(VDD_039) U50000.AC22(VDD_040) U50000.AC23(VDD_041) U50000.AC24(VDD_042) U50000.AC25(VDD_043) U50000.AC26(VDD_044) U50000.AC27(VDD_045) U50000.AC28(VDD_046) U50000.AC29(VDD_047) U50000.AC30(VDD_048) U50000.AC31(VDD_049) U50000.AC32(VDD_050) U50000.AC33(VDD_051) U50000.AC34(VDD_052) U50000.AC35(VDD_053) U50000.AC36(VDD_054) U50000.AC37(VDD_055) U50000.AC38(VDD_056) U50000.AC39(VDD_057) U50000.AC40(VDD_058) U50000.AD13(VDD_059) U50000.AD40(VDD_060) U50000.AE13(VDD_061) U50000.AE14(VDD_062) U50000.AE15(VDD_063) U50000.AE16(VDD_064) U50000.AE17(VDD_065) U50000.AE18(VDD_066) U50000.AE19(VDD_067) U50000.AE20(VDD_068) U50000.AE21(VDD_069) U50000.AE22(VDD_070) U50000.AE23(VDD_071) U50000.AE24(VDD_072) U50000.AE25(VDD_073) U50000.AE26(VDD_074) U50000.AE27(VDD_075) U50000.AE28(VDD_076) U50000.AE29(VDD_077) U50000.AE30(VDD_078) U50000.AE31(VDD_079) U50000.AE32(VDD_080) U50000.AE33(VDD_081) U50000.AE34(VDD_082) U50000.AE35(VDD_083) U50000.AE36(VDD_084) U50000.AE37(VDD_085) U50000.AE38(VDD_086) U50000.AE39(VDD_087) U50000.AE40(VDD_088) U50000.AF13(VDD_089) U50000.AF14(VDD_090) U50000.AF15(VDD_091) U50000.AF16(VDD_092) U50000.AF17(VDD_093) U50000.AF18(VDD_094) U50000.AF24(VDD_095) U50000.AF25(VDD_096) U50000.AF26(VDD_097) U50000.AF30(VDD_098) U50000.AF31(VDD_099) U50000.AF32(VDD_100) U50000.AF33(VDD_101) U50000.AF34(VDD_102) U50000.AF40(VDD_103) U50000.AG13(VDD_104) U50000.AG19(VDD_105) U50000.AG20(VDD_106) U50000.AG21(VDD_107) U50000.AG22(VDD_108) U50000.AG23(VDD_109) U50000.AG27(VDD_110) U50000.AG28(VDD_111) U50000.AG29(VDD_112) U50000.AG35(VDD_113) U50000.AG36(VDD_114) U50000.AG37(VDD_115) U50000.AG38(VDD_116) U50000.AG39(VDD_117) U50000.AG40(VDD_118) U50000.AH13(VDD_119) U50000.AH14(VDD_120) U50000.AH15(VDD_121) U50000.AH16(VDD_122) U50000.AH17(VDD_123) U50000.AH18(VDD_124) U50000.AH19(VDD_125) U50000.AH20(VDD_126) U50000.AH21(VDD_127) U50000.AH22(VDD_128) U50000.AH23(VDD_129) U50000.AH24(VDD_130) U50000.AH25(VDD_131) U50000.AH26(VDD_132) U50000.AH27(VDD_133) U50000.AH28(VDD_134) U50000.AH29(VDD_135) U50000.AH30(VDD_136) U50000.AH31(VDD_137) U50000.AH32(VDD_138) U50000.AH33(VDD_139) U50000.AH34(VDD_140) U50000.AH35(VDD_141) U50000.AH36(VDD_142) U50000.AH37(VDD_143) U50000.AH38(VDD_144) U50000.AH39(VDD_145) U50000.AH40(VDD_146) U50000.AJ13(VDD_147) U50000.AJ40(VDD_148) U50000.AK13(VDD_149) U50000.AK14(VDD_150) U50000.AK15(VDD_151) U50000.AK16(VDD_152) U50000.AK17(VDD_153) U50000.AK18(VDD_154) U50000.AK19(VDD_155) U50000.AK20(VDD_156) U50000.AK21(VDD_157) U50000.AK22(VDD_158) U50000.AK23(VDD_159) U50000.AK24(VDD_160) U50000.AK25(VDD_161) U50000.AK26(VDD_162) U50000.AK27(VDD_163) U50000.AK28(VDD_164) U50000.AK29(VDD_165) U50000.AK30(VDD_166) U50000.AK31(VDD_167) U50000.AK32(VDD_168) U50000.AK33(VDD_169) U50000.AK34(VDD_170) U50000.AK35(VDD_171) U50000.AK36(VDD_172) U50000.AK37(VDD_173) U50000.AK38(VDD_174) U50000.AK39(VDD_175) U50000.AK40(VDD_176) U50000.AL13(VDD_177) U50000.AL40(VDD_178) U50000.AM13(VDD_179) U50000.AM14(VDD_180) U50000.AM15(VDD_181) U50000.AM16(VDD_182) U50000.AM17(VDD_183) U50000.AM18(VDD_184) U50000.AM19(VDD_185) U50000.AM20(VDD_186) U50000.AM21(VDD_187) U50000.AM22(VDD_188) U50000.AM23(VDD_189) U50000.AM24(VDD_190) U50000.AM25(VDD_191) U50000.AM26(VDD_192) U50000.AM27(VDD_193) U50000.AM28(VDD_194) U50000.AM29(VDD_195) U50000.AM30(VDD_196) U50000.AM31(VDD_197) U50000.AM32(VDD_198) U50000.AM33(VDD_199) U50000.AM34(VDD_200) U50000.AM35(VDD_201) U50000.AM36(VDD_202) U50000.AM37(VDD_203) U50000.AM38(VDD_204) U50000.AM39(VDD_205) U50000.AM40(VDD_206) U50000.AN13(VDD_207) U50000.AN40(VDD_208) U50000.AP13(VDD_209) U50000.AP14(VDD_210) U50000.AP15(VDD_211) U50000.AP16(VDD_212) U50000.AP17(VDD_213) U50000.AP18(VDD_214) U50000.AP19(VDD_215) U50000.AP20(VDD_216) U50000.AP21(VDD_217) U50000.AP22(VDD_218) U50000.AP23(VDD_219) U50000.AP24(VDD_220) U50000.AP25(VDD_221) U50000.AP26(VDD_222) U50000.AP27(VDD_223) U50000.AP28(VDD_224) U50000.AP29(VDD_225) U50000.AP30(VDD_226) U50000.AP31(VDD_227) U50000.AP32(VDD_228) U50000.AP33(VDD_229) U50000.AP34(VDD_230) U50000.AP35(VDD_231) U50000.AP36(VDD_232) U50000.AP37(VDD_233) U50000.AP38(VDD_234) U50000.AP39(VDD_235) U50000.AP40(VDD_236) U50000.AR13(VDD_237) U50000.AR40(VDD_238) U50000.AT13(VDD_239) U50000.AT14(VDD_240) U50000.AT15(VDD_241) U50000.AT16(VDD_242) U50000.AT17(VDD_243) U50000.AT18(VDD_244) U50000.AT19(VDD_245) U50000.AT20(VDD_246) U50000.AT21(VDD_247) U50000.AT22(VDD_248) U50000.AT23(VDD_249) U50000.AT24(VDD_250) U50000.AT25(VDD_251) U50000.AT26(VDD_252) U50000.AT27(VDD_253) U50000.AT28(VDD_254) U50000.AT29(VDD_255) U50000.AT30(VDD_256) U50000.AT31(VDD_257) U50000.AT32(VDD_258) U50000.AT33(VDD_259) U50000.AT34(VDD_260) U50000.AT35(VDD_261) U50000.AT36(VDD_262) U50000.AT37(VDD_263) U50000.AT38(VDD_264) U50000.AT39(VDD_265) U50000.AT40(VDD_266) U50000.AT42(VDD_267) U50000.AU13(VDD_268) U50000.AU40(VDD_269) U50000.AU43(VDD_270) U50000.AV13(VDD_271) U50000.AV14(VDD_272) U50000.AV15(VDD_273) U50000.AV16(VDD_274) U50000.AV17(VDD_275) U50000.AV18(VDD_276) U50000.AV19(VDD_277) U50000.AV20(VDD_278) U50000.AV21(VDD_279) U50000.AV22(VDD_280) U50000.AV23(VDD_281) U50000.AV24(VDD_282) U50000.AV25(VDD_283) U50000.AV26(VDD_284) U50000.AV27(VDD_285) U50000.AV28(VDD_286) U50000.AV29(VDD_287) U50000.AV30(VDD_288) U50000.AV31(VDD_289) U50000.AV32(VDD_290) U50000.AV33(VDD_291) U50000.AV34(VDD_292) U50000.AV35(VDD_293) U50000.AV36(VDD_294) U50000.AV37(VDD_295) U50000.AV38(VDD_296) U50000.AV39(VDD_297) U50000.AV40(VDD_298) U50000.AV42(VDD_299) U50000.AV43(VDD_300) U50000.AV44(VDD_301) U50000.AW13(VDD_302) U50000.AW40(VDD_303) U50000.AW42(VDD_304) U50000.AW43(VDD_305) U50000.AW44(VDD_306) U50000.AW45(VDD_307) U50000.AY13(VDD_308) U50000.AY14(VDD_309) U50000.AY15(VDD_310) U50000.AY16(VDD_311) U50000.AY17(VDD_312) U50000.AY18(VDD_313) U50000.AY19(VDD_314) U50000.AY20(VDD_315) U50000.AY21(VDD_316) U50000.AY22(VDD_317) U50000.AY23(VDD_318) U50000.AY24(VDD_319) U50000.AY25(VDD_320) U50000.AY26(VDD_321) U50000.AY27(VDD_322) U50000.AY28(VDD_323) U50000.AY29(VDD_324) U50000.AY30(VDD_325) U50000.AY31(VDD_326) U50000.AY32(VDD_327) U50000.AY33(VDD_328) U50000.AY34(VDD_329) U50000.AY35(VDD_330) U50000.AY36(VDD_331) U50000.AY37(VDD_332) U50000.AY38(VDD_333) U50000.AY39(VDD_334) U50000.AY40(VDD_335) U50000.AY43(VDD_336) U50000.AY45(VDD_337) U50000.BA43(VDD_338) U50000.BA44(VDD_339) U50000.BA45(VDD_340) U50000.BA46(VDD_341) U50000.BA47(VDD_342) U50000.BB38(VDD_343) U50000.BB39(VDD_344) U50000.BB45(VDD_345) U50000.BB46(VDD_346) U50000.BB47(VDD_347) U50000.BB48(VDD_348) U50000.BC38(VDD_349) U50000.BC39(VDD_350) U50000.BC40(VDD_351) U50000.BC41(VDD_352) U50000.BC45(VDD_353) U50000.BC47(VDD_354) U50000.BC49(VDD_355) U50000.BD39(VDD_356) U50000.BD41(VDD_357) U50000.BD46(VDD_358) U50000.BD47(VDD_359) U50000.BD48(VDD_360) U50000.BD49(VDD_361) U50000.BD50(VDD_362) U50000.BD51(VDD_363) U50000.BE41(VDD_364) U50000.BE42(VDD_365) U50000.BE43(VDD_366) U50000.BE46(VDD_367) U50000.BE47(VDD_368) U50000.BE48(VDD_369) U50000.BE49(VDD_370) U50000.BE50(VDD_371) U50000.BE51(VDD_372) U50000.BE52(VDD_373) U50000.BF42(VDD_374) U50000.BF44(VDD_375) U50000.BF45(VDD_376) U50000.BF47(VDD_377) U50000.BF49(VDD_378) U50000.BF51(VDD_379) U50000.BG43(VDD_380) U50000.BG44(VDD_381) U50000.BG45(VDD_382) U50000.BG46(VDD_383) U50000.BG47(VDD_384) U50000.BG48(VDD_385) U50000.BG49(VDD_386) U50000.BG50(VDD_387) U50000.BG51(VDD_388) U50000.BG52(VDD_389) U50000.BH44(VDD_390) U50000.BH45(VDD_391) U50000.BH47(VDD_392) U50000.BH48(VDD_393) U50000.BH49(VDD_394) U50000.BH50(VDD_395) U50000.BH51(VDD_396) U50000.BH52(VDD_397) U50000.BJ44(VDD_398) U50000.BJ45(VDD_399) U50000.BJ46(VDD_400) U50000.BJ47(VDD_401) U50000.BJ48(VDD_402) U50000.BJ49(VDD_403) U50000.BJ50(VDD_404) U50000.BJ51(VDD_405) U50000.BJ52(VDD_406) U50000.BK47(VDD_407) U50000.BK48(VDD_408) U50000.BK49(VDD_409) U50000.BK50(VDD_410) U50000.BK51(VDD_411) U50000.BK52(VDD_412) U50000.BL46(VDD_413) U50000.BL47(VDD_414) U50000.BL48(VDD_415) U50000.BL49(VDD_416) U50000.BL50(VDD_417) U50000.BL51(VDD_418) U50000.BL52(VDD_419) U50000.BM47(VDD_420) U50000.BM48(VDD_421) U50000.BM49(VDD_422) U50000.BM50(VDD_423) U50000.BM51(VDD_424) U50000.N13(VDD_425) U50000.N14(VDD_426) U50000.N15(VDD_427) U50000.N16(VDD_428) U50000.N17(VDD_429) U50000.N18(VDD_430) U50000.N19(VDD_431) U50000.N20(VDD_432) U50000.N21(VDD_433) U50000.N22(VDD_434) U50000.N23(VDD_435) U50000.N24(VDD_436) U50000.N25(VDD_437) U50000.N26(VDD_438) U50000.N27(VDD_439) U50000.N28(VDD_440) U50000.N29(VDD_441) U50000.N30(VDD_442) U50000.N31(VDD_443) U50000.N32(VDD_444) U50000.N33(VDD_445) U50000.N34(VDD_446) U50000.N35(VDD_447) U50000.N36(VDD_448) U50000.N37(VDD_449) U50000.N38(VDD_450) U50000.N39(VDD_451) U50000.N40(VDD_452) U50000.P13(VDD_453) U50000.P40(VDD_454) U50000.R13(VDD_455) U50000.R14(VDD_456) U50000.R15(VDD_457) U50000.R16(VDD_458) U50000.R17(VDD_459) U50000.R18(VDD_460) U50000.R19(VDD_461) U50000.R20(VDD_462) U50000.R21(VDD_463) U50000.R22(VDD_464) U50000.R23(VDD_465) U50000.R24(VDD_466) U50000.R25(VDD_467) U50000.R26(VDD_468) U50000.R27(VDD_469) U50000.R28(VDD_470) U50000.R29(VDD_471) U50000.R30(VDD_472) U50000.R31(VDD_473) U50000.R32(VDD_474) U50000.R33(VDD_475) U50000.R34(VDD_476) U50000.R35(VDD_477) U50000.R36(VDD_478) U50000.R37(VDD_479) U50000.R38(VDD_480) U50000.R39(VDD_481) U50000.R40(VDD_482) U50000.T13(VDD_483) U50000.T40(VDD_484) U50000.U13(VDD_485) U50000.U14(VDD_486) U50000.U15(VDD_487) U50000.U16(VDD_488) U50000.U17(VDD_489) U50000.U18(VDD_490) U50000.U19(VDD_491) U50000.U20(VDD_492) U50000.U21(VDD_493) U50000.U22(VDD_494) U50000.U23(VDD_495) U50000.U24(VDD_496) U50000.U25(VDD_497) U50000.U26(VDD_498) U50000.U27(VDD_499) U50000.U28(VDD_500) U50000.U29(VDD_501) U50000.U30(VDD_502) U50000.U31(VDD_503) U50000.U32(VDD_504) U50000.U33(VDD_505) U50000.U34(VDD_506) U50000.U35(VDD_507) U50000.U36(VDD_508) U50000.U37(VDD_509) U50000.U38(VDD_510) U50000.U39(VDD_511) U50000.U40(VDD_512) U50000.V13(VDD_513) U50000.V40(VDD_514) U50000.W13(VDD_515) U50000.W14(VDD_516) U50000.W15(VDD_517) U50000.W16(VDD_518) U50000.W17(VDD_519) U50000.W18(VDD_520) U50000.W19(VDD_521) U50000.W20(VDD_522) U50000.W21(VDD_523) U50000.W22(VDD_524) U50000.W23(VDD_525) U50000.W24(VDD_526) U50000.W25(VDD_527) U50000.W26(VDD_528) U50000.W27(VDD_529) U50000.W28(VDD_530) U50000.W29(VDD_531) U50000.W30(VDD_532) U50000.W31(VDD_533) U50000.W32(VDD_534) U50000.W33(VDD_535) U50000.W34(VDD_536) U50000.W35(VDD_537) U50000.W36(VDD_538) U50000.W37(VDD_539) U50000.W38(VDD_540) U50000.W39(VDD_541) U50000.W40(VDD_542) U50000.Y13(VDD_543) U50000.Y40(VDD_544)
PVCORE_PG: R7009.1(A) R66602.1(A) U66000.45
PVPACK: C68.1(A) C7689.1(A) C7699.1(A) C60010.1(A) C60011.1(A) C60025.1(A) CN6050.7 CN6050.8 D60002.1(A1) D60002.2(A2) R60001.2
PWR_DP: PAD56250.1 R56250.2(B) U56250.1(OUT)
PWR_LED: CN603.13 U1.24(PWM0/GPA0)
Q4001: C426.2(B) Q400.1 R408.2(B) R409.1(A)
Q4021: C421.1(A) Q401.G R403.2(B)
Q4023: Q401.D R409.2(B)
R_GPP_A11: R4911.2(B) U4710.BE36(GPP_A11/PME#/SD_VDD2_PWR_EN#)
REAR1_A_EQ0: R1702.2(B) R1710.2(B) U1700.21(EQA0)
REAR1_A_EQ1: R1703.2(B) R1711.2(B) U1700.26(EQA1)
REAR1_B_EQ0: R1704.2(B) R1712.2(B) U1700.20(EQB0)
REAR1_B_EQ1: R1705.2(B) R1713.2(B) U1700.15(EQB1)
REAR1_FGA: R1706.2(B) R1715.2(B) U1700.27(FGA)
REAR1_FGB: R1707.2(B) R1714.2(B) U1700.14(FGB)
REAR1_SWA: R1708.2(B) R1716.2(B) U1700.29(SWA)
REAR1_SWB: R1709.2(B) R1717.2(B) U1700.12(SWB)
REP_LAN_C_RX13N: C1704.2(B) CN603.23
REP_LAN_C_RX13P: C1705.2(B) CN603.24
REP_LAN_RX13N: C1704.1(A) U1700.18(BIN)
REP_LAN_RX13P: C1705.1(A) U1700.17(BIP)
REP_LAN_TX13N: CN603.26 U1700.23(AON)
REP_LAN_TX13P: CN603.27 U1700.24(AOP)
REPEATER_DP_LANE0N: C55801.1(A) U55800.34(A0TX-)
REPEATER_DP_LANE0P: C55800.1(A) U55800.35(A0TX+)
REPEATER_DP_LANE1N: C55803.1(A) U55800.31(A1TX-)
REPEATER_DP_LANE1P: C55802.1(A) U55800.32(A1TX+)
REPEATER_DP_LANE2N: C55805.1(A) U55800.28(A2TX-)
REPEATER_DP_LANE2P: C55804.1(A) U55800.29(A2TX+)
REPEATER_DP_LANE3N: C55807.1(A) U55800.25(A3TX-)
REPEATER_DP_LANE3P: C55806.1(A) U55800.26(A3TX+)
REPEATER_DP_LANE_0N: C55801.2(B) L56220.1(INC)
REPEATER_DP_LANE_0P: C55800.2(B) L56220.2(INA)
REPEATER_DP_LANE_1N: C55803.2(B) L56221.1(INC)
REPEATER_DP_LANE_1P: C55802.2(B) L56221.2(INA)
REPEATER_DP_LANE_2N: C55805.2(B) L56225.1(INC)
REPEATER_DP_LANE_2P: C55804.2(B) L56225.2(INA)
REPEATER_DP_LANE_3N: C55807.2(B) L56226.1(INC)
REPEATER_DP_LANE_3P: C55806.2(B) L56226.2(INA)
REPEATER_HDMI_CLKN: R56688.1(A) U56400.16(TXCM)
REPEATER_HDMI_CLKP: R56687.1(A) U56400.17(TXCP)
REPEATER_HDMI_D0N: R56686.1(A) U56400.18(TX0M)
REPEATER_HDMI_D0P: R56685.1(A) U56400.19(TX0P)
REPEATER_HDMI_D1N: R56684.1(A) U56400.21(TX1M)
REPEATER_HDMI_D1P: R56683.1(A) U56400.22(TX1P)
