# Allegro board PH317-53 COVINI-6050A3087701-MB-AX2 (BDV)(.BRD).brd (continued)
## Nets (continued)
REPEATER_HDMI_D2N: R56682.1(A) U56400.23(TX2M)
REPEATER_HDMI_D2P: R56681.1(A) U56400.24(TX2P)
RESUME_PWEN: D7001.1(A2) R7030.1(A) R7040.1(A) R7041.1(A) U1.123(CTX0/TMA0/GPB2<3>)
RET_ADDR: R56435.2(B) R56436.1(A) U56400.6(PCADR)
RET_GPIO1: R56432.1(A) R56433.2(B) U56400.4(GPIO)
RET_GPIO2: R56430.1(A) R56431.2(B) U56400.9(URDBG)
RET_RAVCC10: C564001.1(A) L56401.2(INB) U56400.41(RAVCC10)
RET_RAVCC33: C56400.1(A) L56400.2(INB) U56400.46(RVCC33)
RET_RVCC10: C56402.1(A) L56402.2(INB) U56400.47(RVCC10)
RET_TAVCC10: C56405.1(A) C56406.1(A) L56405.1(INA) U56400.20(TAVCC10)
RET_TVCC10: C56407.1(A) L56407.1(INA) U56400.15(TVCC10)
RET_TVCC33: C56408.1(A) C56409.1(A) L56408.1(INA) U56400.14(TVCC33)
RING2: CN603.5 U500.17(MIC2-L/RING2)
RING2_CONN: C24.1(A) D7523.2 JACK600.3 L601.1(INA)
RSMRST#: C7011.1(A) R346.2(B) R7019.2(B) U4710.BA47(RSMRST#)
RSMRST_EC: R315.2(B) R346.1(A)
RSVD1: TP4600.1 U4710.BC1(RSVD1)
RTC_RST#: C4714.1(A) Q300.3(D2) R4764.2(B) R4795.1(A) U4710.BE47(RTCRST#)
RTC_X1: C4767.2(B) R4862.1(A) U4710.BA49(RTCX1) X4750.1
RTC_X2: C4788.2(B) R4862.2(B) U4710.BA48(RTCX2) X4750.4
RUNSCI#: R4882.2(B) U4710.AV21(GPP_C23/UART2_CTS#)
SA0_DIM0: CN4100.256(SA0) R60.1(A) R4210.2(B)
SA0_DIM1: CN4125.256(SA0) R4216.2(B) R4217.1(A)
SA1_DIM0: CN4100.260(SA1) R4212.2(B) R4213.1(A)
SA1_DIM1: CN4125.260(SA1) R4119.1(A) R4218.2(B)
SA2_DIM0: CN4100.166(SA2) R4211.1(A) R4214.2(B)
SA2_DIM1: CN4125.166(SA2) R4219.1(A) R4220.2(B)
SATA_LED#: R4749.2(B) U4710.AK48(GPP_E8/SATA_LED#)
SATA_PCIE_SEL: R1718.2(B) U1700.30(MODE)
SB_PWRBTN#: R350.2(B) U4710.BE46(GPD3/PWRBTN#)
SB_PWRBTN#_EC: R350.1(A) U1.83(EGCS#/GPE2)
SBPWR_EN_EC: R352.1(A) U1.82(EGAD/GPE1)
SCAN_IN<0>: CN250.26 D250.1 U1.58(KSI0/STB#)
SCAN_IN<1>: CN250.25 D251.1 U1.59(KSI1/AFD#)
SCAN_IN<2>: CN250.24 D252.1 U1.60(KSI2/INIT#)
SCAN_IN<3>: CN250.23 D253.1 U1.61(KSI3/SLIN#)
SCAN_IN<4>: CN250.22 D254.1 U1.62(KSI4)
SCAN_IN<5>: CN250.21 D255.1 U1.63(KSI5)
SCAN_IN<6>: CN250.20 D256.1 TP306.1 U1.64(KSI6)
SCAN_IN<7>: CN250.19 D257.1 TP307.1 U1.65(KSI7)
SCAN_OUT<0>: CN250.3 U1.36(KSO0/PD0)
SCAN_OUT<1>: CN250.4 U1.37(KSO1/PD1)
SCAN_OUT<2>: CN250.5 U1.38(KSO2/PD2)
SCAN_OUT<3>: CN250.6 U1.39(KSO3/PD3)
SCAN_OUT<4>: CN250.7 U1.40(KSO4/PD4)
SCAN_OUT<5>: CN250.8 U1.41(KSO5/PD5)
SCAN_OUT<6>: CN250.9 U1.42(KSO6/PD6)
SCAN_OUT<7>: CN250.10 U1.43(KSO7/PD7)
SCAN_OUT<8>: CN250.11 U1.44(KSO8/ACK#)
SCAN_OUT<9>: CN250.12 U1.45(KSO9/BUSY)
SCAN_OUT<10>: CN250.13 U1.46(KSO10/PE)
SCAN_OUT<11>: CN250.14 U1.51(KSO11/ERR#)
SCAN_OUT<12>: CN250.15 U1.52(KSO12/SLCT)
SCAN_OUT<13>: CN250.16 U1.53(KSO13)
SCAN_OUT<14>: CN250.17 U1.54(KSO14)
SCAN_OUT<15>: CN250.18 U1.55(KSO15)
SCAN_OUT<16>: CN250.1 U1.56(KSO16/SMOSI/GPC3<3>)
SCAN_OUT<17>: CN250.2 U1.57(KSO17/SMISO/GPC5<3>)
SD3_1P8_RCOMP: R4605.1(A) U4710.BE5(SD_RCOMP_1P8)
SD3_3P3_RCOMP: R4606.1(A) U4710.BE4(SD_RCOMP_3P3)
SERIRQ: R4873.2(B) R4904.1(A) U1.5(SERIRQ/GPM6<3>) U4710.AW35(GPP_A6/SERIRQ/ESPI_CS1#)
SERIRQ_ESPI_RST#: R4902.2(B) R4904.2(B) TP4806.1
SET_R: R2559.2(B) U2501.4
SH_IN_N3: R52038.1(A) U52000.13(SH_IN_N3)
SH_IN_N4: R52036.1(A) U52000.16(SH_IN_N4)
SH_IN_P3: R52039.1(A) U52000.12(SH_IN_P3)
SH_IN_P4: R52037.1(A) U52000.15(SH_IN_P4)
SLEEVE: CN603.6 U500.18(MIC2-R/SLEEVE)
SLP_A: TP4700.1 U4710.BE40(GPD6/SLP_A#)
SLP_LAN#: TP4703.1 U4710.BF40(SLP_LAN#)
SLP_S0#: TP4701.1 U4710.BC28(GPP_B12/SLP_S0#)
SLP_S3#: R4718.1(A) U1.119(DSR0#/GPG6) U4710.BF42(GPD4/SLP_S3#)
SLP_S4#: U1.21(RI2#/GPD1) U4710.BE42(GPD5/SLP_S4#)
SLP_S5#_3R: TP4705.1 U4710.BC42(GPD10/SLP_S5#)
SLP_SUS#: U1.118(SMDAT2/PECIRQT#/GPF7<3>) U4710.BD39(SLP_SUS#)
SLP_WLAN#: Q1300.1(G) R1301.2(B) U4710.BD42(GPD9/SLP_WLAN#)
SMB0_CLK: Q303.6(D1) Q700.6(D1) R359.2(B) U1.110(SMCLK0/GPB3)
SMB0_CLK_D: Q303.1(S1) R325.2(B) R55832.1(A) R56463.2(B) U4450.8 U55800.19(SCL)
SMB0_DATA: Q303.3(D2) Q700.3(D2) R360.2(B) U1.111(SMDAT0/GPB4)
SMB0_DATA_D: Q303.4(S2) R327.2(B) R55831.1(A) R56462.2(B) TP4450.1 U4450.7 U55800.18(SDA)
SMBALERT#: R4717.1(A) U4710.BE25(GPP_C2/SMBALERT#)
SPI0_CS1#: TP4714.1 U4710.AW48(SPI0_CS1#)
SPI_EC_CLK: R311.1(A) U1.105(FSCK/GPG7)
SPI_EC_CS0#: R13.1(A) U1.101(FSCE#/GPG3)
SPI_EC_SI: R12.1(A) U1.102(FMOSI/GPG4)
SPI_EC_SO: R11.1(A) U1.103(FMISO/GPG5)
SPK_OUT_L_N: R508.2(B) U500.43(SPK-L-)
SPK_OUT_L_P: R509.2(B) U500.42(SPK-L+)
SPK_OUT_R_L_N: CN603.11 R508.1(A)
SPK_OUT_R_L_P: CN603.12 R509.1(A)
SPK_OUT_R_N: R510.2(B) U500.44(SPK-R-)
SPK_OUT_R_P: R511.2(B) U500.45(SPK-R+)
SPK_OUT_R_R_N: CN603.10 R510.1(A)
SPK_OUT_R_R_P: CN603.9 R511.1(A)
SRTC_RST#: C4713.1(A) Q300.6(D1) R4762.1(A) U4710.BD46(SRTCRST#)
SSD1_DEVSLP: CN1901.38(DEVSLP) R1900.2(B)
SSD1_SATA_LED#: CN1901.10(DAS/DSS#) TP1901.1
SSD1_TX9N: C1916.2(B) CN1901.11(PETP3)
SSD1_TX9P: C1919.2(B) CN1901.13(PETN3)
SSD1_TX10N: C1917.2(B) CN1901.23(PETP2)
SSD1_TX10P: C1918.2(B) CN1901.25(PETN2)
SSD1_TX11N: C1920.2(B) CN1901.35(PETN1)
SSD1_TX11P: C1921.2(B) CN1901.37(PETP1)
SSD1_TX12N: C1922.2(B) CN1901.47(PETN0/SATA-A-)
SSD1_TX12P: C1923.2(B) CN1901.49(PETP0/SATA-A+)
SSD1_WAKE#: CN1901.54(PEWAKE#/NC_54) TP1900.1
SSD2_SATA_LED#: CN1900.10(DAS/DSS#) TP1902.1
SSD2_WAKE#: CN1900.54(PEWAKE#/NC_54) TP1903.1
SSD_CLKREQ2#: CN1901.52(CLKREQ#/NC_52) R1901.1(A)
SSD_CLKREQ3#: CN1900.52(CLKREQ#/NC_52) R1902.1(A)
SSD_TX1N: C1930.2(B) CN1900.47(PETN0/SATA-A-)
SSD_TX1P: C1929.2(B) CN1900.49(PETP0/SATA-A+)
SSD_TX2N: C1928.2(B) CN1900.35(PETN1)
SSD_TX2P: C1909.2(B) CN1900.37(PETP1)
SSD_TX3N: C1927.2(B) CN1900.23(PETP2)
SSD_TX3P: C1926.2(B) CN1900.25(PETN2)
SSD_TX4N: C1925.2(B) CN1900.11(PETP3)
SSD_TX4P: C1924.2(B) CN1900.13(PETN3)
SUSACK#: U1.125(SSCE1#/GPG0) U4710.BE35(GPP_A15/SUSACK#)
SUSCLK: R4706.1(A) R4710.1(A) R4750.1(A) R4753.2(B)
SUSCLK32_PCH: R4753.1(A) U4710.BE45(GPD8/SUSCLK)
SUSWARN#: R4912.1(A) U1.87(PS2CLK1/DTR0#/GPF2) U4710.BC37(GPP_A13/SUSWARN#/SUSPWRDNACK)
SYS_PWROK: R301.1(A) U1.93(CLKRUN#/ID0/GPH0) U4710.AU3(SYS_PWROK)
SYS_RESET#: R4713.1(A) U4710.AU2(SYS_RESET#)
TB_HTPLG: U4710.Y46(GPP_K12/GSXDOUT)
TB_STAT#: TP60002.1 U60000.16
THERM_SCI#: R4454.2(B) U4710.AL47(GPP_E3/CPU_GP0)
THERMTRIP#: Q7003.S R4453.2(B) R4455.1(A)
THERMTRIP_BASE: Q4758.1(B) R4743.2(B)
TOUCH_INT#: Q3000.3(D) R4819.2(B) U4710.AP21(GPP_C13/UART1_TXD/ISH_UART1_TXD)
TOUCH_INT#_L: CN5.27 Q3000.2(S) R3002.2(B)
TOUCH_PAD_DISABLE: CN280.8 D281.2 U1.31(PWM5/GPA5)
TOUCH_PWR_EN: CN5.24 R149.2(B) U4710.AU24(GPP_C12/UART1_RXD/ISH_UART1_RXD)
TOUCH_RST#: CN5.28 U4710.BD38(GPP_A17/SD_VDD1_PWR_EN#/ISH_GP7)
TOUCHPAD_I2C_INT#: R281.1(A) R312.2(B)
TP: TP4702.1 U4710.AN35(TP)
TP1: TP4601.1 U4710.AL35(TP)
TP_CLK: CN280.2 D283.1 R304.1(A) U1.89(PS2CLK2/GPF4)
TP_D+: L3001.2(INA) U4710.G5(USB2P_8)
TP_D-: L3001.1(INC) U4710.G4(USB2N_8)
TP_DATA: CN280.3 D283.2 R306.1(A) U1.90(PS2DAT2/GPF5)
TP_I2C_CLK: CN280.6 D282.2 Q281.4(S2) R287.1(A) R290.2(B)
TP_I2C_DAT: CN280.5 D282.1 Q281.1(S1) R288.1(A) R289.1(A)
TP_I2C_INT#: CN280.7 D281.1 R285.1(A) R286.2(B)
TPM_PIRQ#: R3500.1(A) U3500.18(SPI_IRQ#/GPIO2) U4710.AL15(GPP_I3/DPPE_HPD3/DISP_MISC3)
TPM_SPI_CLK: R3503.2(B) U3500.19(SCLK)
TPM_SPI_CS2#: R3501.1(A) R3504.2(B) U3500.20(SCS#/GPIO5)
TPM_SPI_SI: R3506.2(B) U3500.21(MOSI/GPIO7)
TPM_SPI_SO: R3502.1(A) R3505.2(B) U3500.24(MISO)
TS: C7600.1(A) CN6050.5 D7600.2 R7602.2(B) R7603.1(A) R7604.2(B)
TURBO_KEY: CN2.2 D1.2 SW1.3 SW1.4
TYPEC_1A5: Q6.G R2400.2(B) U1.88(PS2DAT1/RTS0#/GPF3) U8.9(PMODE2)
TYPEC_3A: Q5.G R2401.1(A) U1.33(GINT/CTS0#/GPD5) U8.8(PMODE1)
TYPEC_CC1: C88.1(A) CN2500.A5 D7503.4 D7503.7 U8.7(CC1)
TYPEC_CC2: C87.1(A) CN2500.B5 D7503.5 D7503.6 U8.6(CC2)
TYPEC_SET: Q5.D Q6.D R2681.2(B) U2500.5
U63_STATUS#: R2500.2(B) U2501.9
UART0_RXD: TP4801.1 U4710.BE23(GPP_C8/UART0_RXD)
UART0_TXD: TP4800.1 U4710.BB24(GPP_C9/UART0_TXD)
UNNAMED_65_PI3EQX12902A_I64_TES: TP1700.1 U1700.5(TEST#)
UNNAMED_122_CSC0402_I126_B: C25.2(B) S15.1
UNNAMED_129_BEADSINGLE_I11_INB: C6035.1(A) C6036.1(A) CN8.5 CN8.6 CN8.7 CN8.8 D6035.1 D6035.2 L6035.2(INB) L6036.2(INB)
UNNAMED_130_BQ24780S_I45_17: R60012.1(A) U60000.17
UNNAMED_130_CAPALSP_I76_A: C60000.1(A) C60001.1(A) C60099.1(A) PAD60000.1 Q60000.5(D3) Q60000.6(D2) Q60000.7(D1) Q60000.8(D0)
UNNAMED_130_CSC0603_I106_A: C60019.1(A) L60000.2(INB) Q60012.1(S0) Q60012.2(S1) Q60012.3(S2) R60001.1 R60012.2(B)
UNNAMED_130_RSC0805_I54_B: D60000.3(C) R60009.2(B)
UNNAMED_131_CN082G_I95_3: C7601.1(A) CN6050.3 D7601.2 R6051.2(B)
UNNAMED_131_CSC0603_I65_A: C60013.1(A) D60002.3(C) R60017.2(B)
UNNAMED_131_DDUALSERIESA_I76_A1: D6098.1(A1) Q60003.6(D1)
UNNAMED_131_DDUALSERIESA_I76_C: D6098.3(C) R6098.2(B)
UNNAMED_131_NMOSDUALC_I67_D1: Q60002.5(G2) Q60002.6(D1) R60017.1(A) R60018.1(A)
UNNAMED_131_NMOSDUALC_I67_D2: Q60002.3(D2) R60026.2(B)
UNNAMED_131_NMOSDUALC_I84_G1: Q60003.2(G1) R60023.1(A) R60024.1(A)
UNNAMED_131_NMOSDUALC_I84_G2: Q60003.5(G2) R60019.1(A) R60020.2(B)
UNNAMED_132_RSC0402_I42_B: R60204.2(B) U60200.11
UNNAMED_132_RSCSHORT_I26_A: R60203.1(A) U60200.14
UNNAMED_133_CSC0402_I21_A: C60281.1(A) U60250.13(FF)
UNNAMED_133_CSC0402_I21_B: C60281.2(B) R60289.1(A)
UNNAMED_133_POWERPAD40610_I32_3: PAD60250.3 R60253.2(B) R60289.2(B)
UNNAMED_133_RSC0402_I17_B: R60254.2(B) U60250.11(EN2)
UNNAMED_133_RSCSHORT_I25_A: R60253.1(A) U60250.14(OUT)
UNNAMED_134_CSC0402_I21_A: C60109.1(A) R60110.1(A) R60199.1(A) U60100.10
UNNAMED_135_CSC0402_I18_B: C60309.1(A) C60350.1(A) C60351.2(B) R60349.1(A) U60300.4
UNNAMED_135_CSC0402_I39_A: C60348.1(A) R60344.2(B) R60347.2(B)
UNNAMED_135_RSC0402_I33_A: R60301.1(A) R60302.2(B)
UNNAMED_139_CSC0402_I29_A: C60509.1(A) R60505.1(A) R60506.2(B) U60500.10
UNNAMED_140_CSC0402_I108_B: C66652.2(B) R66651.1(A) U66000.48
UNNAMED_140_RSC0402_I179_B: R66650.2(B) R66652.2(B)
UNNAMED_141_CSC0402_I27_A: C66048.1(A) R66047.1(A) U66040.3(VCC)
UNNAMED_141_CSC0402_I45_A: C66038.1(A) R66037.1(A) U66030.3(VCC)
UNNAMED_141_CSC0402_I73_A: C66018.1(A) R66017.1(A) U66010.3(VCC)
UNNAMED_141_CSC0402_I86_A: C66028.1(A) R66027.1(A) U66020.3(VCC)
UNNAMED_141_NCP302035MNTXG_I3_G: U66030.27(GL) U66030.33(GL_1)
UNNAMED_141_NCP302035MNTXG_I53_: U66010.27(GL) U66010.33(GL_1)
UNNAMED_141_NCP302035MNTXG_I150: U66040.27(GL) U66040.33(GL_1)
UNNAMED_141_NCP302035MNTXG_I151: U66020.27(GL) U66020.33(GL_1)
UNNAMED_142_CSC0603_I5_A: C66317.1(A) R66317.2(B) U66310.4
UNNAMED_142_NCP81151MNTBGDFN_I9: R66311.2(B) U66310.3
UNNAMED_144_J44894_I9_VSS1: TP4711.1 U4710.A2(VSS_1)
UNNAMED_144_J44894_I9_VSS10: TP4710.1 U4710.A48(VSS_10)
UNNAMED_144_J44894_I9_VSS135: TP4708.1 U4710.BF1(VSS_135)
UNNAMED_144_J44894_I11_VSS149: TP4709.1 U4710.BG48(VSS_149)
UNNAMED_145_J44894_I27_GPPB18: R4802.2(B) U4710.BE30(GPP_B18/GSPI0_MOSI)
UNNAMED_145_J44894_I27_GPPC10: TP4803.1 U4710.BA24(GPP_C10/UART0_RTS#)
UNNAMED_145_J44894_I27_GPPC11: TP4802.1 U4710.AP24(GPP_C11/UART0_CTS#)
UNNAMED_151_CN282G_I20_28: C251.1(A) CN250.28 D258.1 R254.2(B) R255.2(B)
UNNAMED_151_CSC0402_I5_A: C255.1(A) Q250.1 R253.2(B)
UNNAMED_151_NMOSC_I3_D: Q251.D R251.2(B) R253.1(A)
UNNAMED_152_RSC0402_I29_A: R280.2(B) R281.2(B) R282.1(A) R286.1(A)
UNNAMED_153_1222UYOSUBCS530A4_1: D101.3(OUT1) R100.2(B)
UNNAMED_153_1222UYOSUBCS530A4TR: D101.2(OUT) R103.2(B)
UNNAMED_153_LEDSINGLE_I35_A1: D102.1(A1) R105.2(B)
UNNAMED_153_NMOSC_I26_D: Q102.D R105.1(A)
UNNAMED_153_NMOSDUALC_I22_D1: Q101.6(D1) R103.1(A)
UNNAMED_153_NMOSDUALC_I22_D2: Q101.3(D2) R100.1(A)
UNNAMED_155_CN102G_I26_1: C20.1(A) C1700.1(A) C1701.1(A) CN1700.1 CN1700.2 CN1700.3 PAD1700.2
UNNAMED_158_CSC0402_I363_A: C1301.1(A) U1300.6(CT)
UNNAMED_158_NMOS_I353_D: Q1300.3(D) R1300.1(A) U1300.3(ON)
UNNAMED_158_NPND_I59_B: Q1314.1(B) R1360.1(A)
UNNAMED_160_APCI0020P003A_I103_: C1913.1(A) C1931.1(A) C1932.1(A) C1933.1(A) C1936.1(A) CN1901.2(3.3VAUX_2) CN1901.4(3.3VAUX_4) CN1901.12(3.3VAUX_12) CN1901.14(3.3VAUX_14) CN1901.16(3.3VAUX_16) CN1901.18(3.3VAUX_18) CN1901.70(3.3VAUX_70) CN1901.72(3.3VAUX_72) CN1901.74(3.3VAUX_74) PAD1901.1
UNNAMED_160_NMOS_I89_G: CN1901.69(PEDET) Q1900.1(G) R1905.1(A) R1906.2(B)
UNNAMED_161_APCI0020P003A_I118_: C1900.1(A) C1901.1(A) C1902.1(A) C1908.1(A) C1937.1(A) CN1900.2(3.3VAUX_2) CN1900.4(3.3VAUX_4) CN1900.12(3.3VAUX_12) CN1900.14(3.3VAUX_14) CN1900.16(3.3VAUX_16) CN1900.18(3.3VAUX_18) CN1900.70(3.3VAUX_70) CN1900.72(3.3VAUX_72) CN1900.74(3.3VAUX_74) PAD1902.1
UNNAMED_162_CSC0402_I53_A: C2509.1(A) R2505.1(A) R2507.1(A)
UNNAMED_162_CSC0402_I54_A: C2510.1(A) R2504.1(A) R2506.1(A)
UNNAMED_162_CSC0402_I124_A: C2500.1(A) R2508.1(A) R2512.1(A)
UNNAMED_162_CSC0402_I125_A: C2511.1(A) R2509.1(A) R2513.1(A)
UNNAMED_162_G518B1TP1U_I112_4: R2411.2(B) U2500.4 U2502.4
UNNAMED_162_NMOSC_I83_S: Q5.S R2649.2(B)
UNNAMED_162_NMOSC_I84_S: Q6.S R2680.2(B)
UNNAMED_162_RSC0402_I41_B: R2410.2(B) U8.2(REXT)
UNNAMED_162_RSC0402_I90_A: R2402.1(A) U8.10(NFAULT)
UNNAMED_164_PS8713BTQFN24GTR2_1: R2418.1(A) U2401.3
UNNAMED_164_PS8713BTQFN24GTR2_2: R2417.1(A) U2401.4
UNNAMED_164_PS8713BTQFN24GTR2_3: R2415.1(A) U2401.5
UNNAMED_164_PS8713BTQFN24GTR2_4: R2416.1(A) U2401.6
UNNAMED_164_PS8713BTQFN24GTR2_5: R2414.1(A) U2401.7
UNNAMED_164_PS8713BTQFN24GTR2_6: R2412.2(B) U2401.14
UNNAMED_164_PS8713BTQFN24GTR2_7: R2413.2(B) U2401.15
UNNAMED_164_PS8713BTQFN24GTR2_8: R2406.2(B) U2401.16
UNNAMED_164_PS8713BTQFN24GTR2_9: R2407.2(B) U2401.17
UNNAMED_164_PS8713BTQFN24GTR2A2: R2409.1(A) U2401.2
UNNAMED_164_PS8713BTQFN24GTR_10: R2408.2(B) U2401.18
UNNAMED_165_PS8713BTQFN24GTR2_1: R2427.1(A) U2403.3
UNNAMED_165_PS8713BTQFN24GTR2_2: R2426.1(A) U2403.4
UNNAMED_165_PS8713BTQFN24GTR2_3: R2420.1(A) U2403.5
UNNAMED_165_PS8713BTQFN24GTR2_4: R2421.1(A) U2403.6
UNNAMED_165_PS8713BTQFN24GTR2_5: R2419.1(A) U2403.7
UNNAMED_165_PS8713BTQFN24GTR2_6: R2404.2(B) U2403.14
UNNAMED_165_PS8713BTQFN24GTR2_7: R2405.2(B) U2403.15
UNNAMED_165_PS8713BTQFN24GTR2_8: R2422.2(B) U2403.16
UNNAMED_165_PS8713BTQFN24GTR2_9: R2423.2(B) U2403.17
UNNAMED_165_PS8713BTQFN24GTR2A2: R2428.1(A) U2403.2
UNNAMED_165_PS8713BTQFN24GTR_10: R2424.2(B) U2403.18
UNNAMED_166_CHOKE4PINC_I129_INB: CN5.17 L3001.3(INB)
UNNAMED_166_CHOKE4PINC_I129_IND: CN5.16 L3001.4(IND)
UNNAMED_166_CHOKE4PINC_I150_INB: CN5.30 L3002.3(INB)
UNNAMED_166_CHOKE4PINC_I150_IND: CN5.29 L3002.4(IND)
UNNAMED_166_CN405G_I84_34: C3011.1(A) C3012.1(A) CN5.34 CN5.35 FUSE3001.2(B)
UNNAMED_166_CN405G_I84_39: C3009.1(A) C3010.1(A) CN5.39 CN5.40 FUSE3000.2
UNNAMED_166_CSC0402_I36_A: C3003.1(A) R40.1(A) U3000.3
UNNAMED_166_FUSE_I171_1: FUSE3000.1 PAD3001.2
UNNAMED_166_NCT3521U_I118_4: R3004.1(A) U3000.4
UNNAMED_166_NCT3521U_I118_OUT: PAD3000.1 R3004.2(B) U3000.1(OUT)
UNNAMED_169_C17711120A9L_I187_1: CN56200.19 R56202.2(B)
UNNAMED_169_C17711120A9L_I187_6: CN56200.6 R56201.2(B)
UNNAMED_169_NCT3521U_I119_3: R56251.1(A) R56290.1(A) U56250.3
UNNAMED_171_AZ104504FR7G_I85_1: CN56600.1 D56650.1 D56650.10 R56681.2(B)
UNNAMED_171_AZ104504FR7G_I85_2: CN56600.3 D56650.2 D56650.9 R56682.2(B)
UNNAMED_171_AZ104504FR7G_I85_4: CN56600.4 D56650.4 D56650.7 R56683.2(B)
UNNAMED_171_AZ104504FR7G_I85_5: CN56600.6 D56650.5 D56650.6 R56684.2(B)
UNNAMED_171_AZ104504FR7G_I86_1: CN56600.7 D56651.1 D56651.10 R56685.2(B)
UNNAMED_171_AZ104504FR7G_I86_2: CN56600.9 D56651.2 D56651.9 R56686.2(B)
UNNAMED_171_AZ104504FR7G_I86_4: CN56600.10 D56651.4 D56651.7 R56687.2(B)
UNNAMED_171_AZ104504FR7G_I86_5: CN56600.12 D56651.5 D56651.6 R56688.2(B)
UNNAMED_171_CN194G_I167_13: CN56600.13 TP56630.1
UNNAMED_171_CN194G_I167_14: CN56600.14 TP56631.1
UNNAMED_171_NMOS2D2SDIODE_I12_1: Q56670.2 Q56670.5 R56670.1(A)
UNNAMED_171_NMOS2D2SDIODE_I12_2: Q56670.3 R56679.1(A) R56680.1(A)
UNNAMED_171_NMOS2D2SDIODE_I12_3: Q56670.4 R56674.2(B) R56675.1(A) R56676.2(B)
UNNAMED_171_NMOS2D2SDIODE_I12_4: Q56670.6 R56677.1(A) R56678.1(A)
UNNAMED_171_NMOS2D2SDIODE_I126_: Q56670.1 R56671.2(B) R56672.1(A) R56673.2(B)
UNNAMED_171_NMOS2D2SDIODE_I170_: Q56690.2 Q56690.5 R56690.1(A)
UNNAMED_172_CSC0402_I14_A: C3500.1(A) C3503.1(A) C3504.1(A) C3505.1(A) PAD3500.2 U3500.8(VHIO1) U3500.22(VHIO2)
UNNAMED_206_CSC0402_I359_A: C402.1(A) U400.36
UNNAMED_206_CSC0402_I360_A: C400.1(A) U400.35
UNNAMED_206_E2500RIV1RL_I357_10: R407.2(B) U400.10
UNNAMED_206_NPND_I342_B: Q402.1(B) R416.1(A)
UNNAMED_259_CSC0402_I133_A: C401.1(A) C433.1(A) U401.3(TDCT) U401.4 U401.9 U401.10
UNNAMED_259_CSC0402_I152_A: C429.2(B) C478.1(A) C479.1(A)
UNNAMED_259_CSC1206_I129_A: C429.1(A) R412.2(B) R413.2(B) R414.2(B) R415.2(B)
UNNAMED_259_NA0069RLF_I116_16: R414.1(A) U401.16
UNNAMED_259_NA0069RLF_I116_21: R413.1(A) U401.21
UNNAMED_259_NA0069RLF_I116_22: R412.1(A) U401.22
UNNAMED_259_NA0069RLF_I116_TXTC: R415.1(A) U401.15(TXTC)
UNNAMED_262_RSC0402_I121_B: R4452.2(B) R4454.1(A) U4450.6
UNNAMED_263_CSC0402_I83_A: C700.1(A) Q701.1 R702.2(B)
UNNAMED_263_NMOSC_I75_D: Q702.D R702.1(A) R705.2(B)
UNNAMED_263_RSC0402_I11_B: R704.2(B) U702.30(REXT)
UNNAMED_263_RSC0402_I17_A: R703.1(A) U702.24(#RESET)
UNNAMED_264_CSC0402_I125_B: C303.2(B) U1.12(VCORE)
UNNAMED_264_CSC0402_I634_A: C315.1(A) R331.2(B) U1.13(LPCCLK/GPM4<3>)
UNNAMED_264_IT8987ECX_I608_ADC1: R307.1(A) U1.67(ADC1/GPI1<3>)
UNNAMED_264_IT8987ECX_I608_ID5: R312.1(A) U1.98(ID5/GPH5)
UNNAMED_264_IT8987ECX_I608_LPCP: R315.1(A) R316.1(A) U1.17(LPCPD#/GPE6)
UNNAMED_264_IT8987ECX_I608_LPCR: R347.2(B) U1.22(LPCRST#/GPD2)
UNNAMED_264_IT8987ECX_I608_PWRS: R333.1(A) U1.107(PWRSW/GPE4)
UNNAMED_265_ANDGATE_I549_1: R7063.2(B) R7068.2(B) U7006.1
UNNAMED_265_ANDGATE_I549_4: R7069.1(A) R7070.1(A) U7006.4
UNNAMED_265_APL3523A_I456_8: PAD7002.1 U2.8 U2.9
UNNAMED_265_APL3523A_I456_10: C7012.1(A) U2.10
UNNAMED_265_APL3523A_I456_12: C7013.1(A) U2.12
UNNAMED_265_APL3523A_I456_13: PAD7003.1 U2.13 U2.14
UNNAMED_265_APL3523A_I457_3: R7029.2(B) U7002.3
UNNAMED_265_APL3523A_I457_5: R38.2(B) U7002.5
UNNAMED_265_APL3523A_I457_10: C7014.1(A) U7002.10
UNNAMED_265_APL3523A_I457_12: C131.1(A) U7002.12
UNNAMED_265_APL3523A_I457_13: PAD1.1 U7002.13 U7002.14
UNNAMED_265_APL3523A_I458_5: C7032.1(A) R37.2(B) U7003.5
UNNAMED_265_APL3523A_I458_10: C17.1(A) U7003.10
UNNAMED_265_APL3523A_I458_12: C7035.1(A) U7003.12
UNNAMED_265_CSC0402_I502_B: C4626.2(B) Q7006.6(D1) Q7007.G R7038.1(A)
UNNAMED_265_NMOSDUALC_I506_D2: Q7006.2(G1) Q7006.3(D2) R7039.1(A)
UNNAMED_266_CSC0402_I474_A: C7023.1(A) R6900.1(A) R6901.1(A) R7037.2(B)
UNNAMED_266_NMOSC_I493_D: Q7003.D R7033.1(A)
UNNAMED_266_RSC0402_I167_A: R7002.1(A) R7017.2(B)
UNNAMED_266_RSC0402_I374_A: R7014.2(B) R7019.1(A) R7021.1(A)
UNNAMED_266_RSC0402_I529_A: D7001.3(A1) R7027.1(A)
UNNAMED_275_NMOSDUALC_I208_D2: Q4751.2(G1) Q4751.3(D2) R4742.2(B)
UNNAMED_277_J43242_I59_RSVD6: TP4528.1 U4555.B2(RSVD6)
UNNAMED_277_J43242_I59_RSVD8: TP4527.1 U4555.B38(RSVD8)
UNNAMED_277_J43242_I59_RSVD16: TP4526.1 U4555.BP1(RSVD16)
UNNAMED_280_J43242_I30_VSSBR38: TP4525.1 U4555.BR38(VSS_BR38)
UNNAMED_281_J44894_I301_GPPH12: R4835.1(A) U4710.AB47(GPP_H12/SML2ALERT#)
UNNAMED_281_J44894_I301_GPPH15: R4834.1(A) U4710.AC47(GPP_H15/SML3ALERT#)
UNNAMED_281_J44894_I301_SPI0CLK: R136.2(B) U4710.AW47(SPI0_CLK)
UNNAMED_281_J44894_I301_SPI0CS0: R135.2(B) U4710.AY47(SPI0_CS0#)
UNNAMED_281_J44894_I301_SPI0IO2: R4701.2(B) U4710.AY48(SPI0_IO2)
UNNAMED_281_J44894_I301_SPI0IO3: R4721.2(B) U4710.BA46(SPI0_IO3)
UNNAMED_281_J44894_I301_SPI0MIS: R134.2(B) U4710.BA45(SPI0_MISO)
UNNAMED_281_J44894_I301_SPI0MOS: R133.2(B) U4710.AU41(SPI0_MOSI)
UNNAMED_282_J44894_I161_GPPF15: R4720.1(A) U4710.AV47(GPP_F15/USB2_OC4#)
UNNAMED_282_J44894_I161_GPPF16: R4726.1(A) U4710.AR35(GPP_F16/USB2_OC5#)
UNNAMED_282_J44894_I161_GPPF17: R4727.1(A) U4710.AR37(GPP_F17/USB2_OC6#)
UNNAMED_282_J44894_I161_GPPF18: R4728.1(A) U4710.AV43(GPP_F18/USB2_OC7#)
UNNAMED_283_CSC0402_I158_B: C4960.2(B) U4710.B38(PCIE13_TXN/SATA0B_TXN)
UNNAMED_283_CSC0402_I159_B: C4961.2(B) U4710.C38(PCIE13_TXP/SATA0B_TXP)
UNNAMED_284_CSC0402_I129_A: C4802.1(A) R4770.1(A) R4771.1(A) U4710.BB46(DRAM_RESET#)
UNNAMED_284_J44894_I164_GPPA8: R4909.1(A) U4710.AV32(GPP_A8/CLKRUN#)
UNNAMED_285_J44894_I143_GPPA10: R4800.1(A) U4710.BB34(GPP_A10/CLKOUT_LPC1)
UNNAMED_285_RSC0402_I265_B: R4800.2(B) TP4804.1
UNNAMED_285_RSC0402_I283_B: R4723.2(B) R4813.2(B) R4873.1(A) R4908.1(A)
UNNAMED_286_CSC0402_I598_A: C4871.1(A) R4906.1(A) U4710.AN32(VCCPGPPA)
UNNAMED_289_ALC255CG_I118_CBN: C511.2(B) U500.35(CBN)
UNNAMED_289_ALC255CG_I118_CBP: C511.1(A) U500.37(CBP)
UNNAMED_289_ALC255CG_I118_CPVEE: C503.2(B) U500.34(CPVEE)
UNNAMED_289_ALC255CG_I118_HP: R502.1(A) R504.1(A) U500.13(HP/LINE1 JD)
UNNAMED_289_ALC255CG_I118_LDO1: C501.1(A) R531.1(A) U500.27(LDO1-CAP)
UNNAMED_289_ALC255CG_I118_LDO2: C512.2(B) U500.39(LDO2-CAP)
UNNAMED_289_ALC255CG_I118_LDO3: C530.1(A) U500.7(LDO3-CAP)
UNNAMED_289_ALC255CG_I118_MIC: C531.1(A) U500.19(MIC-CAP)
UNNAMED_289_ALC255CG_I118_NC: R514.1(A) U500.20(NC)
UNNAMED_289_ALC255CG_I118_PCBEE: C507.1(A) U500.12(PCBEEP)
UNNAMED_289_ALC255CG_I118_SPDIF: R501.1(A) U500.15(SPDIFO/FRONT JD)
UNNAMED_289_ALC255CG_I118_VREF: C502.2(B) U500.28(VREF)
UNNAMED_289_CSC0402_I68_B: C506.2(B) C507.2(B) R503.1(A) R505.1(A) R521.1(A)
UNNAMED_314_CSC0402_I14_A: C67009.1(A) R67009.2(B) U67000.12(VDD33)
UNNAMED_314_CSC0402_I47_A: C67082.1(A) R67012.2(B) R67013.1(A) U67000.40(VTEMP)
UNNAMED_314_CSC0402_I55_A: C67081.1(A) R67004.1(A) R67005.2(B) U67000.33(TSNS/BOOT)
UNNAMED_314_CSC0402_I81_A: C67080.1(A) R67080.2(B)
UNNAMED_314_MP2886AGUZ_I21_PSI: R67008.2(B) U67000.37(PSI)
UNNAMED_314_MP2886AGUZ_I21_PWMV: R67010.2(B) U67000.39(PWMVID)
UNNAMED_314_MP2886AGUZ_I21_VFB: R67080.1(A) R67094.2(B) U67000.29(VFB)
UNNAMED_314_RSC0402_I74_B: R67091.2(B) R67092.1(A)
UNNAMED_315_NMOS_I101_D: Q5000.4(G) Q5001.3(D) R5000.2(B)
UNNAMED_315_NMOS_I101_G: Q5001.1(G) R5001.2(B)
UNNAMED_318_RSC0402_I4_A: R67206.2(B) R67212.1(A)
UNNAMED_318_RSC0603_I39_A: R67225.1(A) U67200.15
UNNAMED_318_RSC0603_I40_A: R67215.1(A) U67200.1
UNNAMED_319_CSC0402_I39_A: C67600.1(A) C67601.1(A) L67600.2(INB) PAD67600.1 R67600.1(A)
UNNAMED_319_CSC0603_I29_A: C67610.1(A) PAD67610.2 U67600.9 U67600.10
UNNAMED_398_CSC0402_I129_A: C51631.1(A) Q51660.3(D) Q51661.2(S)
UNNAMED_398_CSC0402_I130_A: C51630.1(A) Q51640.3(D) Q51641.2(S)
UNNAMED_399_N18EG1KDQSA1_I74__1: R51751.2(B) U50000.AW10(USB_HVDD_1) U50000.AW11(USB_HVDD_2)
UNNAMED_399_N18EG1KDQSA1_I74__2: R51753.2(B) U50000.BE12(USB_VDDP)
UNNAMED_399_N18EG1KDQSA1_I74_US: R51750.2(B) U50000.BB15(USB_DVDD_1) U50000.BC15(USB_DVDD_2)
UNNAMED_400_IT66317FN0003R_I566: R56412.2(B) U56400.13(REXT)
UNNAMED_402_CSC0201_I296_A: C52000.1(A) R52000.1(A) U52000.27(VCC)
UNNAMED_402_CSC0402_I282_B: C52014.2(B) R52013.1(A) R52014.2(B) U52000.3(BS_IN1)
UNNAMED_402_CSC0402_I285_B: C52024.2(B) R52023.1(A) R52024.2(B) R52080.1(A) R52081.1(A) U52000.6(BS_IN2)
UNNAMED_402_NCP45491XMNTWG_I2_1: R52081.2(B) U52000.14(BS_IN4)
UNNAMED_402_NCP45491XMNTWG_I2_3: R52001.2(B) U52000.9(GND_FET)
UNNAMED_402_NCP45491XMNTWG_I2_4: R52011.2(B) U52000.1(SH_IN_N1)
UNNAMED_402_NCP45491XMNTWG_I2_5: R52021.2(B) U52000.4(SH_IN_N2)
UNNAMED_402_NCP45491XMNTWG_I2_6: R52012.2(B) U52000.2(SH_IN_P1)
UNNAMED_402_NCP45491XMNTWG_I2_7: R52022.2(B) U52000.5(SH_IN_P2)
UNNAMED_402_NCP45491XMNTWG_I2_8: R52006.1(A) R52007.1(A) U52000.25(SKIP)
UNNAMED_402_NCP45491XMNTWG_I267: R52080.2(B) U52000.11(BS_IN3)
UNNAMED_402_NMOSC_I297_G: Q52070.G R52070.1(A) R52071.2(B)
UNNAMED_402_NPND_I214_C: Q52060.3(C) R52054.1(A)
UNNAMED_403_APL3537BHAI_I10_A1: C52101.2(B) C52102.2(B) R52102.2(B) U50000.BD14(FP_FUSE_SRC) UU52100.A1 UU52100.B1
UNNAMED_409_74LVC1G32_I108_1: R53550.2(B) R53551.1(A) U53550.1
UNNAMED_409_ANDGATE_I103_4: D53571.3(A1) R53570.1(A) R53571.1(A) R53574.1(A) U53570.4
UNNAMED_410_NMOSC_I216_D: Q55220.D Q55225.G R55220.1(A)
UNNAMED_410_NMOSC_I250_D: Q55230.D Q55235.G R55230.1(A)
UNNAMED_410_NMOSC_I395_D: Q55225.D R55225.1(A) R55226.1(A) R55227.1(A) R55228.1(A)
UNNAMED_410_NMOSC_I397_D: Q55235.D R55235.1(A) R55236.1(A) R55237.1(A) R55238.1(A)
UNNAMED_410_NMOSC_I444_D: Q55215.D R55215.1(A) R55216.1(A) R55217.1(A) R55218.1(A)
UNNAMED_410_NMOSC_I444_G: Q55210.D Q55215.G R55210.1(A)
USB2_CHR_3N: L2501.1(INC) R2523.1(A) U2501.11
USB2_CHR_3P: L2501.2(INA) R2524.1(A) U2501.10
USB2_CN_1N: CN2500.A7 CN2500.B7 D7503.1 D7503.10 L2500.4(IND) R2511.2(B)
USB2_CN_1P: CN2500.A6 CN2500.B6 D7503.2 D7503.9 L2500.3(INB) R2510.2(B)
USB2_CN_3N: CN2501.2 D7500.4 L2501.4(IND) R2523.2(B)
USB2_CN_3P: CN2501.3 D7500.7 L2501.3(INB) R2524.2(B)
USB2_COMP: R4756.1(A) U4710.F4(USB2_COMP)
USB2_ID: R4759.1(A) U4710.G3(USB2_ID)
USB2_M2_BT_DN_L: CN1300.5(USB_D-) L1300.3(INB) R1356.2(B)
USB2_M2_BT_DP_L: CN1300.3(USB_D+) L1300.4(IND) R1355.2(B)
USB2_OC0#: C4705.1(A) R4783.1(A) U4710.AH36(GPP_E9/USB2_OC0#)
USB2_OC1#: R4774.1(A) U4710.AL40(GPP_E10/USB2_OC1#)
USB2_OC2#: C4707.1(A) R4767.1(A) U4710.AJ44(GPP_E11/USB2_OC2#)
USB2_OC3#: R4760.1(A) U4710.AL41(GPP_E12/USB2_OC3#)
USB2_REAR_1N: L2500.1(INC) R2511.1(A) U4710.J3(USB2N_1)
USB2_REAR_1P: L2500.2(INA) R2510.1(A) U4710.J2(USB2P_1)
USB2_REAR_3N: U2501.2 U4710.K4(USB2N_3)
USB2_REAR_3P: U2501.3 U4710.K3(USB2P_3)
USB2_VBUSSENSE: R4758.1(A) U4710.F3(USB2_VBUSSENSE)
USB3_C_TX1N: C2502.1(A) R2515.1(A)
USB3_C_TX1P: C2503.1(A) R2514.1(A)
USB3_C_TX2N: C2504.1(A) R2502.1(A)
USB3_C_TX2P: C2501.1(A) R2503.1(A)
USB3_C_TX3N: C2518.1(A) R2531.1(A)
USB3_C_TX3P: C2519.1(A) R2532.1(A)
USB3_L_RX1N: CN2500.B10 D7505.4 D7505.7 R2512.2(B)
USB3_L_RX1P: CN2500.B11 D7505.5 D7505.6 R2513.2(B)
USB3_L_RX2N: CN2500.A10 D7504.2 D7504.9 R2504.2(B)
USB3_L_RX2P: CN2500.A11 D7504.1 D7504.10 R2505.2(B)
USB3_L_RX3N: CN2501.5 D7500.1 R2529.2(B)
USB3_L_RX3P: CN2501.6 D7500.10 R2530.2(B)
USB3_L_TX1N: CN2500.A3 D7504.4 D7504.7 R2515.2(B)
USB3_L_TX1P: CN2500.A2 D7504.5 D7504.6 R2514.2(B)
USB3_L_TX2N: CN2500.B3 D7505.2 D7505.9 R2502.2(B)
USB3_L_TX2P: CN2500.B2 D7505.1 D7505.10 R2503.2(B)
USB3_L_TX3N: CN2501.8 D7500.5 R2531.2(B)
USB3_L_TX3P: CN2501.9 D7500.6 R2532.2(B)
USB3_RX1N: C2500.2(B) U4710.D11(USB31_1_RXN)
USB3_RX1P: C2511.2(B) U4710.C11(USB31_1_RXP)
USB3_RX2N: C2510.2(B) U4710.B9(USB31_2_RXN)
USB3_RX2P: C2509.2(B) U4710.C9(USB31_2_RXP)
USB3_RX3N: R2529.1(A) U4710.B10(USB31_3_RXN)
USB3_RX3P: R2530.1(A) U4710.C10(USB31_3_RXP)
USB3_RX4_C_DN: C2413.2(B) U2401.23
USB3_RX4_C_DP: C2412.2(B) U2401.22
USB3_RX4_L_DN: CN2400.5 D2401.1 D2401.10 L2402.3(INB)
USB3_RX4_L_DP: CN2400.6 D2401.2 D2401.9 L2402.4(IND)
USB3_RX4N: CN603.35 U4710.K16(USB31_4_RXN)
USB3_RX4P: CN603.36 U4710.J15(USB31_4_RXP)
USB3_RX5_C_DN: C2423.2(B) U2403.23
USB3_RX5_C_DP: C2422.2(B) U2403.22
USB3_RX5_L_DN: CN2401.5 D2403.1 D2403.10 L2405.3(INB)
USB3_RX5_L_DP: CN2401.6 D2403.2 D2403.9 L2405.4(IND)
USB3_RX5N: CN603.29 U4710.J13(USB31_5_RXN)
USB3_RX5P: CN603.30 U4710.K13(USB31_5_RXP)
USB3_TCL_RX4_IC_DN: L2402.2(INA) U2401.8
USB3_TCL_RX4_IC_DP: L2402.1(INC) U2401.9
USB3_TCL_RX5_IC_DN: L2405.2(INA) U2403.8
USB3_TCL_RX5_IC_DP: L2405.1(INC) U2403.9
USB3_TCL_TX4_IC_DN: C2405.1(A) U2401.11
USB3_TCL_TX4_IC_DP: C2406.1(A) U2401.12
USB3_TCL_TX5_IC_DN: C2417.1(A) U2403.11
USB3_TCL_TX5_IC_DP: C2418.1(A) U2403.12
USB3_TX1N: C2502.2(B) U4710.F9(USB31_1_TXN)
USB3_TX1P: C2503.2(B) U4710.F7(USB31_1_TXP)
USB3_TX2N: C2504.2(B) U4710.C3(USB31_2_TXN)
USB3_TX2P: C2501.2(B) U4710.D4(USB31_2_TXP)
USB3_TX3N: C2518.2(B) U4710.F11(USB31_3_TXN)
USB3_TX3P: C2519.2(B) U4710.G12(USB31_3_TXP)
USB3_TX4_C_DN: C2411.2(B) U2401.20
USB3_TX4_C_DP: C2410.2(B) U2401.19
USB3_TX4_IC_C_DN: C2405.2(B) L2401.2(INA)
USB3_TX4_IC_C_DP: C2406.2(B) L2401.1(INC)
USB3_TX4_L_DN: CN2400.8 D2401.4 D2401.7 L2401.3(INB)
USB3_TX4_L_DP: CN2400.9 D2401.5 D2401.6 L2401.4(IND)
USB3_TX4N: CN603.38 U4710.B14(USB31_4_TXN)
USB3_TX4P: CN603.39 U4710.C14(USB31_4_TXP)
USB3_TX5_C_DN: C2421.2(B) U2403.20
USB3_TX5_C_DP: C2420.2(B) U2403.19
USB3_TX5_IC_C_DN: C2417.2(B) L2404.2(INA)
USB3_TX5_IC_C_DP: C2418.2(B) L2404.1(INC)
USB3_TX5_L_DN: CN2401.8 D2403.4 D2403.7 L2404.3(INB)
USB3_TX5_L_DP: CN2401.9 D2403.5 D2403.6 L2404.4(IND)
USB3_TX5N: CN603.32 U4710.C15(USB31_5_TXN)
USB3_TX5P: CN603.33 U4710.B15(USB31_5_TXP)
USB_BT_DN: L1300.2(INA) R1356.1(A) U4710.E5(USB2N_14)
USB_BT_DP: L1300.1(INC) R1355.1(A) U4710.F6(USB2P_14)
USB_CAM_R_DN: L3002.1(INC) U4710.L4(USB2N_7)
USB_CAM_R_DP: L3002.2(INA) U4710.L3(USB2P_7)
USB_CHR#: R2501.2(B) U2501.13
USB_CHR_POWER: C2507.1(A) C2508.1(A) C2520.1(A) C2521.1(A) C2522.1(A) C7573.1(A) CN2501.1 D7500.2 U2501.12
USB_IC4_L_DN: CN2400.2 D2400.1 L2400.3(INB)
USB_IC4_L_DP: CN2400.3 D2400.3 L2400.4(IND)
USB_IC5_L_DN: CN2401.2 D2402.1 L2403.3(INB)
USB_IC5_L_DP: CN2401.3 D2402.3 L2403.4(IND)
USB_P4_DN: CN603.44 U4710.M10(USB2N_4)
USB_P4_DP: CN603.45 U4710.L9(USB2P_4)
USB_P5_DN: CN603.41 U4710.M1(USB2N_5)
USB_P5_DP: CN603.42 U4710.L2(USB2P_5)
USB_PLL_HVDD: C51752.2(B) R51752.2(B) U50000.AW9(USB_PLL_HVDD)
USB_PWR_EN: R2555.2(B) U2501.5
USBPWR_EN: CN603.46 R352.2(B) U2502.1
VADPBL: C60003.2(B) Q60003.4(S2) Q60010.1(S0) Q60010.2(S1) Q60010.3(S2) Q60011.1(S0) Q60011.2(S1) Q60011.3(S2) R60005.2(B) R60020.1(A)
VBIOS_CS#: R51400.1(A) R51401.2(B) U51400.1(CS#)
VBIOS_SCLK: R51402.1(A) U51400.6(SCLK)
VBIOS_SI: R51403.1(A) U51400.5(SI)
VGT_VCCSENSE: R4525.1(A) R66480.2(B) U4555.AH38(VCCGT_SENSE)
VGT_VSSSENSE: R4527.1(A) R66481.2(B) U4555.AH37(VSSGT_SENSE)
VID0_VCCIO: R7044.2(B) R60524.1(A) U60500.4
VID1_VCCIO: R7043.2(B) R60525.1(A) U60500.3
VIDALERT#: R4511.2(B) U4555.BH31(VIDALERT#)
VR_SVID_ALERT#: R4511.1(A) R4538.2(B) U66000.41
VR_SVID_CLK: R66101.2(B) R66102.2(B) U4555.BH32(VIDSCK)
VR_SVID_DATA: R4509.2(B) R66100.2(B) R66103.2(B) U4555.BH29(VIDSOUT)
VRA1V05A_FB: C60920.2(B) R60900.2(B) R60901.1(A) U60900.14
VRA1V05A_FF: C60920.1(A) R60920.2(B)
VRA1V05A_ILMT: R60905.1(A) U60900.13
VRA1V05A_SNB: C60916.1(A) R60916.2(B)
VRA1V05A_VOUT: PAD60900.3 R60900.1(A) R60920.1(A)
VRA1V8A_FB: C60605.2(B) R60600.1(A) R60601.2(B) U60600.5
VRA1V8S_FB: C67420.2(B) R67400.1(A) R67401.2(B) U67400.14
VRA1V8S_FF: C67420.1(A) R67420.1(A)
VRA1V8S_ILMT: R67405.1(A) U67400.13
VRA1V8S_SNB: C67416.1(A) R67416.2(B)
VRA1V8S_VOUT: PAD67400.3 R67400.2(B) R67420.2(B)
VRA1V35_SNB: C60316.1(A) R60316.2(B)
VRA2V5_FB: C60405.2(B) R60400.2(B) R60401.1(A) U60400.6
VRA3V3A_SNB: C60166.1(A) R60166.2(B)
VRA3V3A_VCC: C60109.2(B) U60100.9
VRA3V3DS_VOUT: C60190.1(A) PAD60100.3 U60100.5
VRA5V0_LDO: C60280.1(A) U60250.15(LDO)
VRA5V0_SNB: C60266.1(A) R60266.2(B)
VRA5V0A_FF: C60231.2(B) U60200.13
VRA5V0A_FF_R: C60231.1(A) R60239.1(A)
VRA5V0A_LDO: C60230.1(A) U60200.15
VRA5V0A_SNB: C60216.1(A) R60216.2(B)
VRA5V0A_VOUT: PAD60200.3 R60203.2(B) R60239.2(B)
VRA_SY8284_VCC: C67409.1(A) U67400.16(NC_1) U67400.17(VCC)
VRA_SY8288_VCC: C60909.1(A) U60900.16(NC_1) U60900.17(VCC)
VRACHG_ACDET: C60012.1(A) D6098.2(A2) R60002.1(A) R60003.1(A) U60000.6
VRACHG_ACDRV: R60004.1(A) U60000.4
VRACHG_ACN: C60017.1(A) C60018.2(B) R60000.4 U60000.1
VRACHG_ACP: C60014.1(A) C60018.1(A) R60000.3 U60000.2
VRACHG_BATDRV: R60011.1(A) U60000.18
VRACHG_BATDRV1: C60019.2(B) Q60012.4(G) R60011.2(B)
VRACHG_BST: R60015.1(A) U60000.25
VRACHG_BST1: C60015.1(A) D60001.3(C) R60015.2(B)
VRACHG_CMSRC: R60005.1(A) U60000.3
VRACHG_ILIM: C60024.1(A) R60013.1(A) R60014.2(B) U60000.21
VRACHG_MP1: Q60003.1(S1) Q60011.5(D3) Q60011.6(D2) Q60011.7(D1) Q60011.8(D0) R60000.1
VRACHG_REGN: C60023.1(A) D60001.1(A1) D60001.2(A2) R60023.2(B) U60000.24
VRACHG_SNB: C60016.1(A) R60016.2(B)
VRACHG_SRN: R60010.1(A) U60000.19
VRACHG_SRN1: C60020.1(A) C60021.2(B) R60001.4 R60010.2(B)
VRACHG_SRP: R60008.1(A) U60000.20
VRACHG_SRP1: C60021.1(A) C60022.1(A) R60001.3 R60008.2(B)
VRACHG_VCC: C60009.2(B) R60009.1(A) U60000.28
VRACPU_BST1: C66015.2(B) U66010.7(PHASE)
VRACPU_BST2: C66025.2(B) U66020.7(PHASE)
VRACPU_BST3: C66035.2(B) U66030.7(PHASE)
VRACPU_BST4: C66045.2(B) U66040.7(PHASE)
VRACPU_BST11: C66015.1(A) R66015.1(A)
VRACPU_BST12: R66015.2(B) U66010.5(BOOT)
VRACPU_BST21: C66025.1(A) R66025.1(A)
VRACPU_BST22: R66025.2(B) U66020.5(BOOT)
VRACPU_BST31: C66035.1(A) R66035.1(A)
VRACPU_BST32: R66035.2(B) U66030.5(BOOT)
VRACPU_BST41: C66045.1(A) R66045.1(A)
VRACPU_BST42: R66045.2(B) U66040.5(BOOT)
VRACPU_COMP: C66172.1(A) R66172.1(A) U66000.6
VRACPU_COMP1: C66171.1(A) R66172.2(B)
VRACPU_CSCOMP: C66150.1(A) C66151.1(A) R66005.1(A) R66150.2(B) R66151.2(B) U66000.8
VRACPU_CSCOMP1: R66150.1(A) R66151.1(A) R66152.1(A)
VRACPU_CSN1: R66018.2(B) R66113.1(A)
VRACPU_CSN2: R66028.2(B) R66123.1(A)
VRACPU_CSN3: R66038.2(B) R66133.1(A)
VRACPU_CSN4: R66048.2(B) R66143.1(A)
VRACPU_CSN11: L66010.4 R66018.1(A)
VRACPU_CSN21: L66020.4 R66028.1(A)
VRACPU_CSN31: L66030.4 R66038.1(A)
VRACPU_CSN41: L66040.4 R66048.1(A)
VRACPU_CSP1: R66019.2(B) R66112.1(A) R66114.1(A)
VRACPU_CSP1_R: C66114.2(B) R66114.2(B) R66115.2(B) U66000.11
VRACPU_CSP2: R66029.2(B) R66122.1(A) R66124.1(A)
VRACPU_CSP2_R: C66124.2(B) R66124.2(B) U66000.12
VRACPU_CSP3: R66039.2(B) R66132.1(A) R66134.1(A)
VRACPU_CSP3_R: C66134.2(B) R66134.2(B) R66136.2(B) U66000.13
VRACPU_CSP4: R66049.2(B) R66142.1(A) R66144.2(B)
VRACPU_CSP4_R: C66144.1(A) R66137.1(A) R66144.1(A) U66000.26
VRACPU_CSP11: L66010.3 R66019.1(A)
VRACPU_CSP21: L66020.3 R66029.1(A)
VRACPU_CSP31: L66030.3 R66039.1(A)
VRACPU_CSP41: L66040.3 R66049.1(A)
VRACPU_CSREF: C66113.1(A) C66114.1(A) C66124.1(A) C66134.1(A) C66144.2(B) R66113.2(B) R66115.1(A) R66123.2(B) R66133.2(B) R66136.1(A) R66143.2(B) U66000.10
VRACPU_CSSUM: C66150.2(B) C66151.2(B) R66112.2(B) R66122.2(B) R66132.2(B) R66142.2(B) R66152.2(B) U66000.9
VRACPU_DIFFOUT: C66170.2(B) R66171.2(B) U66000.4
VRACPU_DRVON: C66198.1(A) R66311.1(A) U66000.17 U66010.30(DISB#) U66020.30(DISB#) U66030.30(DISB#) U66040.30(DISB#) U66610.3(EN)
VRACPU_FB: C66171.2(B) C66172.2(B) R66170.1(A) R66171.1(A) U66000.5
VRACPU_FB1: C66170.1(A) R66170.2(B)
VRACPU_ILIM: R66005.2(B) U66000.7
VRACPU_IMON: C66107.2(B) R66107.2(B) U66000.3
VRACPU_PH1: L66010.1 R66016.2(B) U66010.16(SW) U66010.17(SW_1) U66010.18(SW_2) U66010.19(SW_3) U66010.20(SW_4) U66010.21(SW_5) U66010.22(SW_6) U66010.23(SW_8) U66010.24(SW_9) U66010.25(SW_7) U66010.26(SW_10)
VRACPU_PH2: L66020.1 R66026.2(B) U66020.16(SW) U66020.17(SW_1) U66020.18(SW_2) U66020.19(SW_3) U66020.20(SW_4) U66020.21(SW_5) U66020.22(SW_6) U66020.23(SW_8) U66020.24(SW_9) U66020.25(SW_7) U66020.26(SW_10)
VRACPU_PH3: L66030.1 R66036.2(B) U66030.16(SW) U66030.17(SW_1) U66030.18(SW_2) U66030.19(SW_3) U66030.20(SW_4) U66030.21(SW_5) U66030.22(SW_6) U66030.23(SW_8) U66030.24(SW_9) U66030.25(SW_7) U66030.26(SW_10)
VRACPU_PH4: L66040.1 R66046.2(B) U66040.16(SW) U66040.17(SW_1) U66040.18(SW_2) U66040.19(SW_3) U66040.20(SW_4) U66040.21(SW_5) U66040.22(SW_6) U66040.23(SW_8) U66040.24(SW_9) U66040.25(SW_7) U66040.26(SW_10)
VRACPU_PROCHOT#: R66105.1(A) U66000.39
VRACPU_PSYS: C66197.1(A) R66195.2(B) R66197.1(A) U66000.24
VRACPU_PWM1: R66093.1(A) U66000.18 U66010.1(PWM)
VRACPU_PWM2: R66092.1(A) U66000.19 U66020.1(PWM)
VRACPU_PWM3: R66091.1(A) U66000.20 U66030.1(PWM)
VRACPU_PWM4: R66090.1(A) U66000.21 U66040.1(PWM)
VRACPU_SNB1: C66016.1(A) R66016.1(A)
VRACPU_SNB2: C66026.1(A) R66026.1(A)
VRACPU_SNB3: C66036.1(A) R66036.1(A)
VRACPU_SNB4: C66046.1(A) R66046.1(A)
VRACPU_SVID_CLK: R66102.1(A) U66000.42
VRACPU_SVID_DATA: R66103.1(A) U66000.40
VRACPU_TSENSE: C66160.1(A) R66161.1(A) U66000.14
VRACPU_TSENSE1: R66160.1(A) R66161.2(B) R66162.1(A)
VRACPU_VCC: C66109.1(A) R66109.2(B) U66000.16
VRACPU_VRMP: C66199.1(A) R66199.2(B) U66000.15
VRACPU_VSN: C66182.2(B) R66182.2(B) U66000.2
VRACPU_VSN1: C66180.2(B) C66182.1(A) R66181.2(B) R66182.1(A)
VRACPU_VSP: C66180.1(A) R66180.2(B) U66000.1
VRAGPU_ADDR: R67089.1(A) R67090.1(A) U67000.24(ADDR)
VRAGPU_CS1: R67081.2(B) U67000.20(CS1) U67010.18(CS)
VRAGPU_CS2: R67082.2(B) U67000.19(CS2) U67020.18(CS)
VRAGPU_CS3: R67083.2(B) U67000.18(CS3) U67030.18(CS)
VRAGPU_CS4: R67084.2(B) U67000.17(CS4) U67040.18(CS)
VRAGPU_CS5: R67085.2(B) R67095.1(A) U67000.16(CS5) U67050.18(CS)
VRAGPU_CS6: R67086.2(B) R67096.1(A) U67000.15(CS6) U67060.18(CS)
VRAGPU_CSSUM: R67081.1(A) R67082.1(A) R67083.1(A) R67084.1(A) R67085.1(A) R67086.1(A) U67000.21(CSSUM)
VRAGPU_IMON: C67089.1(A) R67091.1(A) U67000.25(IMON)
VRAGPU_IREF: R67093.1(A) U67000.26(IREF)
VRAGPU_PWM1: U67000.11(PWM1) U67010.15(PWM)
VRAGPU_PWM2: U67000.10(PWM2) U67020.15(PWM)
VRAGPU_PWM3: U67000.9(PWM3) U67030.15(PWM)
VRAGPU_PWM4: U67000.8(PWM4) U67040.15(PWM)
VRAGPU_PWM5: U67000.7(PWM5) U67050.15(PWM)
VRAGPU_PWM6: U67000.6(PWM6) U67060.15(PWM)
VRAGPU_SNB1: C67016.1(A) R67016.2(B)
VRAGPU_SNB2: C67026.1(A) R67026.2(B)
VRAGPU_SNB3: C67036.1(A) R67036.2(B)
VRAGPU_SNB4: C67046.1(A) R67046.2(B)
VRAGPU_SNB5: C67056.1(A) R67056.2(B)
VRAGPU_SNB6: C67066.1(A) R67066.2(B)
VRAGPU_SYNC1: R67017.2(B) U67010.16(SYNC)
VRAGPU_SYNC2: R67027.2(B) U67020.16(SYNC)
VRAGPU_SYNC3: R67037.2(B) U67030.16(SYNC)
VRAGPU_SYNC4: R67047.2(B) U67040.16(SYNC)
VRAGPU_SYNC5: R67057.2(B) U67050.16(SYNC)
VRAGPU_SYNC6: R67067.2(B) U67060.16(SYNC)
VRAGPU_VDD18: C67088.1(A) R67089.2(B) U67000.23(VDD18)
VRAGPU_VDIFF: R67094.1(A) U67000.28(VDIFF)
VRAGPU_VINSEN: C67087.1(A) R67087.1(A) R67088.1(A) U67000.22(VINSEN)
VRAGPU_VORTN: R67001.1(A) R67003.1(A) U67000.32(VORTN)
VRAGPU_VOSEN: R67000.1(A) R67002.1(A) U67000.31(VOSEN)
VRAGPU_VTEMP: R67012.1(A) U67010.17(VTEP/FLT) U67020.17(VTEP/FLT) U67030.17(VTEP/FLT) U67040.17(VTEP/FLT) U67050.17(VTEP/FLT) U67060.17(VTEP/FLT)
VRAGT_BST1: R66315.1(A) U66310.1
VRAGT_BST11: C66315.2(B) R66315.2(B)
VRAGT_COMP: C66472.2(B) R66472.2(B) U66000.33
VRAGT_COMP1: C66471.2(B) R66472.1(A)
VRAGT_CSCOMP: C66450.1(A) C66451.1(A) R66305.2(B) R66450.1(A) R66451.1(A) U66000.31
VRAGT_CSCOMP1: R66450.2(B) R66451.2(B) R66452.1(A)
VRAGT_CSN1: R66318.2(B) R66413.2(B)
VRAGT_CSN11: L66310.4 R66318.1(A)
VRAGT_CSP1: R66319.2(B) R66412.2(B) R66414.2(B)
VRAGT_CSP1_R: C66414.1(A) R66414.1(A) U66000.28
VRAGT_CSP2_R: R66424.1(A) U66000.27
VRAGT_CSP11: L66310.3 R66319.1(A)
VRAGT_CSREF: C66413.1(A) C66414.2(B) R66413.1(A) U66000.29
VRAGT_CSSUM: C66450.2(B) C66451.2(B) R66412.1(A) R66452.2(B) U66000.30
VRAGT_DIFFOUT: C66470.1(A) R66471.1(A) U66000.35
VRAGT_FB: C66471.1(A) C66472.1(A) R66470.2(B) R66471.2(B) U66000.34
VRAGT_FB1: C66470.2(B) R66470.1(A)
VRAGT_ILIM: R66305.1(A) U66000.32
VRAGT_IMON: C66407.1(A) R66407.1(A) U66000.36
VRAGT_PWM1: R66393.1(A) U66000.23 U66310.2
VRAGT_PWM2: R66690.1(A) U66000.22
VRAGT_SNB1: C66316.1(A) R66316.1(A)
VRAGT_TSENSE: C66460.1(A) R66461.1(A) U66000.25
VRAGT_TSENSE1: R66460.1(A) R66461.2(B) R66462.1(A)
VRAGT_VSN: C66482.1(A) R66482.1(A) U66000.37
VRAGT_VSN1: C66480.2(B) C66482.2(B) R66481.1(A) R66482.2(B)
VRAGT_VSP: C66480.1(A) R66480.1(A) U66000.38
VRAM_DGPU_BST1: C67215.1(A) R67215.2(B)
VRAM_DGPU_BST2: C67225.1(A) R67225.2(B)
VRAM_DGPU_EN: R67211.2(B) U67200.3
VRAM_DGPU_GND: C67230.1(A) C67232.2(B) C67234.2(B) C67235.2(B) C67236.2(B) R67202.2(B) R67203.1(A) R67208.2(B) R67212.2(B) U67200.10
VRAM_DGPU_HG1: Q67210.1 U67200.2
VRAM_DGPU_HG2: Q67220.1 U67200.14
VRAM_DGPU_LG1: Q67210.8 U67200.19
VRAM_DGPU_LG2: Q67220.8 U67200.17
VRAM_DGPU_OCSET: C67233.1(A) R67233.2(B) U67200.12
VRAM_DGPU_PG: R53541.1(A) U53500.2 U53540.1 U67200.13
VRAM_DGPU_PH1: C67215.2(B) L67210.1 L67210.3 Q67210.9 R67216.1(A) U67200.20
VRAM_DGPU_PH2: C67225.2(B) L67220.1 L67220.3 Q67220.9 R67226.1(A) U67200.16
VRAM_DGPU_PSI: R51582.2(B) R51586.1(A) R51587.2(B) R67219.1(A) R67230.2(B) R67231.1(A)
VRAM_DGPU_PSI1: C67219.1(A) R67219.2(B) U67200.4
VRAM_DGPU_PVCC: C67209.1(A) R67209.1(A) U67200.18
VRAM_DGPU_PWMVID: R51580.2(B) R67220.1(A)
VRAM_DGPU_REFADJ: R67207.1(A) U67200.6
VRAM_DGPU_REFADJ1: C67235.1(A) R67204.2(B) R67205.1(A) R67207.2(B)
VRAM_DGPU_REFIN: C67236.1(A) R67205.2(B) R67206.1(A) U67200.7
VRAM_DGPU_SENSE: C67230.2(B) C67231.1(A) R67200.2(B) R67201.2(B) U67200.11
VRAM_DGPU_SN1: C67216.1(A) R67216.2(B)
VRAM_DGPU_SN2: C67226.1(A) R67226.2(B)
VRAM_DGPU_TON: R67217.2(B) U67200.9
VRAM_DGPU_TON1: C67218.2(B) R67217.1(A) R67218.2(B)
VRAM_DGPU_VCC_SENSE: R52230.2(B) R67201.1(A) TP52230.1
VRAM_DGPU_VID: R67220.2(B) U67200.5
VRAM_DGPU_VREF: C67234.1(A) R67204.1(A) U67200.8
VRAM_DGPU_VSS_SENSE: R52231.2(B) R67202.1(A) TP52231.1
VRAP1V0S_DGPU_FB: C67601.2(B) R67600.2(B) R67601.1(A) U67600.6
VRASA_BST1: R66615.1(A) U66610.1(BST)
VRASA_BST11: C66615.1(A) R66615.2(B)
VRASA_COMP: C66671.2(B) R66670.2(B) U66000.50
VRASA_COMP1: C66670.2(B) R66670.1(A)
VRASA_CSN1: C66650.1(A) C66651.1(A) R66618.2(B) R66650.1(A) R66651.2(B)
VRASA_CSN11: L66610.4 R66618.1(A)
VRASA_CSP1: R66619.2(B) R66653.2(B)
VRASA_CSP1_R: C66650.2(B) C66651.2(B) R66652.1(A) R66653.1(A) U66000.47
VRASA_CSP11: L66610.3 R66619.1(A)
VRASA_ILIM: C66605.2(B) R66605.2(B) U66000.49
VRASA_IMON: C66607.1(A) R66607.1(A) U66000.46
VRASA_PWM1: R66693.1(A) U66000.44 U66610.2(PWM)
VRASA_SNB1: C66616.1(A) R66616.2(B)
VRASA_VSN: C66682.2(B) R66682.2(B) U66000.51
VRASA_VSN1: C66680.1(A) C66682.1(A) R66681.2(B) R66682.1(A)
VRASA_VSP: C66683.2(B) R66683.2(B) U66000.52
VRASA_VSP1: C66680.2(B) C66683.1(A) R66680.2(B) R66683.1(A)
VRAVCCIO_BST: R60515.1(A) U60500.9
VRAVCCIO_BST1: C60515.1(A) R60515.2(B)
VRAVCCIO_MODE: R60529.2(B) U60500.7
VRAVCCIO_SNB: C60516.1(A) R60516.2(B)
VRAVDDQ_BST: R60315.1(A) U60300.10
VRAVDDQ_BST1: C60315.1(A) R60315.2(B)
VRAVDDQ_FB: R60300.1(A) R60301.2(B) R60344.1(A) U60300.13
VRAVDDQ_MODE: R60346.1(A) U60300.14
VRAVDDQ_OTW#: R60348.1(A) U60300.11
VRAVDDQ_VOUT: C60348.2(B) PAD60300.3 R60300.2(B)
VRAVR_ON: R66000.2(B) R66001.1(A) TP66001.1 U66000.43
VRB1V05A_BST: R60915.1(A) U60900.1(BS)
VRB1V05A_BST1: C60915.1(A) R60915.2(B)
VRB1V8S_BST: R67415.1(A) U67400.1(BS)
VRB1V8S_BST1: C67415.1(A) R67415.2(B)
VRB3V3A_BST: R60115.1(A) U60100.8
VRB3V3A_BST1: C60115.1(A) R60115.2(B)
VRB5V0_BST: R60265.1(A) U60250.1(BS)
VRB5V0_BST1: C60265.1(A) R60265.2(B)
VRB5V0_VCC: C60259.1(A) U60250.17(VCC)
VRB5V0A_BST: R60215.1(A) U60200.1
VRB5V0A_BST1: C60215.1(A) R60215.2(B)
VRB5V0A_VCC: C60209.1(A) U60200.16 U60200.17
VRB_VDD3: C60309.2(B) C60930.1(A) C67019.1(A) C67029.1(A) C67039.1(A) C67049.1(A) C67059.1(A) C67069.1(A) C67430.1(A) PAD60100.4 R60348.2(B) R60506.1(A) R67009.1(A) R67017.1(A) R67027.1(A) R67037.1(A) R67047.1(A) R67057.1(A) R67067.1(A) U60300.3 U60900.15 U67010.20(VCC) U67020.20(VCC) U67030.20(VCC) U67040.20(VCC) U67050.20(VCC) U67060.20(VCC) U67400.15
VRB_VDD5: C66017.1(A) C66027.1(A) C66037.1(A) C66047.1(A) C66617.1(A) PAD60200.4 R60505.2(B) R66017.2(B) R66027.2(B) R66037.2(B) R66047.2(B) R66109.1(A) R66137.2(B) R66317.1(A) R66424.2(B) R67209.2(B) R67230.1(A) U66010.2(SMOD#) U66010.29(VCCD) U66020.2(SMOD#) U66020.29(VCCD) U66030.2(SMOD#) U66030.29(VCCD) U66040.2(SMOD#) U66040.29(VCCD) U66610.4(VCC)
VRP1V0S_DGPU_PH: L67600.1(INA) U67600.1 U67600.2 U67600.3
VRP1V2_PH: C67415.2(B) L67400.1(INA) R67416.1(A) U67400.6(LX_2) U67400.19(LX_1) U67400.20(LX)
VRP1V05A: C60900.1(A) C60901.1(A) C60902.1(A) C60903.1(A) C60904.1(A) L60900.2 L60900.4 PAD60900.1
VRP1V05A_PH: C60915.2(B) L60900.1 L60900.3 R60916.1(A) U60900.6(LX_2) U60900.19(LX_1) U60900.20(LX)
VRP1V05A_VIN: C60910.1(A) C60911.1(A) C60912.1(A) PAD60910.2 U60900.2(IN_3) U60900.3(IN_2) U60900.4(IN_1) U60900.5(IN)
VRP1V8: C67400.1(A) C67401.1(A) C67402.1(A) C67403.1(A) C67404.1(A) L67400.2(INB) PAD67400.1
VRP1V8A: C60600.1(A) C60605.1(A) L60600.2 PAD60600.1 R60600.2(B)
VRP1V8A_PH: L60600.1 U60600.3
VRP1V8A_VIN: C60610.1(A) PAD60610.2 U60600.4
VRP1V8S_VIN: C67410.1(A) C67411.1(A) C67412.1(A) PAD67410.2 R67405.2(B) U67400.2(IN_3) U67400.3(IN_2) U67400.4(IN_1) U67400.5(IN)
VRP2V5: C60400.1(A) C60401.1(A) C60405.1(A) L60400.2 PAD60400.1 R60400.1(A)
VRP2V5_PH: L60400.1 U60400.3
VRP2V5_VIN: C60410.1(A) PAD60410.2 U60400.4
VRP3V3A: C60100.1(A) C60101.1(A) C60102.1(A) C60103.1(A) C60104.1(A) L60100.2(INB) PAD60100.1
VRP3V3A_LDO: C60191.1(A) PAD60191.1 R7037.1(A) U60100.6
VRP3V3A_PH: C60115.2(B) L60100.1(INA) R60166.1(A) U60100.7
VRP3V3A_RTC: D4700.2(A2) R4751.2(B) R4752.1(A)
VRP3V3A_VIN: C60110.1(A) C60111.1(A) C60112.1(A) C60113.1(A) PAD60110.2 U60100.1
VRP5V0: C60250.1(A) C60251.1(A) L60250.2 L60250.4 PAD60250.1
VRP5V0_PH: C60265.2(B) L60250.1 L60250.3 R60266.1(A) U60250.6(LX_2) U60250.19(LX_1) U60250.20(LX)
VRP5V0_VIN: C60260.1(A) C60261.1(A) C60262.1(A) PAD60260.2 U60250.2(IN_3) U60250.3(IN_2) U60250.4(IN_1) U60250.5(IN)
VRP5V0A: C60200.1(A) C60201.1(A) C60202.1(A) C60203.1(A) C60204.1(A) L60200.2(INB) PAD60200.1
VRP5V0A_PH: C60215.2(B) L60200.1(INA) R60216.1(A) U60200.6 U60200.19 U60200.20
VRP5V0A_VIN: C60210.1(A) C60211.1(A) C60212.1(A) C60213.1(A) C60214.1(A) PAD60210.2 U60200.2 U60200.3 U60200.4 U60200.5
VRPCHG_HG: Q60000.4(G) U60000.26
VRPCHG_LG: Q60001.4(G) U60000.23
VRPCHG_PH: C60015.2(B) L60000.1(INA) Q60000.1(S0) Q60000.2(S1) Q60000.3(S2) Q60001.5(D3) Q60001.6(D2) Q60001.7(D1) Q60001.8(D0) R60016.1(A) U60000.27
VRPGPU_BST1: C67015.1(A) U67010.21(BST)
VRPGPU_BST2: C67025.1(A) U67020.21(BST)
VRPGPU_BST3: C67035.1(A) U67030.21(BST)
VRPGPU_BST4: C67045.1(A) U67040.21(BST)
VRPGPU_BST5: C67055.1(A) U67050.21(BST)
VRPGPU_BST6: C67065.1(A) U67060.21(BST)
VRPGPU_SW1: C67015.2(B) L67010.1 L67010.3 R67016.1(A) U67010.2(SW1) U67010.3(SW2) U67010.4(SW3)
VRPGPU_SW2: C67025.2(B) L67020.1 L67020.3 R67026.1(A) U67020.2(SW1) U67020.3(SW2) U67020.4(SW3)
VRPGPU_SW3: C67035.2(B) L67030.1 L67030.3 R67036.1(A) U67030.2(SW1) U67030.3(SW2) U67030.4(SW3)
VRPGPU_SW4: C67045.2(B) L67040.1 L67040.3 R67046.1(A) U67040.2(SW1) U67040.3(SW2) U67040.4(SW3)
VRPGPU_SW5: C67055.2(B) L67050.1 L67050.3 R67056.1(A) U67050.2(SW1) U67050.3(SW2) U67050.4(SW3)
VRPGPU_SW6: C67065.2(B) L67060.1 L67060.3 R67066.1(A) U67060.2(SW1) U67060.3(SW2) U67060.4(SW3)
VRPGT_HG1: Q66310.1 Q66311.1 U66310.8
VRPGT_LG1: Q66310.8 Q66311.8 U66310.5
VRPGT_PH1: C66315.1(A) L66310.1 Q66310.9 Q66311.9 R66316.2(B) U66310.7
VRPSA_HG1: Q66610.1 U66610.8(HG)
VRPSA_LG1: Q66610.8 U66610.5(LG)
VRPSA_PH1: C66615.2(B) L66610.1 Q66610.9 R66616.1(A) U66610.7(SW)
VRPVBAT_DGPU: PAD67210.1 R67099.2 R67199.1
VRPVBAT_NVVDD: C67010.1(A) C67011.1(A) C67012.1(A) C67013.1(A) C67020.1(A) C67021.1(A) C67022.1(A) C67023.1(A) C67030.1(A) C67031.1(A) C67032.1(A) C67033.1(A) C67040.1(A) C67041.1(A) C67042.1(A) C67043.1(A) C67050.1(A) C67051.1(A) C67052.1(A) C67053.1(A) C67060.1(A) C67061.1(A) C67062.1(A) C67063.1(A) R67088.2(B) R67199.2 U67010.1(VIN1) U67010.14(VIN2) U67020.1(VIN1) U67020.14(VIN2) U67030.1(VIN1) U67030.14(VIN2) U67040.1(VIN1) U67040.14(VIN2) U67050.1(VIN1) U67050.14(VIN2) U67060.1(VIN1) U67060.14(VIN2)
VRPVCCIO: C60500.1(A) C60501.1(A) C60502.1(A) L60500.2 L60500.4 PAD60500.1
VRPVCCIO_PH: C60515.2(B) L60500.1 L60500.3 R60516.1(A) U60500.8
VRPVCCIO_VIN: C60510.1(A) C60511.1(A) PAD60510.2 U60500.1
VRPVDDQ: C60300.1(A) C60301.1(A) C60302.1(A) C60303.1(A) C60304.1(A) L60300.2 L60300.4 PAD60300.1 U60300.6
VRPVDDQ_PH: C60315.2(B) L60300.1 L60300.3 R60316.1(A) R60347.1(A) U60300.9
VRPVDDQ_VIN: C60310.1(A) C60311.1(A) C60312.1(A) PAD60310.2 U60300.1
VRPVTT: C60350.2(B) PAD60350.1 U60300.5 U60300.8
VRPVTT_REF: C60351.1(A) U60300.7
WLAN_CLK: CN1300.64(RSRVD4) R1352.2(B)
WLAN_CLKREQ14#: R1357.2(B) R1358.1(A)
WLAN_I2C_CLK: CN1300.60(I2C_CLK) TP1307.1
WLAN_I2C_DAT: CN1300.58(I2C_DATA) TP1300.1
WLAN_WAKE#: CN1300.55(PEWAKE0*) Q1314.2(E) R1359.1(A)
WOL_PWEN: CN603.19 U1.109(TXD/SOUT0/GPB1)
WP_RCOMP: R4600.1(A) U4710.BA1(CNV_WT_RCOMP)
WR_CLK_DN: R1338.1(A) U4710.BD4(CNV_WR_CLKN)
WR_CLK_DP: R1337.1(A) U4710.BE3(CNV_WR_CLKP)
WR_LANE0_DN: R1366.1(A) U4710.BB3(CNV_WR_D0N)
WR_LANE0_DP: R1324.1(A) U4710.BB4(CNV_WR_D0P)
WR_LANE1_DN: R1328.1(A) U4710.BA3(CNV_WR_D1N)
WR_LANE1_DP: R1329.1(A) U4710.BA2(CNV_WR_D1P)
WT_CLK_DN: R1354.1(A) U4710.BC5(CNV_WT_CLKN)
WT_CLK_DP: R1353.1(A) U4710.BB6(CNV_WT_CLKP)
WT_LANE0_DN: R1330.1(A) U4710.BE6(CNV_WT_D0N)
WT_LANE0_DP: R1331.1(A) U4710.BD7(CNV_WT_D0P)
WT_LANE1_DN: R1367.1(A) U4710.BG6(CNV_WT_D1N)
WT_LANE1_DP: R1368.1(A) U4710.BF6(CNV_WT_D1P)
X401_3: C423.2(B) R410.1(A) R411.2(B) X400.3
XCLK_BIASREF: R4892.2(B) U4710.T3(XCLK_BIASREF)
XTAL24_IN: L4700.1(INC) R4719.1(A) U4710.U10(XTAL_IN)
XTAL24_IN_R: C4828.1(A) L4700.4(IND) R4719.2(B) R4898.1(A) X4751.3
XTAL24_OUT: L4700.2(INA) R4716.1(A) U4710.U9(XTAL_OUT)
XTAL24_OUT_R: C4826.1(A) L4700.3(INB) R4716.2(B) R4898.2(B) X4751.1
XTLI: C422.2(B) R411.1(A) U400.8 X400.1
XTLO: R410.2(B) U400.7
