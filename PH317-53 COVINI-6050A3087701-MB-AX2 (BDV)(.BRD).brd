# Allegro board PH317-53 COVINI-6050A3087701-MB-AX2 (BDV)(.BRD).brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
PCIE_WLAN_TX14N: length 65.1
  TOP w0.107: C1322.1 279.49,24.12 279.49,24.38 v1(279.67,24.56)
  L8 w0.084: v1(279.67,24.56) 279.53,24.42 279.53,24.42 279.53,24.02 279.24,23.73 278.39,23.73 276.98,25.14 276.98,29.05 273.7,32.33 268.44,32.33 267.47,31.36 263.43,31.36 262.15,32.64 259.06,32.64 254.32,37.38 250.2,37.38 249.66,37.92 246.61,37.92 244.75,39.78 243.76,39.78 242.62,40.92 235.28,40.92 234.34,41.87 234.34,42.25 v1(234.14,42.45)
  BOTTOM w0.089: 237.01,45.21 237.02,45.22 237.04,45.22 237.74,45.92 237.74,46.18 238.05,46.49 238.67,46.49 U4710.C39
  BOTTOM w0.107: 237.01,45.21 235.93,44.13 235.31,44.13 235.14,44.13 234.36,43.35 234.36,42.66 v1(234.14,42.45)
PCIE_WLAN_TX14P: length 65
  TOP w0.107: v3(279.01,24.56) 279.28,24.29 279.28,24.06 C1323.1
  L8 w0.084: v1(234.82,42.45) 234.69,42.45 234.55,42.3 234.55,41.96 235.37,41.13 242.7,41.13 243.85,39.99 244.84,39.99 246.7,38.13 249.75,38.13 250.28,37.6 254.4,37.6 259.15,32.85 262.24,32.85 263.52,31.58 267.38,31.58 268.35,32.54 273.78,32.54 277.19,29.14 277.19,25.23 278.47,23.94 279.15,23.94 279.32,24.11 279.32,24.36 279.12,24.56 v3(279.01,24.56)
  BOTTOM w0.089: 237.15,45.06 237.17,45.08 237.17,45.1 237.92,45.85 237.92,46.1 238.13,46.31 238.47,46.31 238.61,46.17 238.92,46.17 U4710.D39
  BOTTOM w0.107: v1(234.82,42.45) 234.57,42.7 234.57,43.26 235.23,43.92 236.01,43.92 237.15,45.06
PCSPKR_EC_3: length 203.7
  TOP w0.102: R505.2 v1(13.5,59.99)
  L8 w0.102: v3(199.78,27.23) 199.11,26.56 169.25,26.56 169.01,26.8 126.5,26.8 122.42,30.89 108.54,30.89 107.7,31.73 63.06,31.73 61.31,33.48 60.09,33.48 54.28,39.3 45.49,39.3 36.07,48.72 30.35,48.72 28.93,50.14 28.93,51.94 21.17,59.69 16.2,59.69 15.91,59.99 v1(13.5,59.99)
  BOTTOM w0.102: U1.34 199.67,27.14 199.77,27.23 v3(199.78,27.23)
PEG_CPU_RX0N_C: length 23.4
  TOP w0.102: 152.39,141.11 152.41,141.13 152.41,141.13 152.46,141.17 152.63,141.17 152.63,141.17 154.3,141.17 154.55,140.91 154.55,140.63 154.56,140.62
  TOP w0.105: v4(154.7,140.48) 154.56,140.62
  TOP w0.107: 152.39,141.11 151.92,140.64 139.62,140.64 135.18,136.2 134.38,136.2 C55731.2
  BOTTOM w0.105: v4(154.7,140.48) U50000.BG41
PEG_CPU_RX0P_C: length 23.4
  TOP w0.102: v4(154,140.48) 154.19,140.48 154.35,140.64 154.35,140.83 154.21,140.97 152.54,140.97
  TOP w0.107: C55730.2 134.26,135.76 134.49,135.99 135.26,135.99 139.71,140.43 152.01,140.43 152.54,140.97
  BOTTOM w0.105: U50000.BH41 154.3,140.74 154.04,140.48 v4(154,140.48)
PEG_CPU_RX1N_C: length 25.4
  TOP w0.102: 153.52,139.55 153.52,139.55 153.86,139.55 153.92,139.48 154.13,139.48 154.23,139.58 154.23,139.89 154.34,139.99 154.49,139.99 154.68,139.79 v4(154.68,139.75)
  TOP w0.107: C55729.2 132.81,135.12 132.97,134.96 135.03,134.96 140.05,139.98 151.22,139.98 151.65,139.55 153.52,139.55
  BOTTOM w0.105: v4(154.68,139.75) 154.73,139.75 155,139.48 U50000.BG39
PEG_CPU_RX1P_C: length 25.4
  TOP w0.102: 153.52,139.34 153.52,139.35 153.77,139.35 153.84,139.28 154.2,139.28 154.63,139.35 154.82,139.39 154.93,139.44 v4(155.4,139.68)
  TOP w0.107: C55728.2 132.96,134.75 135.11,134.75 140.14,139.77 151.13,139.77 151.56,139.34 153.52,139.34
  BOTTOM w0.105: v4(155.4,139.68) U50000.BF39
PEG_CPU_RX2N_C: length 29.3
  TOP w0.102: v4(156.08,138.31) 155.82,138.57 155.64,138.57 155.42,138.79 151.99,138.79 151.99,138.79 151.96,138.79
  TOP w0.107: C55727.2 130.08,134.1 131.7,134.1 131.82,133.98 135.22,133.98 140.4,139.15 150.44,139.15 150.8,138.79 151.96,138.79
  BOTTOM w0.105: v4(156.08,138.31) 156.08,138.36 U50000.BE38
PEG_CPU_RX2P_C: length 29.4
  TOP w0.102: 151.96,139 151.99,139 151.99,138.99 155.5,138.99 155.72,138.77 155.82,138.77 156.08,139.03 v4(156.09,139.03)
  TOP w0.107: C55726.2 130.15,134.31 131.78,134.31 131.91,134.19 135.13,134.19 140.31,139.36 150.52,139.36 150.89,139 151.96,139
  BOTTOM w0.105: U50000.BF38 156.04,139.02 156.07,139.02 v4(156.09,139.03)
PEG_CPU_RX3N_C: length 25.1
  TOP w0.102: v4(154,138.38) 154.05,138.33 154.05,138.18 153.9,138.02 153.69,138.02 153.19,138.52 152.35,138.52 152.19,138.36 151.77,138.36 151.77,138.36 151.74,138.36
  TOP w0.107: C55725.2 132.96,133.35 133.07,133.24 133.24,133.24 133.36,133.36 133.52,133.36 133.66,133.21 133.82,133.21 133.97,133.36 134.12,133.36 134.27,133.21 134.4,133.21 134.54,133.35 134.74,133.35 134.88,133.21 135.04,133.21 140.57,138.74 149.8,138.74 150.18,138.36 151.74,138.36
  BOTTOM w0.105: v4(154,138.38) 154,138.43 154.25,138.68 U50000.BH38
PEG_CPU_RX3P_C: length 25.1
  TOP w0.102: 151.74,138.15 151.77,138.15 151.77,138.15 152.27,138.15 152.44,138.32 153.11,138.32 153.61,137.82 153.98,137.82 154.19,138.03 v4(154.7,138.38)
  TOP w0.107: C55724.2 133.09,133.01 135.13,133.01 140.65,138.54 149.71,138.54 150.1,138.15 151.74,138.15
  BOTTOM w0.105: v4(154.7,138.38) U50000.BG38
PEG_CPU_RX4N_C: length 27.1
  TOP w0.102: 151.38,137.47 151.41,137.47 151.41,137.47 152.81,137.47 152.88,137.4 153.37,137.4 153.51,137.54 153.7,137.54 153.84,137.4 154.11,137.4 154.21,137.5 154.21,137.68 154.36,137.83 154.6,137.83 154.7,137.73 v4(154.7,137.58)
  TOP w0.107: 151.38,137.47 140.24,137.47 135.14,132.37 131.3,132.37 C55723.2
  BOTTOM w0.102: U50000.BG36 154.97,137.25 154.83,137.25 154.7,137.38 v4(154.7,137.58)
PEG_CPU_RX4P_C: length 27.1
  TOP w0.102: v4(155.4,137.58) 154.95,137.26 154.75,137.2 152.79,137.2 152.73,137.26 151.41,137.26 151.41,137.26 151.38,137.26
  TOP w0.107: C55722.2 131.16,132.16 135.22,132.16 140.32,137.26 151.38,137.26
  BOTTOM w0.105: v4(155.4,137.58) U50000.BF36
PEG_CPU_RX5N_C: length 26.5
  TOP w0.102: v4(156.03,136.25) 155.88,136.4 155.58,136.4 155.28,136.71 151.61,136.71 151.52,136.62 151.44,136.62 151.44,136.62
  TOP w0.107: 151.44,136.62 140.62,136.62 135.4,131.4 132.68,131.4 C55721.2
  BOTTOM w0.105: v4(156.03,136.25) 156.03,136.25 156.07,136.25 U50000.BE35
PEG_CPU_RX5P_C: length 26.6
  TOP w0.102: v4(156.03,136.91) 156.03,136.77 155.86,136.6 155.67,136.6 155.36,136.91 151.52,136.91 151.44,136.83 151.44,136.83
  TOP w0.107: 151.44,136.83 140.53,136.83 135.31,131.6 132.68,131.6 C55720.2
  BOTTOM w0.105: U50000.BF35 v4(156.03,136.91)
PEG_CPU_RX6N_C: length 23.8
  TOP w0.102: v4(153.94,136.23) 153.81,136.09 153.65,136.09 153.34,136.4 151.93,136.4 151.89,136.36 151.89,136.36 151.87,136.34
  TOP w0.107: 151.87,136.34 151.74,136.21 140.79,136.21 135.22,130.64 135,130.64 134.9,130.74 134.9,130.88 134.8,130.98 134.57,130.98 134.48,130.89 134.48,130.73 134.39,130.64 134.14,130.64 133.93,130.85 C55719.2
  BOTTOM w0.105: U50000.BH35 154.3,136.47 154.06,136.23 v4(153.94,136.23)
PEG_CPU_RX6P_C: length 23.9
  TOP w0.102: 152.02,136.19 152.02,136.2 153.26,136.2 153.57,135.89 153.67,135.85 154.03,135.85 154.14,135.9 154.7,136.27 v4(154.7,136.28)
  TOP w0.107: C55718.2 134,130.43 135.31,130.43 140.88,136 151.83,136 152.02,136.19
  BOTTOM w0.105: v4(154.7,136.28) U50000.BG35
PEG_CPU_RX7N_C: length 25.9
  TOP w0.102: v4(154.7,135.48) 154.75,135.43 154.75,135.25 154.63,135.13 154.31,135.13 154.22,135.21 152.29,135.21 152.11,135.38 151.84,135.38 151.84,135.38 151.81,135.38
  TOP w0.107: 151.81,135.38 141.13,135.38 135.55,129.79 135.24,129.79 135.12,129.67 134.97,129.67 134.84,129.79 134.67,129.79 134.54,129.67 134.39,129.67 134.27,129.79 134.11,129.79 134.01,129.7 133.81,129.7 133.71,129.79 133.52,129.79 133.4,129.68 133.25,129.68 133.14,129.79 132.88,129.79 C55717.2
  BOTTOM w0.105: U50000.BG33 v4(154.7,135.48)
PEG_CPU_RX7P_C: length 26
  TOP w0.102: 151.81,135.59 151.84,135.59 151.84,135.59 152.2,135.59 152.37,135.41 154.11,135.41 154.51,135.81 154.6,135.85 154.76,135.85 154.92,135.8 v4(155.33,135.53)
  TOP w0.107: 151.81,135.59 141.05,135.59 135.46,130 132.63,130 C55716.2
  BOTTOM w0.105: U50000.BF33 155.35,135.53 v4(155.33,135.53)
PEG_CPU_RX8N_C: length 24.5
  TOP w0.102: v4(156.07,134.15) 155.91,134.31 155.55,134.31 155.21,134.65 151.97,134.65 151.96,134.65 151.94,134.65
  TOP w0.107: 151.94,134.65 141.28,134.65 135.43,128.8 134.81,128.8 C55715.2
  BOTTOM w0.105: U50000.BE32 v4(156.07,134.15)
PEG_CPU_RX8P_C: length 24.7
  TOP w0.102: 151.94,134.85 151.96,134.85 151.97,134.85 155.3,134.85 155.64,134.51 155.83,134.51 155.99,134.67 v4(155.99,134.81)
  TOP w0.107: C55714.2 134.97,129.01 135.34,129.01 141.19,134.85 151.94,134.85
  BOTTOM w0.105: v4(155.99,134.81) 155.96,134.81 155.7,134.55 U50000.BF32
PEG_CPU_RX9N_C: length 25.3
  TOP w0.102: v4(153.97,134.14) 153.82,133.99 153.68,133.99 153.42,134.25 152.12,134.25 152.11,134.23 152.11,134.23
  TOP w0.107: C55713.2 132.68,128.3 132.81,128.17 133.91,128.17 133.97,128.23 136.1,128.23 141.89,134.03 148.51,134.03 148.62,134.14 148.77,134.14 148.88,134.03 149.09,134.03 149.21,134.14 149.3,134.14 149.41,134.03 149.51,134.03 149.62,134.14 149.72,134.14 149.83,134.03 149.93,134.03 150.04,134.14 150.13,134.14 150.25,134.03 150.34,134.03 150.46,134.14 150.55,134.14 150.66,134.03 150.76,134.03 150.87,134.14 150.97,134.14 151.08,134.03 151.39,134.03 151.6,134.23 152.11,134.23
  BOTTOM w0.102: U50000.BH32 154.3,134.24 154.2,134.14 v4(153.97,134.14)
PEG_CPU_RX9P_C: length 25.3
  TOP w0.102: 152.11,134.03 152.13,134.03 152.13,134.03 152.19,134.03 152.2,134.04 153.34,134.04 153.61,133.77 154.12,133.77 154.35,134 154.52,134 v4(154.7,134.18)
  TOP w0.107: C55712.2 132.88,127.96 134,127.96 134.06,128.02 136.19,128.02 141.98,133.82 151.48,133.82 151.69,134.03 152.11,134.03
  BOTTOM w0.105: v4(154.7,134.18) U50000.BG32
PEG_CPU_RX10N_C: length 24.2
  TOP w0.102: 151.33,133.2 151.35,133.2 151.36,133.2 151.71,133.2 151.87,133.04 152.08,133.04 152.16,133.11 152.35,133.11 152.45,133.02 152.6,133.02 152.69,133.11 152.85,133.11 152.95,133.02 153.09,133.02 153.19,133.11 153.42,133.11 153.62,133.32 154.07,133.32 154.22,133.16 154.54,133.16 154.7,133.32 v4(154.7,133.38)
  TOP w0.107: 151.33,133.2 143.93,133.2 138.14,127.4 134.77,127.4 134.66,127.3 134.66,127.04 134.54,126.92 134.32,126.92 C55711.2
  BOTTOM w0.105: U50000.BG30 155,133.14 154.76,133.38 v4(154.7,133.38)
PEG_CPU_RX10P_C: length 24.4
  TOP w0.102: 151.33,133.41 151.35,133.41 151.36,133.4 151.8,133.4 151.88,133.32 153.33,133.32 153.53,133.52 154.23,133.52 154.46,133.75 155,133.75 155.37,133.38 v4(155.4,133.38)
  TOP w0.107: 151.33,133.41 143.85,133.41 138.05,127.61 C55710.2
  BOTTOM w0.105: v4(155.4,133.38) U50000.BF30
PEG_CPU_RX11N_C: length 27.5
  TOP w0.102: v4(156.7,132.08) 156.51,132.27 156.51,132.52 156.22,132.81 154.39,132.81 154.29,132.91 153.73,132.91 153.57,132.91 153.33,132.67 151.51,132.67 151.51,132.67 151.48,132.67
  TOP w0.107: 151.48,132.67 144.18,132.67 138.42,126.9 135.6,126.9 135.13,126.43 132.92,126.43 C55709.2
  BOTTOM w0.105: v4(156.7,132.08) U50000.BE29
PEG_CPU_RX11P_C: length 27.4
  TOP w0.102: v4(156,132.08) 156.12,132.08 156.3,132.27 156.3,132.43 156.13,132.61 154.31,132.61 154.21,132.7 153.65,132.7 153.41,132.46 151.51,132.46 151.51,132.46 151.48,132.46
  TOP w0.107: 151.48,132.46 144.27,132.46 138.5,126.69 135.68,126.69 135.21,126.22 133.01,126.22 132.81,126.03 C55708.2
  BOTTOM w0.105: v4(156,132.08) U50000.BF29
PEG_CPU_RX12N_C: length 23.5
  TOP w0.102: 152.22,131.95 152.25,131.95 152.25,131.96 153.42,131.96 153.49,131.88 153.49,131.73 153.59,131.64 153.73,131.64 153.96,131.87 v4(153.96,132.04)
  TOP w0.107: 152.22,131.95 151.84,131.95 151.73,131.84 144.55,131.84 138.01,125.3 136.2,125.3 136.14,125.24 136.14,125.24 136.08,125.17 135.99,125.17 135.93,125.24 135.93,125.24 135.87,125.3 135.78,125.3 135.72,125.24 135.72,125.24 135.66,125.17 135.57,125.17 135.51,125.24 135.51,125.24 135.45,125.3 135.37,125.3 135.3,125.24 135.3,125.24 135.24,125.17 135.16,125.17 135.1,125.24 135.1,125.24 135.04,125.3 134.76,125.3 C55707.2
  BOTTOM w0.105: U50000.BH29 v4(153.96,132.04)
PEG_CPU_RX12P_C: length 23.6
  TOP w0.102: v4(154.7,132.08) 154.45,132.08 154.11,132.41 153.81,132.41 153.56,132.16 152.25,132.16 152.25,132.16 152.22,132.16
  TOP w0.107: 152.22,132.16 151.76,132.16 151.64,132.05 144.46,132.05 137.92,125.51 134.76,125.51 C55706.2
  BOTTOM w0.105: v4(154.7,132.08) U50000.BG29
PEG_CPU_RX13N_C: length 25.8
  TOP w0.102: v4(154.7,131.35) 154.7,131.11 154.6,131.01 154.31,131.01 154.19,131.13 153.98,131.13 153.85,131.01 153.66,131.01 153.56,131.11 153.32,131.11 153.22,131.01 152.98,131.01 152.86,131.12 152.61,131.12 152.5,131.01 152.06,131.01 152.05,131.01 151.88,131.01 151.86,130.98
  TOP w0.107: 151.86,130.98 144.28,130.98 137.84,124.54 133.09,124.54 133.03,124.59 132.98,124.59 132.81,124.76 C55705.2
  BOTTOM w0.105: U50000.BG27 155,131.05 v4(154.7,131.35)
PEG_CPU_RX13P_C: length 25.9
  TOP w0.102: 151.86,130.78 151.88,130.78 151.88,130.78 151.94,130.78 151.97,130.8 154.68,130.8 154.9,131.02 154.9,131.03 155.15,131.28 v4(155.4,131.28)
  TOP w0.107: C55704.2 132.9,124.35 132.92,124.35 132.94,124.33 137.92,124.33 144.37,130.78 151.86,130.78
  BOTTOM w0.105: v4(155.4,131.28) U50000.BF27
PEG_CPU_RX14N_C: length 26.2
  TOP w0.102: v4(156.04,129.92) 155.74,130.22 155.69,130.22 155.61,130.22 155.48,130.34 153.39,130.34 153.39,130.34 153.37,130.34
  TOP w0.107: 153.37,130.34 153.03,130.34 150.86,128.17 142.64,128.17 137.51,123.04 133.67,123.04 C55703.2
  BOTTOM w0.102: U50000.BE26 v4(156.04,129.92)
PEG_CPU_RX14P_C: length 26.2
  TOP w0.102: v4(156.04,130.62) 155.83,130.42 155.72,130.42 155.69,130.42 155.57,130.54 153.39,130.54 153.39,130.54 153.37,130.54
  TOP w0.107: 153.37,130.54 152.94,130.54 150.77,128.38 142.55,128.38 137.42,123.24 133.88,123.24 C55702.2
  BOTTOM w0.105: U50000.BF26 v4(156.04,130.62)
PEG_CPU_RX15N_C: length 24.5
  TOP w0.102: v4(154.02,129.95) 154.12,129.95 154.29,129.79 154.29,129.51 154.07,129.3 153.34,129.3 152.75,128.71 152.74,128.71 152.72,128.69
  TOP w0.107: C55701.2 134.76,121.8 135.17,121.8 135.4,121.57 136.7,121.57 142.81,127.68 151.72,127.68 152.72,128.69
  BOTTOM w0.105: v4(154.02,129.95) 154.07,129.95 154.3,130.18 U50000.BH26
PEG_CPU_RX15P_C: length 24.6
  TOP w0.102: 152.87,128.54 152.89,128.56 152.89,128.56 153.42,129.1 154.16,129.1 154.49,129.43 154.49,129.76 v4(154.66,129.92)
  TOP w0.107: 152.87,128.54 151.81,127.48 142.9,127.48 136.79,121.36 135.31,121.36 135.08,121.59 134.47,121.59 C55700.2
  BOTTOM w0.105: v4(154.66,129.92) 155,130.27 U50000.BG26
PEG_RCOMP: length 8.5
  BOTTOM w0.254: U4555.G2 122.84,118.31 122.84,117.52 123.7,116.66 124.34,116.66 125.33,115.68 125.33,115.19 125.35,115.17
  BOTTOM w0.508: R4501.2 v2(125.35,112.59) 125.35,115.17
PEG_TX0_DN: length 9.8
  BOTTOM w0.076: 127.85,135.27 127.83,135.27 127.8,135.25 127.18,135.25 127.01,135.08 126.66,135.08 126.55,135.19 126.55,135.3 126.64,135.39 U4555.A25
  BOTTOM w0.107: 127.85,135.27 131.9,135.27 133.45,136.83 134.74,136.83 C4836.2
PEG_TX0_DP: length 9.9
  BOTTOM w0.076: U4555.B25 126.21,135.39 126.39,135.21 126.39,135.12 126.6,134.92 127.08,134.92 127.25,135.08 127.8,135.08 127.83,135.06 127.85,135.06
  BOTTOM w0.107: 127.85,135.06 131.98,135.06 133.54,136.62 134.91,136.62 C4835.2
PEG_TX1_DN: length 12.2
  BOTTOM w0.076: U4555.C24 125.83,134.77 126.08,134.89 126.13,134.9 126.23,134.9 126.32,134.86 126.43,134.75 126.45,134.69 126.47,134.59 126.52,134.49 126.55,134.45 126.69,134.31 127.21,134.31 127.29,134.22 127.89,134.22 127.91,134.24 127.93,134.24
  BOTTOM w0.107: 127.93,134.24 131.77,134.24 133.65,136.12 136.27,136.12 C4838.2
PEG_TX1_DP: length 12.1
  BOTTOM w0.076: 127.93,134.03 127.91,134.03 127.89,134.06 127.22,134.06 127.14,134.14 126.62,134.14 126.49,134.27 125.95,134.27 125.86,134.36 125.86,134.53 125.93,134.6 U4555.B24
  BOTTOM w0.107: C4837.2 136.23,135.91 133.74,135.91 131.86,134.03 127.93,134.03
PEG_TX2_DN: length 10
  BOTTOM w0.076: 128.31,133.44 128.29,133.44 128.27,133.42 127.84,133.42 127.64,133.62 127.19,133.62 127.1,133.52 126.72,133.52 126.65,133.52 126.51,133.66 126.51,133.77 126.61,133.86 126.77,133.86 U4555.A23
  BOTTOM w0.107: 128.31,133.44 131.84,133.44 133.64,135.24 134.78,135.24 C4840.2
PEG_TX2_DP: length 10
  BOTTOM w0.076: 128.31,133.23 128.29,133.23 128.27,133.25 127.77,133.25 127.57,133.46 127.26,133.46 127.16,133.36 126.79,133.36 126.58,133.36 126.35,133.59 126.35,133.63 U4555.B23
  BOTTOM w0.107: 128.31,133.23 131.93,133.23 133.73,135.03 134.88,135.03 C4839.2
PEG_TX3_DN: length 12.2
  BOTTOM w0.076: U4555.C22 125.85,133.21 125.93,133.26 126.03,133.3 126.15,133.33 126.23,133.32 126.28,133.31 126.35,133.27 126.43,133.19 126.56,132.87 126.71,132.72 127.01,132.72 127.15,132.57 127.72,132.57 127.88,132.73 128.23,132.73 128.25,132.75 128.27,132.75
  BOTTOM w0.107: 128.27,132.75 132.04,132.75 133.75,134.46 136.29,134.46 C4842.2
PEG_TX3_DP: length 12.3
  BOTTOM w0.076: U4555.B22 125.88,133.03 125.8,132.95 125.8,132.81 125.91,132.71 126.48,132.71 126.64,132.55 126.94,132.55 127.09,132.41 127.79,132.41 127.95,132.57 128.23,132.57 128.25,132.54 128.27,132.54
  BOTTOM w0.107: C4841.2 136.45,134.1 136.29,134.25 133.83,134.25 132.12,132.54 128.27,132.54
PEG_TX4_DN: length 9.7
  BOTTOM w0.076: 128.11,132.04 128.1,132.04 128.07,132.02 127.21,132.02 127.12,131.93 126.65,131.93 126.52,132.06 126.52,132.14 126.62,132.24 U4555.A21
  BOTTOM w0.107: 128.11,132.04 132.2,132.04 133.69,133.53 134.77,133.53 C4882.2
PEG_TX4_DP: length 9.8
  BOTTOM w0.076: U4555.B21 126.36,132.05 126.36,131.99 126.59,131.76 127.19,131.76 127.28,131.85 128.07,131.85 128.1,131.83 128.11,131.83
  BOTTOM w0.107: 128.11,131.83 132.29,131.83 133.78,133.32 134.83,133.32 C4883.2
PEG_TX5_DN: length 11.9
  BOTTOM w0.076: 128.36,131.13 128.34,131.13 128.32,131.15 127.98,131.15 127.74,130.91 127.07,130.91 126.98,131 125.91,131 125.71,131.2 125.71,131.32 125.57,131.45 U4555.C20
  BOTTOM w0.107: 128.36,131.13 132.46,131.13 133.76,132.43 136.31,132.43 C4834.2
PEG_TX5_DP: length 11.9
  BOTTOM w0.076: 128.36,131.34 128.34,131.34 128.32,131.31 127.91,131.31 127.67,131.07 127.14,131.07 127.05,131.16 125.97,131.16 125.87,131.26 125.87,131.38 125.95,131.45 U4555.B20
  BOTTOM w0.107: 128.36,131.34 132.37,131.34 133.67,132.64 136.27,132.64 136.45,132.82 C4879.2
PEG_TX6_DN: length 9.3
  BOTTOM w0.076: 128.34,130.62 128.32,130.62 128.3,130.6 127.36,130.6 127.13,130.37 126.65,130.37 126.57,130.45 126.57,130.57 126.67,130.67 U4555.A19
  BOTTOM w0.107: C4812.2 134.7,131.96 134.48,131.74 133.65,131.74 132.53,130.62 128.34,130.62
PEG_TX6_DP: length 9.4
  BOTTOM w0.076: 129.49,130.41 129.5,130.41 ; 128.34,130.41 128.32,130.41 128.3,130.43 127.42,130.43 127.2,130.21 126.58,130.21 126.41,130.38 126.41,130.48 126.23,130.67 U4555.B19
  BOTTOM w0.107: C4831.2 134.59,131.53 133.74,131.53 132.62,130.41 129.5,130.41 ; 128.34,130.41 129.49,130.41
PEG_TX7_DN: length 10.6
  BOTTOM w0.076: 129.5,129.94 129.51,129.94 ; 127.93,129.76 127.91,129.75 127.91,129.72 127.68,129.48 127.29,129.48 127.18,129.59 126.65,129.59 126.47,129.76 126.47,129.91 126.42,130.04 126.33,130.13 126.23,130.17 126.1,130.17 125.87,130.1 U4555.C18
  BOTTOM w0.107: 129.5,129.94 128.1,129.94 127.93,129.76 ; 129.51,129.94 132.76,129.94 133.59,130.76 C4810.2
PEG_TX7_DP: length 10.5
  BOTTOM w0.076: 128.07,129.61 128.06,129.6 128.03,129.6 127.75,129.32 127.22,129.32 127.12,129.42 126.58,129.42 126.42,129.58 125.96,129.58 125.9,129.64 125.9,129.77 126.01,129.88 U4555.B18 ; 129.5,129.73 129.51,129.73
  BOTTOM w0.107: 128.07,129.61 128.19,129.73 129.5,129.73 ; C4811.2 135.1,130.23 134.78,130.55 133.67,130.55 132.85,129.73 129.51,129.73
PEG_TX8_DN: length 8.9
  BOTTOM w0.076: 128.71,129.09 128.63,129.09 128.61,129.11 128.42,129.11 128.13,128.82 127.34,128.82 127.13,128.62 126.54,128.62 126.34,128.81 126.34,128.91 U4555.B17
  BOTTOM w0.107: 128.71,129.09 134.33,129.09 134.34,129.09 134.34,129.09 C4820.2
PEG_TX8_DP: length 8.8
  BOTTOM w0.076: U4555.A17 126.6,129.09 126.51,129 126.51,128.88 126.61,128.78 127.06,128.78 127.27,128.99 128.06,128.99 128.35,129.28 128.68,129.28 128.7,129.3 128.71,129.3
  BOTTOM w0.107: 128.71,129.3 134.25,129.3 C4818.2
PEG_TX9_DN: length 7.8
  BOTTOM w0.076: 127.92,128.16 127.91,128.15 127.91,128.12 127.7,127.91 127.29,127.91 127.2,127.99 125.94,127.99 125.86,128.07 125.86,128.19 125.98,128.3 U4555.B16
  BOTTOM w0.107: 127.92,128.16 128.25,128.49 132.6,128.49 C4822.2
PEG_TX9_DP: length 7.9
  BOTTOM w0.076: 128.07,128.01 128.06,128 128.02,128 127.76,127.74 127.22,127.74 127.13,127.83 125.87,127.83 125.7,128 125.7,128.12 U4555.C16 ; 129.36,128.28 129.37,128.28
  BOTTOM w0.107: 129.36,128.28 128.33,128.28 128.07,128.01 ; C4819.2 132.59,128.28 129.37,128.28
PEG_TX10_DN: length 14
  TOP w0.076: v1(128.23,127.21) 128.23,127.25 128.37,127.38 128.61,127.38 128.8,127.19 129.5,127.19 129.57,127.26 129.81,127.26 130.04,127.49 130.04,127.51
  TOP w0.107: v1(130.23,127.65) 130.18,127.65 130.04,127.51
  BOTTOM w0.076: v1(128.23,127.21) 128.21,127.23 128.19,127.23 128.14,127.28 128.08,127.28 128.03,127.33 127.33,127.33 127.05,127.06 126.56,127.06 126.37,127.25 126.37,127.42 126.27,127.52 U4555.B15
  BOTTOM w0.107: v1(130.23,127.65) 130.23,127.51 130.45,127.29 131.56,127.29 131.9,127.63 134.77,127.63 134.97,127.83 136.39,127.83 137.35,128.78 137.91,128.78 138.11,128.98 C4821.2
PEG_TX10_DP: length 13.9
  TOP w0.076: v1(129.65,127.66) 129.65,127.57 129.43,127.36 128.87,127.36 v1(128.43,127.79)
  BOTTOM w0.076: v1(128.43,127.79) 128.43,127.78 128.25,127.59 128.07,127.59 127.98,127.5 127.26,127.5 126.98,127.22 126.63,127.22 126.53,127.32 126.53,127.44 126.61,127.52 U4555.A15
  BOTTOM w0.107: v1(129.65,127.66) 129.69,127.61 129.69,127.61 130.06,127.24 130.2,127.24 130.36,127.08 131.65,127.08 131.99,127.42 134.85,127.42 135.06,127.62 136.48,127.62 137.43,128.58 137.91,128.58 138.11,128.38 C4823.2
PEG_TX11_DN: length 7
  BOTTOM w0.076: U4555.B14 125.95,126.73 125.88,126.66 125.88,126.52 125.97,126.44 127.2,126.44 127.27,126.37 128,126.37 128.02,126.39 128.04,126.39
  BOTTOM w0.107: 128.04,126.39 129.57,126.39 129.85,126.67 131.9,126.67 C4833.2
PEG_TX11_DP: length 7.1
  BOTTOM w0.076: U4555.C14 125.58,126.73 125.72,126.58 125.72,126.45 125.9,126.27 127.13,126.27 127.2,126.2 128,126.2 128.02,126.18 128.04,126.18
  BOTTOM w0.107: 128.04,126.18 129.65,126.18 129.94,126.47 132.01,126.47 C4832.2
PEG_TX12_DN: length 10
  BOTTOM w0.076: U4555.B13 126.39,125.71 126.39,125.65 126.57,125.47 127.18,125.47 127.31,125.6 127.63,125.6 127.65,125.58 127.67,125.58
  BOTTOM w0.107: C4878.2 135.1,125.91 134.77,125.59 134.75,125.59 130.04,125.59 129.93,125.48 128.17,125.48 128.07,125.58 127.67,125.58
PEG_TX12_DP: length 10.1
  BOTTOM w0.076: 127.67,125.79 127.65,125.79 127.63,125.77 127.24,125.77 127.11,125.64 126.63,125.64 126.56,125.71 126.56,125.84 126.66,125.94 U4555.A13
  BOTTOM w0.107: C4880.2 135.69,126.42 135.38,126.12 135.01,126.12 134.69,125.79 129.95,125.79 129.85,125.69 128.25,125.69 128.16,125.79 127.67,125.79
PEG_TX13_DN: length 9.5
  BOTTOM w0.076: 128.51,125.03 128.49,125.03 128.46,125.01 128.23,125.01 127.86,124.64 127.25,124.64 127.03,124.86 126.02,124.86 125.94,124.94 125.94,125.06 126.03,125.15 U4555.B12
  BOTTOM w0.107: C4881.2 134.42,125.11 134.08,124.77 131.58,124.77 131.22,125.13 130.16,125.13 130.06,125.03 128.51,125.03
PEG_TX13_DP: length 9.6
  BOTTOM w0.076: 128.51,124.82 128.49,124.82 128.46,124.84 128.29,124.84 127.93,124.48 127.18,124.48 126.96,124.7 125.95,124.7 125.77,124.87 125.77,124.99 125.61,125.15 U4555.C12
  BOTTOM w0.107: C4884.2 131.49,124.57 131.14,124.92 130.25,124.92 130.15,124.82 128.51,124.82
PEG_TX14_DN: length 12
  TOP w0.107: v1(128.29,123.55) 128.31,123.55 128.71,123.95 128.77,123.95 128.96,124.13 129.94,124.13 129.98,124.17 v1(130.06,124.17)
  BOTTOM w0.076: U4555.B11 126.34,124.19 126.34,124.13 126.59,123.88 128.03,123.88 128.29,123.62 v1(128.29,123.55)
  BOTTOM w0.107: v1(130.06,124.17) 130.32,123.91 133.86,123.91 134.09,124.14 136.17,124.14 136.56,124.53 136.82,124.53 C4886.2
PEG_TX14_DP: length 12
  TOP w0.107: v1(130.12,123.55) 129.75,123.93 129.05,123.93 128.87,123.75 v1(128.87,123.55)
  BOTTOM w0.076: U4555.A11 126.65,124.37 126.57,124.29 126.57,124.13 126.66,124.04 128.1,124.04 128.21,123.93 128.49,123.93 v1(128.87,123.55)
  BOTTOM w0.107: v1(130.12,123.55) 130.12,123.55 130.28,123.71 133.95,123.71 134.17,123.93 136.26,123.93 136.65,124.32 136.9,124.32 C4885.2
PEG_TX15_DN: length 9.3
  BOTTOM w0.076: 129.37,123.08 129.35,123.08 129.33,123.06 127.56,123.06 127.34,123.29 125.99,123.29 125.88,123.4 125.88,123.51 125.94,123.58 U4555.B10
  BOTTOM w0.107: 129.37,123.08 130.42,123.08 130.63,123.29 134.21,123.29 C4888.2
PEG_TX15_DP: length 9.4
  BOTTOM w0.076: 129.37,122.87 129.35,122.87 129.33,122.89 127.49,122.89 127.27,123.12 125.92,123.12 125.71,123.33 125.71,123.42 125.55,123.58 U4555.C10
  BOTTOM w0.107: C4887.2 134.23,123.08 130.72,123.08 130.51,122.87 129.37,122.87
PEX_CLKREQ#: length 226
  L5 w0.102: v1(128.67,46.79) 129.23,46.23 133.41,46.23 133.44,46.21 151.02,46.21 151.93,47.12 208.2,47.12 211.43,43.89 212.99,43.89 213.88,43.01 214.56,43.01 215.02,43.46 217.86,43.46 219.16,42.17 228.83,42.17 230.98,44.32 237.28,44.32 240,47.04 240.89,47.04 242.52,48.67 251.11,48.67 251.33,48.45 251.52,48.26 251.85,48.26 252.52,48.93 253.82,48.93 253.88,48.87 254.55,48.87 254.78,49.11 254.78,49.37 255.1,49.69 257.06,49.69 v1(257.48,50.11)
  L8 w0.102: v1(128.67,46.79) 128.67,48.88 131.75,51.95 131.75,53.34 133.6,55.2 135.47,55.2 140.76,60.49 140.76,65.88 142.11,67.23 142.11,73.13 142.77,73.79 142.77,74.71 142.77,99.48 143.21,99.92 143.21,108.04 142.71,108.55 142.71,111.97 144.14,113.39 144.14,118.55 141.96,120.73 v1(141.96,121.95)
  BOTTOM w0.089: U4710.BE31 258.3,49.68 257.9,49.68 257.48,50.09 v1(257.48,50.11)
  BOTTOM w0.102: TP50010.1 140.45,122.71 140.72,122.98 Q50010.D 141.31,122.98 141.96,122.33 v1(141.96,121.95) 141.35,121.34 R50012.1
PEX_DGPU_RST#: length 121.4
  L5 w0.102: v1(144.14,41.84) 143.51,42.47 141.95,42.47 141.62,42.8 131.5,42.8 131.22,42.52 128.94,42.52 128.44,43.02 v1(128.44,43.62)
  L8 w0.102: v1(128.44,43.62) 128.44,44.68 128.98,45.22 128.98,45.62 129.21,45.85 129.21,47.55 130.58,48.92 131.3,49.65 131.3,51.1 135.2,54.99 135.39,54.99 135.39,54.99 135.55,54.99 140.97,60.41 140.97,65.8 142.31,67.15 142.31,73.05 142.97,73.71 142.97,94.64 142.97,99.39 143.42,99.84 143.42,100.01 143.42,108.13 142.91,108.63 142.91,111.88 144.34,113.31 144.34,121.73 143.94,122.13 143.94,123.7 145.61,125.38 v1(146.05,125.38)
  BOTTOM w0.102: R50020.1 145.54,39.32 U50020.4 145.58,39.61 v2(144.31,40.89) 144.14,41.05 v1(144.14,41.84) ; R51526.1 147.66,126.64 147.03,126.64 146.58,126.19 146.58,125.91 v1(146.05,125.38) ; R51526.1 149.17,127.13 151.97,129.93 152.32,129.93 U50000.BK26 ; R51526.1 R51512.1
PEX_GPU_CLKREQ#: length 18.6
  BOTTOM w0.102: 142.11,123.14 143.07,123.14 143.39,123.46 143.39,123.61 R50011.1 ; 142.11,123.14 142.11,122.69 142.77,122.03 Q50010.S ; 142.11,123.14 141.93,123.32 141.93,125.86 143.51,127.44 146.86,127.44 147.12,127.7 v2(148.92,127.7) 149.44,127.7 152.03,130.28 U50000.BL26
PEX_PLL_HVDD_SVDD: length 29.4
  TOP w0.254: C50092.1 159.26,134.07 C50091.1 159.15,133.62 v4(159.15,133.26) 159.15,132.85 C50090.1
  L3 w0.381: v1(141.73,144.2) 141.73,143.03 142.11,142.65 154.41,142.65 156.16,140.9 156.31,140.9 159.28,137.93 159.28,136.02 159.15,135.89 v4(159.15,133.26)
  BOTTOM w0.2: v4(159.15,133.26) 158.97,133.08 U50000.BB30
  BOTTOM w0.381: R50090.1 141.2,143.67 v1(141.73,144.2)
PFM_BG_REF_OUT: length 6.1
  BOTTOM w0.102: 145.95,56.98 R52053.1 ; 145.95,56.98 145.89,57.03 R52050.2 ; 145.95,56.98 145.95,56.24 146.4,55.79 146.4,55.1 C52055.1 145.95,53.93 v2(146.26,53.61) 146.06,53.4 U52000.23
PFM_BS_REF: length 8.1
  BOTTOM w0.102: U52000.24 146.46,53.02 146.81,53.37 146.81,54.52 C52053.1 146.6,55.33 146.6,56.36 v2(146.88,56.65) 146.88,56.94 R52053.2 R52054.2 R52055.2
PFM_CM_REF_IN: length 7.4
  BOTTOM w0.102: R52051.1 144.31,58.63 R52050.1 144.55,57.38 144.55,55.15 C52050.1 145.06,53.88 v2(145.01,53.83) 145.23,53.6 145.27,53.6 145.66,53.22 U52000.22
PFM_PF_BSOK_RC: length 2.2
  BOTTOM w0.102: Q52060.1 149.61,59.41 v2(150.59,59.41) 150.59,58.75 R52060.2
PFM_PF_R_BSOK: length 11.2
  L8 w0.102: v1(150.26,54.61) 149.22,53.57 149.22,50.67 v1(148.53,49.98)
  BOTTOM w0.102: R52061.1 149.95,54.3 v1(150.26,54.61) 150.26,56.26 150.44,56.44 R52060.1 ; U52000.30 v1(148.53,49.98)
PHASE_ID: length 4.9
  BOTTOM w0.102: U1.68 201.49,41.64 200.53,42.6 200.26,42.6 v2(200.26,42.6) 200.25,42.6 200.25,42.6 199.97,42.6 199.29,43.29 R322.2 198.46,43.5 R337.2
PLT_ID0: length 19.3
  TOP w0.102: R4791.2 270,48.59 v3(269.77,48.37) 269.69,48.44 R4784.1
  L8 w0.102: v3(269.77,48.37) 269.26,47.86 269.26,47.04 268.25,46.03 266.07,46.03 265.28,45.24 259.27,45.24 259.04,45.01 257.18,45.01 257.13,44.96 256.42,44.96 256.26,45.12 v1(254.77,45.12)
  BOTTOM w0.089: U4710.AR42 254.33,44.71 254.74,45.12 v1(254.77,45.12)
PLT_ID1: length 16.2
  L8 w0.102: v1(266.87,42.07) 266.67,41.86 260.12,41.86 259.69,41.43 258.24,41.43 257.83,41.84 254.16,41.84 v1(253.96,41.64)
  BOTTOM w0.089: U4710.AR48 254.1,41.65 253.98,41.65 v1(253.96,41.64)
  BOTTOM w0.102: v1(266.87,42.07) 267.53,42.73 R4782.1 267.82,43.61 R4790.2
PLT_ID2: length 19.8
  L8 w0.102: v1(267.51,40.96) 265.18,40.96 264.49,41.66 260.31,41.66 258.91,40.26 256.82,40.26 255.63,41.44 254.39,41.44 254.1,41.15 v1(253.64,41.15)
  BOTTOM w0.089: U4710.AU46 254.81,42.61 254.81,41.94 254.02,41.15 v1(253.64,41.15)
  BOTTOM w0.102: R4780.1 267.82,41.27 v1(267.51,40.96) 267.3,40.76 R4788.2
PLT_ID3: length 16.9
  L8 w0.102: v1(255.06,40.87) 255.88,40.06 263.36,40.06 263.55,39.87 267.52,39.87 v1(267.71,39.68)
  BOTTOM w0.089: U4710.AU47 255.15,42.24 255.37,42.02 255.37,41.18 v1(255.06,40.87)
  BOTTOM w0.102: R4781.1 268.09,39.68 v1(267.71,39.68) 267.52,39.87 R4789.2
PLT_RST#: length 18.5
  L8 w0.102: v1(255.9,50.57) 256.36,51.03 256.83,51.03 257.36,51.56 259.94,51.56 260.83,52.45 261.31,52.45 262.13,53.27 264.92,53.27 265.45,53.8 267.18,53.8 268.43,55.05 269.52,55.05 v3(269.92,55.45)
  BOTTOM w0.089: v1(255.9,50.57) 255.9,50.81 U4710.AV29
  BOTTOM w0.102: v3(269.92,55.45) 269.92,55.58 269.66,55.84 U4700.1 U4700.2
PLTRST_CPU#: length 321.4
  L8 w0.102: v3(249.88,67.67) 249.07,66.86 248.01,66.86 247.91,66.96 244.56,66.96 243.57,67.95 240.43,67.95 237.31,64.82 234.26,64.82 232.01,62.58 223.63,62.58 221.15,60.1 221.15,58.2 219.33,56.37 219.33,50.4 219.25,50.32 217.09,48.17 216.37,48.17 182.47,48.17 182.13,48.17 173.89,39.93 169.02,39.93 165.83,36.74 138.01,36.74 136.57,38.18 135.15,38.18 135.15,38.18 133.66,38.18 128.78,38.18 123.22,43.74 115.46,43.74 112.06,47.15 108.51,47.15 99.91,55.74 89.32,55.74 87.7,57.37 78.02,57.37 77.86,57.37 76.14,59.08 70.45,59.08 64.21,65.32 64.21,80.33 65.93,82.05 66.05,82.05 67.89,83.89 67.89,91.88 68.07,92.05 68.07,92.22 68.07,97.26 69.06,98.25 74.67,98.25 75.21,98.78 75.5,98.78 77.84,98.78 79.24,100.19 79.24,109.18 78.01,110.42 75.11,110.42 73.43,112.1 73.43,115.81 78.34,120.72 78.34,125.03 78.34,126.13 80.36,128.15 80.36,136.9 82.75,139.29 83.22,139.29 83.72,139.78 83.72,141.41 84.78,142.48 v1(85.18,142.48)
  BOTTOM w0.089: 249.88,67.36 249.88,67.29 249.7,67.11 249.7,67.1 249.68,67.08 249.68,65.72 249.88,65.51 249.88,64.91 250.3,64.5 250.3,63.2 U4710.AG5 ; v1(85.18,142.48) 85.33,142.48 85.93,141.88 85.93,141.88 86.04,141.77 86.71,141.77 86.85,141.91 86.97,141.91 86.97,141.92 87.16,141.92 U4555.BP35
  BOTTOM w0.102: v3(249.88,67.67) 249.88,67.36
PM_EXTTS#0_R: length 2.4
  TOP w0.102: R4201.2 113.76,76.08 v3(113.73,76.12)
  BOTTOM w0.102: CN4100.134 113.91,75.93 v3(113.73,76.12)
PM_EXTTS#1_R: length 3
  TOP w0.102: R4200.2 118.44,63.61 v3(118.85,63.2)
  BOTTOM w0.102: v3(118.85,63.2) 118.91,63.14 CN4125.134
POLARITY: length 3
  BOTTOM w0.102: TP2400.1 295.42,25.2 296.05,24.57 R2403.1 296.44,24.16 296.54,24.06 U8.5
PROC_SELECT#: length 8.9
  BOTTOM w0.076: R4520.2 85.81,112.7 85.06,112.7 84.32,113.44 v2(84.32,114.46) 84.32,114.73 86.12,116.52 87.04,116.52 U4555.BN1
PROCHOT#: length 122.7
  TOP w0.109: v1(79.17,156.28) 79.17,156.6 R60021.2
  L5 w0.076: v1(79.17,156.28) 79.17,152.97 81.52,150.62 81.52,141.72 78.37,138.58 78.37,129.77 76.21,127.6 76.21,119.22 67.19,110.2 67.19,103.15 65.95,101.91 65.95,98.54 67.67,96.82 67.67,89.96 68.06,89.57 68.06,85.77 67.43,85.15 67.43,84.48 66.71,83.76 66.43,83.76 65.83,83.16 65.83,82.65 62.94,79.76 62.94,79.24 56.08,72.38 v3(56.08,48.95)
  BOTTOM w0.109: U60000.10 56.03,47.77 56.03,48.9 v3(56.08,48.95)
PUSB3_PWR2: length 2.1
  BOTTOM w0.33: CN2500.A9 312.43,13.35 312.48,13.3 CN2500.B4 ; CN2500.B9 312.5,15.85 CN2500.A4
  vias: v2(309.29,8.16) v5(308.48,7.24) v5(308.48,6.48) v5(309.22,7.27) v5(309.22,6.48)
PV_RGLI: length 6.6
  TOP w0.254: 291.59,78.11 291.31,77.83 U56400.26
  TOP w0.305: R56453.2 294.9,80.24 R56452.2 C56452.2 294.03,77.96 v2(293.93,78.06) 293.87,78.11 291.59,78.11
PV_RGLRO: length 4.2
  TOP w0.254: U56400.27 290.91,78.19 291.03,78.31
  TOP w0.305: C56404.2 R56440.1 292.49,79.07 v2(291.51,79.07) 291.03,78.59 291.03,78.31
PVADPTR: length 23
  L3 w0.254: v1(50.62,49.58) 51.07,49.58 54.15,46.51 v1(54.15,40.19)
  BOTTOM w0.254: 45.59,51.87 49.2,51.87 50.62,50.45 v1(50.62,49.58) R60002.2 ; D60000.1 54.8,39.79 54.4,40.19 v1(54.15,40.19)
  BOTTOM w0.381: C6037.1 15.11,77.84 ; C60002.1 38.58,48.72 ; C6038.1 16,77.84
  vias: v2(16.96,81.18) v2(35.46,67.08) v2(40.18,50.52) v5(15.06,81.54) v5(15.06,80.78) v5(15.06,80.01) v5(15.06,79.27) v5(15.06,78.49) v5(15.82,81.54) v5(15.82,80.78) v5(15.82,80.02) v5(15.81,79.28) v5(15.82,78.49) v5(36.77,52.82) v5(37.03,51.8) v5(37.41,53.19) v5(37.41,52.44) v5(37.8,51.79) v5(38.17,53.19) v5(38.17,52.45) v5(38.53,51.79) v5(38.93,53.2) v5(38.93,52.46)
PVCORE: length 48.8
  TOP w0.254: C7512.2 102.22,158.63 C4722.1
  TOP w0.381: 115.73,126.43 C4561.1 ; 110.18,129.76 C4526.1 C4523.1 108.84,129.36 ; 113.24,129.36 C4695.1 ; C4695.1 C4535.1 ; C4695.1 113.69,129.92 ; C4535.1 115.02,129.36 ; C4535.1 114.58,129.82 ; 116.95,138.99 C4697.1 ; 109.47,136.21 C4692.1 ; C4552.1 118.4,126.43 ; 119.31,129.36 C4530.1 ; C4559.1 116.42,138.99 ; 117.07,126.03 C4560.1 ; C4557.1 110.76,126.43 ; 104.73,129.36 C4522.1 ; 108.97,126.43 C4556.1 ; C4529.1 103.92,138.99 ; 109.96,138.99 C4808.1 ; 104.55,126.4 C4667.1 ; 110.98,126.43 C4558.1 ; 114.85,137.05 C4521.1 ; C4566.1 118.73,138.99 ; 113.54,156.93 C7513.2 ; 113.15,130.92 C4698.1 113.79,130.47 ; C4532.1 106.23,137.38 ; 119.36,126.43 C4562.1 ; C4690.1 106.25,131.15 ; v1(115.26,127.85) 115.26,127.64 115,127.38 C4549.1 115,126.79 ; R21.2 109.28,142.61 ; C4568.1 103.82,126.43 ; 106.15,126.4 C4614.1 ; 114.64,138.99 C4807.1 ; C4670.1 117.68,130.85 ; 119.66,134.18 C4689.1 ; C4679.1 107.94,126.4 ; C4746.1 102.59,139.39 ; C4563.1 111.75,138.99 ; C4696.1 108.04,129.16 ; 112.28,137.18 C4694.1 ; 104.5,139.41 C4753.1 ; 102.04,126.43 C4744.1
  BOTTOM w0.127: 120.82,126.33 U4555.K14 ; 112.72,125.88 112.34,125.5 U4555.AA13 ; 120.5,126.71 U4555.L14 120.34,126.18 120.08,126.24 ; U4555.AJ14 105.98,126.06 v1(106.32,125.82)
  BOTTOM w0.152: U4555.AL13 104.78,125.5 104.67,125.39 104.31,125.39 104.21,125.5 U4555.AM13 103.86,125.5 103.76,125.39 103.4,125.39 103.29,125.5 U4555.AN13
  BOTTOM w0.203: U4555.AN35 v1(102.56,142.03) 102.88,141.71 U4555.AN34 ; U4555.AN36 v1(102.56,142.68) U4555.AP35 ; v1(103.54,125.82) U4555.AM13 ; v1(105.71,141.38) 106.03,141.71 U4555.AJ34 ; U4555.N38 118.76,144.38 118.76,145.37 ; U4555.AN13 102.67,125.79 v1(102.66,125.82) ; U4555.AL35 v1(104.13,142.03) U4555.AM34
  BOTTOM w0.254: U4555.AM14 103.91,126.06 v1(103.54,125.82) 103.23,126.06 U4555.AN14 ; U4555.L13 v1(120.03,125.82) ; U4555.AD38 110.36,144.64 v1(110.43,144.64) ; U4555.AA36 112.72,142.69 ; 112.72,142.69 U4555.AA35 ; 112.72,142.69 v1(112.79,142.69) 112.86,142.69 ; U4555.Y35 112.86,142.69 ; 112.86,142.69 U4555.Y36 112.86,143.34 v1(112.79,143.34) ; U4555.AG14 107.57,126.06 v1(107.24,125.82) 106.9,126.06 U4555.AH14 106.66,126.06 v1(106.32,125.82) ; U4555.AG14 108.03,126.43 ; U4555.AG14 107.42,126.48 ; U4555.AC35 110.5,142.69 v1(110.43,142.69) 110.36,142.69 U4555.AD36 ; v1(113.58,143.99) 113.65,143.99 U4555.W38 ; C66008.1 133.55,153.99 133.55,153.55 132.99,152.99 132.18,152.99 ; U4555.AB35 111.29,142.69 v1(111.22,142.69) ; U4555.AA13 v1(111.81,125.82) U4555.AC13 ; v1(112.79,144.64) 112.72,144.64 U4555.AA38 ; v1(111.22,143.99) 111.29,143.99 U4555.AB38 ; U4555.W35 113.65,142.69 v1(113.58,142.69)
  vias: v1(101.35,152.35) v1(101.35,151.77) v1(101.35,151.13) v1(101.35,150.55) v1(101.35,149.97) v1(101.84,126.55) v1(101.96,152.35) v1(101.96,151.77) v1(101.96,151.13) v1(101.96,150.55) v1(101.96,149.97) v1(102.54,152.35) v1(102.54,151.77) v1(102.54,151.13) v1(102.54,150.55) v1(102.54,149.97) v1(102.56,140.73) v1(102.56,140.08) v1(103.12,152.35) v1(103.12,151.77) v1(103.12,151.13) v1(103.12,150.55) v1(103.12,149.97) v1(103.33,142.68) v1(103.34,142.05) v1(103.35,141.41) v1(103.59,134.01) v1(103.59,132.79) v1(103.59,131.58) v1(103.96,127.87) v1(104.14,142.68) v1(104.13,140.73) v1(104.13,140.08) v1(104.09,137.56) v1(104.92,141.38) v1(104.92,140.74) v1(104.92,140.08) v1(105.41,125.82) v1(105.71,140.73) v1(105.71,140.09) v1(105.99,127.87) v1(106.37,137.56) v1(106.53,152.35) v1(106.53,151.77) v1(106.53,151.13) v1(106.53,150.55) v1(106.53,149.97) v1(107.04,136.43) v1(107.14,152.35) v1(107.14,151.77) v1(107.14,151.13) v1(107.14,150.55) v1(107.14,149.97) v1(107.28,142.04) v1(107.28,140.09) v1(107.72,152.35) v1(107.72,151.77) v1(107.72,151.13) v1(107.72,150.55) v1(107.72,149.97) v1(107.95,127.87) v1(108.07,142.04) v1(108.07,141.39) v1(108.07,140.74) v1(108.07,140.09) v1(108.31,152.35) v1(108.31,151.77) v1(108.31,151.13) v1(108.31,150.55) v1(108.31,149.97) v1(108.67,127.89) v1(108.84,139.43) v1(108.86,140.09) v1(108.94,137.67) v1(109.63,141.38) v1(109.63,140.74) v1(109.61,134.37) v1(109.65,140.08) v1(109.66,139.44) v1(109.99,125.82) v1(110.43,143.34) v1(110.43,142.04) v1(110.43,141.39) v1(110.43,140.74) v1(110.43,140.09) v1(110.69,127.85) v1(110.9,125.82) v1(111.22,140.09) v1(111.42,136.43) v1(111.91,137.67) v1(112.55,134.45) v1(112.55,131.98) v1(112.79,142.04) v1(112.79,141.39) v1(112.79,140.74) v1(112.79,140.09) v1(113.05,128.22) v1(113.05,127.61) v1(113.58,140.09) v1(114.25,137.65) v1(114.55,125.82) v1(115.15,144.64) v1(115.15,143.34) v1(115.15,142.69) v1(115.15,142.04) v1(115.15,141.39) v1(115.15,140.74) v1(115.15,140.09) v1(115.21,129.39) v1(115.94,143.99) v1(115.94,142.69) v1(115.94,140.09) v1(116.37,125.82) v1(116.71,137.72) v1(117.3,125.82) v1(117.52,144.64) v1(117.52,143.34) v1(117.52,142.69) v1(117.52,142.04) v1(117.52,141.39) v1(117.52,140.74) v1(117.52,140.09) v1(118.21,125.82) v1(118.3,143.99) v1(118.3,142.69) v1(118.3,140.09) v1(118.57,127.88) v1(118.84,129.37) v1(119.07,137.06) v1(122.07,152.33) v1(122.07,151.74) v1(122.07,151.11) v1(122.07,150.52) v1(122.07,149.94) v1(122.68,152.33) v1(122.68,151.74) v1(122.68,151.11) v1(122.68,150.52) v1(122.68,149.94) v1(123.27,152.33) v1(123.27,151.74) v1(123.27,151.11) v1(123.27,150.52) v1(123.27,149.94) v1(123.85,152.33) v1(123.85,151.74) v1(123.85,151.11) v1(123.85,150.52) v1(123.85,149.94) v1(127.38,152.33) v1(127.38,151.74) v1(127.38,151.11) v1(127.38,150.52) v1(127.38,149.94) v1(127.99,152.33) v1(127.99,151.74) v1(127.99,151.11) v1(127.99,150.52) v1(127.99,149.94) v1(128.58,152.33) v1(128.58,151.74) v1(128.58,151.11) v1(128.58,150.52) v1(128.58,149.94) v1(129.16,152.33) v1(129.16,151.74) v1(129.16,151.11) v1(129.16,150.52) v1(129.16,149.94) v5(101.5,149.13) v5(102.43,149.13) v5(102.47,147.15) v5(102.49,146.26) v5(103.37,149.13) v5(103.37,148.24) v5(103.35,147.36) v5(103.35,146.47) v5(104.14,152.2) v5(104.14,151.18) v5(104.14,150.17) v5(104.29,149.13) v5(104.29,148.24) v5(104.26,147.36) v5(104.26,146.47) v5(104.57,134.37) v5(104.57,133.51) v5(104.57,132.54) v5(104.57,131.63) v5(105.15,152.2) v5(105.15,151.19) v5(105.15,150.17) v5(105.23,149.13) v5(105.23,148.24) v5(105.2,147.36) v5(105.2,146.47) v5(105.36,134.37) v5(105.36,133.51) v5(105.36,132.54) v5(105.36,131.63) v5(106.14,147.36) v5(106.14,146.47) v5(106.17,149.13) v5(106.17,148.24) v5(107.03,130.28) v5(107.11,149.13) v5(107.11,148.24) v5(107.08,147.36) v5(107.08,146.47) v5(110.64,134.17) v5(110.64,133.12) v5(110.64,132.16) v5(110.64,131.19) v5(110.64,130.28) v5(111.43,134.17) v5(111.43,133.12) v5(111.43,132.16) v5(111.43,131.19) v5(111.43,130.28) v5(111.53,146.1) v5(112.01,146.82) v5(112.04,145.44) v5(112.52,146.13) v5(112.85,146.82) v5(112.87,145.44) v5(113.33,146.11) v5(113.84,148.37) v5(113.84,147.61) v5(113.79,146.82) v5(113.81,145.45) v5(114.27,146.11) v5(114.7,146.82) v5(114.73,145.45) v5(114.75,148.37) v5(114.75,147.61) v5(115.19,146.11) v5(115.64,146.82) v5(115.59,133.1) v5(115.59,132.36) v5(115.59,131.4) v5(115.59,130.43) v5(115.69,148.37) v5(115.69,147.61) v5(115.67,145.45) v5(116.13,146.11) v5(116.48,133.1) v5(116.48,132.36) v5(116.48,131.4) v5(116.48,130.43) v5(116.63,148.37) v5(116.63,147.61) v5(116.58,146.82) v5(116.61,145.45) v5(117.07,146.11) v5(117.52,146.82) v5(117.55,145.45) v5(118.01,146.11) v5(121.18,152.05) v5(121.21,151.03) v5(121.23,150.12) v5(121.27,149.12) v5(121.27,147.85) v5(121.27,146.58) v5(121.27,145.31) v5(122.54,149.12) v5(122.54,147.85) v5(122.54,146.58) v5(122.54,145.31) v5(123.81,149.12) v5(123.81,147.85) v5(123.81,146.58) v5(123.81,145.31) v5(125.06,152.85) v5(125.06,151.58) v5(125.06,150.31) v5(125.08,149.12) v5(125.08,147.85) v5(125.08,146.58) v5(125.08,145.31) v5(126.43,152.85) v5(126.43,151.58) v5(126.43,150.31) v5(126.46,149.12) v5(126.46,147.85) v5(126.46,146.58) v5(126.46,145.31) v5(127.73,149.12) v5(127.73,147.85) v5(127.73,146.58) v5(127.73,145.31) v5(129,149.12) v5(129,147.85) v5(129,146.58) v5(129,145.31) v5(130.27,149.12) v5(130.27,147.85) v5(130.27,146.58) v5(130.27,145.31)
PVCORE_DGPU: length 276.6
  TOP w0.2: 170.68,137.7 v4(170.75,137.63) 170.77,137.61 ; v4(160.97,122.89) 161.6,122.89 v4(161.65,122.93) ; v4(169.35,124.33) 169.41,124.27 ; 170.86,138.22 v4(170.75,138.33) 170.73,138.31 ; 170.75,127.07 v4(170.75,127.13) ; v4(167.95,125.73) 167.95,125.73 ; v4(169.38,123.62) 169.42,123.66
  TOP w0.254: v4(166.6,122.24) C52569.1 v4(166.55,122.93) ; v4(166.6,122.24) C52416.1 ; v4(166.6,122.24) C52582.1 ; C52551.1 v4(163.03,122.29) ; 166.7,124.35 C52530.1 ; C52404.1 168.89,137.28 ; v4(161.63,130.59) 161.65,130.61 v4(162.33,130.61) ; C52417.1 169.22,136.36 ; C52517.1 165.01,125.53 ; v4(177.7,122.95) 177.52,123.14 C52494.1 ; C52477.1 170.62,127.07 ; 174.7,133.13 C52520.1 174.37,132.81 v4(174.24,132.68) ; v4(163.75,129.23) 163.8,129.29 C52498.1 ; C7567.1 169.33,76.51 v5(169.36,76.48) ; C52427.1 177.42,134.47 v4(177.06,134.83) ; C52429.1 166.44,127.94 v4(166.55,127.83) ; C52549.1 v4(177.06,126.43) 177.3,126.67 C52522.1 ; 172.97,137.01 C52486.1 ; v4(166.55,122.93) C52556.1 C52543.1 167.02,123.77 166.58,124.21 v4(166.58,124.34) ; v4(166.55,122.93) C52402.1 ; v4(169.35,127.83) C52464.1 ; v4(169.35,127.83) C52450.1 ; v4(169.35,127.83) C52501.1 ; v4(165.15,134.13) 165.42,134.13 ; 168.39,134.23 C52457.1 ; 166.7,136.14 C52465.1 v4(166.55,136.23) ; v4(169.38,122.21) 169.72,122.55 C52571.1 C52558.1 169.48,123.48 ; C52504.1 169.39,133.54 v4(169.39,133.4) 169.44,133.35 C52518.1 ; 172.97,135.49 C52514.1 ; 168.07,125.56 C52554.1 v4(167.95,125.73) ; C52603.1 169.56,139.07 170.3,138.33 C52409.1 170.62,138.15 ; C52475.1 v4(166.55,126.43) ; v4(166.55,126.43) C52456.1 ; v4(166.55,126.43) C52489.1 ; v4(166.55,126.43) C52470.1 166.11,125.82 ; 160.62,135.54 160.26,135.54 v4(160.25,135.53) ; C52481.1 v4(175.65,130.63) C52559.1 ; C52495.1 177.1,127.87 v4(177.06,127.83) C52438.1 ; C52414.1 177.29,135.07 v4(177.06,134.83) ; 165.29,127.34 C52442.1 ; v4(166.55,127.83) C52447.1 ; v4(166.55,127.83) C52462.1 ; C52401.1 172.04,138.84 ; C52497.1 172.7,134.97 ; v5(206.95,75.64) 207.08,75.52 C7566.1 ; v4(175.65,132.03) C52546.1 ; v4(175.65,132.03) C52533.1 ; v4(175.65,132.03) C52560.1 ; 169.48,136.35 C52449.1 ; C52473.1 v4(169.35,129.23) C52423.1 ; C52466.1 v4(177.06,136.26) C52562.1 ; C52563.1 171.82,131.65 v4(171.52,131.35) 171.82,131.05 C52576.1 ; R67002.2 130.97,51.4 v1(130.97,51.79) ; 172.97,135.22 C52527.1 ; C52487.1 167.95,128.56 v4(167.94,128.55) 167.94,128.55 C52408.1 ; C52528.1 v4(167.92,127.12) C52515.1 ; v4(172.85,125.73) 172.91,125.8 172.91,125.86 C52420.1 ; v4(172.85,125.73) C52461.1 ; v4(172.85,125.73) C52433.1 ; v4(160.25,129.26) 160.8,129.26 ; C52494.1 C52574.1 C52561.1 177.22,124.87 v4(177.06,125.03) ; C52494.1 177.2,123.35 ; C52494.1 177.11,123.67 v4(177.06,123.61) ; C52552.1 v4(172.87,128.52) 172.97,128.62 C52474.1 ; v4(172.82,132.04) C52550.1 172.7,132.25 ; v4(177.06,129.23) C52467.1 ; v4(177.06,129.23) C52412.1 ; v4(177.06,129.23) C52509.1 ; C52505.1 170.62,125.55 ; 174.37,129.21 C52405.1 ; v4(169.35,129.93) C52410.1 169.48,129.75 ; 166.7,129.75 C52568.1 ; 175.78,125.08 C52577.1 ; 170.9,138.24 C52415.1 ; 171.56,129.85 C52526.1 ; C52579.1 174.11,132.82 ; C52584.1 175.52,125.28 ; C52566.1 174.11,133.42 ; C52400.1 178.33,127.27 v4(178.47,127.13) ; C52573.1 v4(177.06,131.33) ; v4(177.06,131.33) C52426.1 ; v4(177.06,131.33) C52413.1 ; v4(177.06,134.83) 176.85,135.04 C52493.1 ; 171.56,136.17 C52469.1 ; C52453.1 v4(177.06,129.93) C52496.1 ; 172.97,134.94 C52540.1 ; 164.19,124.6 C52511.1 163.86,124.92 v4(163.75,125.03) ; 169.48,124.35 C52532.1 ; C52444.1 v4(175.69,127.11) C52536.1 ; v4(164.41,122.94) 164.38,122.94 C52616.1 ; v4(178.47,128.54) 178.4,128.47 C52480.1 ; 172.97,137.61 C52472.1 ; v4(166.55,133.43) C52488.1 166.7,133.35 ; C52458.1 v4(177.06,137.63) C52421.1 ; C52443.1 168.32,135.16 v4(167.95,135.53) ; C52499.1 174.02,128.02 v4(174.24,127.8) 174.46,128.01 C52431.1 ; 171.56,129.25 C52539.1 ; v4(167.95,135.53) 167.64,135.22 C52478.1 ; v4(167.95,135.53) 168.17,135.76 C52430.1 ; C52445.1 v4(167.95,130.63) C52555.1 ; 169.48,136.07 C52463.1 ; v4(178.47,130.61) 178.13,130.27 C52439.1 ; C52529.1 v4(166.55,131.33) C52542.1 ; v4(177.06,134.1) 177.29,133.87 C52440.1 ; v4(177.06,134.1) 176.79,133.84 C52521.1 ; v4(177.06,134.1) 176.72,134.44 C52507.1 ; C52403.1 C52524.1 171.56,133.45 ; v4(165.26,132.73) 165.62,132.73 ; v4(167.97,125.03) C52567.1 168.07,124.96 ; 166.7,125.23 C52503.1 ; C52600.1 161.04,132.03 v4(161.03,132.03) v4(160.22,132.03) ; C52490.1 v4(169.35,134.83) C52476.1 ; C52452.1 v4(175.65,136.93) C52424.1 ; C52479.1 v4(175.65,135.53) C52451.1 ; C52565.1 167.03,137.34 ; C52436.1 170.62,128.55 ; C52460.1 169.22,129.6 ; 172.97,127.09 C52406.1 v4(172.9,127.14) ; 172.04,137.04 C52441.1 171.72,136.88 171.55,136.71 ; C52437.1 v4(174.24,136.23) C52500.1 ; C52525.1 162.92,123.54 ; 168.89,124.03 C52580.1 ; 174.37,129.81 C52459.1 ; C52575.1 v4(178.47,135.53) ; C52531.1 170.62,132.75 ; C52538.1 v4(161.65,122.93) ; 176.1,124.48 C52471.1 ; 166.7,136.74 C52578.1 ; C52483.1 172.7,135.25 ; C52553.1 174.11,134.02 ; C52425.1 v4(175.66,128.55) C52418.1 ; C52434.1 v4(178.47,136.93) ; C52544.1 170.62,132.15 ; v4(174.24,137.63) 174.26,137.61 C52411.1 174.7,137.93 ; C52508.1 172.7,130.45 ; C52516.1 167.84,132.15 ; C52516.1 C52502.1 ; C52516.1 v4(167.97,132.02) ; 175.78,133.24 C52534.1 ; C52484.1 164.68,130.21 ; C52583.1 v4(170.7,130.63) C52570.1 ; C52446.1 171.89,126.53 ; C52537.1 172.7,132.85 ; C52510.1 v4(174.24,126.43) C52419.1 ; C52432.1 168.39,131.28 ; v4(160.25,126.43) 160.72,126.43 ; v4(166.56,134.83) C52492.1 166.7,134.62 ; 169.48,131.55 C52557.1 v4(169.35,131.33) ; C52523.1 173.79,130.14 ; C52506.1 167.85,134.02 ; C52548.1 178.2,125.47 v4(178.47,125.74) 178.14,126.07 C52535.1 ; C52422.1 170.62,137.55 ; C52482.1 178.43,132.07 v4(178.47,132.03) ; 166.7,129.15 C52581.1 ; C52454.1 v4(178.47,133.46) ; 171.88,127.72 C52485.1 ; 171.56,136.44 C52455.1 ; 169.48,123.75 C52545.1 ; 170.9,137.64 C52428.1 ; C52547.1 v4(177.06,132.73) C52468.1 ; C52513.1 v4(175.65,125.73) 175.93,126.01 C52564.1 ; v4(160.25,136.93) 160.67,136.93 ; 164.68,128.36 C52512.1 ; C52491.1 169.59,126.15 v4(169.34,126.41) 169.09,126.16 C52541.1 ; 169.48,136.95 C52435.1 ; 166.7,124.95 C52448.1 ; C52519.1 170.62,124.95 ; 174.37,130.41 C52572.1 ; C52407.1 174.11,129.22
  TOP w0.381: 158.12,145.48 C52005.1 ; 155.97,141.7 C52004.1 156.53,141.25 v4(156.9,141.62)
  L5 w0.254: v1(130.97,51.79) 130.41,52.35 130.41,56.53 129.59,57.36 129.59,58.37 130.6,59.39 141.63,59.39 142.34,58.68 154.81,58.68 158.11,61.98 158.11,63.94 v1(158.95,64.77)
  BOTTOM w0.127: v4(172.17,136.98) 172.22,136.93 v4(172.83,136.93) ; U50000.AB13 U50000.AC13 ; v4(161.65,129.23) 162.47,129.23 ; U50000.AT27 162.71,130.99 162.71,131.67 U50000.AT28 U50000.AT29
  BOTTOM w0.152: U50000.AP22 164.13,127.45 164.13,126.81 U50000.AP21 164.13,126.75 164.13,126.11 U50000.AP20
  BOTTOM w0.178: U50000.W39 174.67,139.31 174.67,138.75 U50000.W38 ; 160.28,123.64 161.02,123.64 ; U50000.Y40 U50000.W40 ; U50000.AT15 162.67,122.61 162.67,123.25 U50000.AT16 ; U50000.AA38 173.15,138.63 173.15,138.03 U50000.AA37
  BOTTOM w0.203: U50000.AT26 162.81,130.17 162.81,129.69 U50000.AT25 ; U50000.AH31 168.34,133.74 168.34,133.12 U50000.AH30 ; U50000.AN40 164.83,140.12 165.46,140.12 U50000.AM40
  BOTTOM w0.254: v4(174.24,127.8) 174.38,127.8 ; U50000.AV25 161.19,129.69 161.19,130.17 U50000.AV26 ; U50000.AT30 U50000.AT29 ; U50000.AP15 164.1,122.63 v4(164.41,122.94) 164.41,122.97 U50000.AP16 164.07,123.28 v4(163.77,123.57) ; U50000.BH44 U50000.BH45 ; v4(175.69,127.11) 175.72,127.11 ; U50000.AT26 162.66,130.28 v4(162.33,130.61) 162.7,130.98 U50000.AT27 ; U50000.W28 174.66,131.62 174.66,131.04 U50000.W27 ; 165.76,129.19 165.5,128.93 U50000.AM24 v4(165.15,128.53) 165.15,128.53 U50000.AM23 ; v4(160.25,126.43) U50000.AY21 ; v4(163.75,129.23) U50000.AP25 164.12,129.6 164.12,130.26 U50000.AP26 ; v4(175.65,125.73) 175.84,125.73 ; U50000.AA27 172.88,130.66 v4(172.84,130.66) 172.84,130.64 U50000.AA26 ; U50000.AA27 173.25,131.03 173.25,131.62 U50000.AA28 ; U50000.AA27 173.24,130.98 v4(173.55,130.66) 173.55,130.64 U50000.AA26 ; U50000.AA18 U50000.AA19 v4(172.85,125.73) U50000.AA20 173.3,126.18 173.3,126.68 U50000.AA21 173.2,126.84 v4(172.9,127.14) 173.2,127.44 U50000.AA22 173.3,127.58 173.3,128.08 U50000.AA23 173.2,128.19 v4(172.87,128.52) 172.87,128.55 U50000.AA24 173.3,128.98 173.3,129.48 U50000.AA25 173.26,129.64 173.26,130.22 U50000.AA26 ; U50000.AC16 171.58,123.5 v4(171.53,123.5) ; v4(163.83,136.21) 164.02,136.21 ; v4(175.69,125.09) 175.75,125.09 ; v4(172.83,136.93) 173.04,136.93 ; U50000.R37 177.42,137.98 v4(177.71,138.27) 177.71,138.36 U50000.R38 177.71,138.99 v4(177.71,139.05) ; v4(165.22,138.3) 165.39,138.3 ; v4(172.82,132.04) 173.02,132.04 ; U50000.W27 174.69,130.89 174.69,130.37 U50000.W26 174.24,130.64 v4(174.24,130.69) 174.31,130.69 U50000.W27 ; U50000.AL13 166.17,121.15 165.53,121.15 U50000.AM13 U50000.AN13 U50000.AP13 U50000.AP14 ; v4(170.75,125.75) 170.73,125.75 U50000.AE20 170.31,125.99 170.31,125.47 U50000.AE19 ; v4(162.99,138.31) 162.79,138.31 ; U50000.N31 178.94,133.92 178.94,134.34 U50000.N32 ; v4(170.7,130.63) 170.4,130.93 U50000.AE27 170.33,131.05 170.33,131.61 U50000.AE28 ; U50000.U31 176.08,133.86 176.08,134.4 U50000.U32 176.08,134.56 176.08,135.1 U50000.U33 ; v4(167.95,138.32) 167.95,138.33 U50000.AH38 ; U50000.AH15 168.37,122.65 168.37,123.21 U50000.AH16 ; v4(171.45,133.43) 171.61,133.43 ; U50000.AP34 164.1,135.88 164.23,135.74 164.23,135.31 U50000.AP33 v4(163.75,134.83) U50000.AP32 U50000.AP31 ; U50000.AA30 172.85,132.73 v4(172.83,132.73) ; v4(163.03,122.29) 162.75,122.29 ; U50000.AM14 165.57,121.95 165.57,122.51 U50000.AM15 ; U50000.AC28 171.8,131.62 v4(171.52,131.35) 171.8,131.07 U50000.AC27 ; U50000.AC28 171.86,131.74 171.86,132.32 U50000.AC29 171.87,132.45 171.87,133.01 U50000.AC30 ; U50000.AC28 171.83,131.68 ; v4(161.01,133.42) 161.25,133.42 ; U50000.AE35 v4(170.75,136.23) ; U50000.W35 174.25,136.23 v4(174.24,136.23) 174.59,135.88 U50000.W34 174.66,135.82 174.66,135.24 U50000.W33 ; U50000.BJ44 U50000.BJ45 ; U50000.AP30 164.1,133.02 v4(163.8,132.72) 164.1,132.42 U50000.AP29 U50000.AP28 U50000.AP27 ; U50000.AA13 173.12,121.1 172.58,121.1 U50000.AB13 ; C67001.1 162.94,73.38 162.2,72.65 159.74,72.65 159.1,72.01 159.1,64.93 v1(158.95,64.77) ; U50000.AE18 170.3,124.58 170.3,124.08 U50000.AE17 170.33,123.91 170.33,123.35 U50000.AE16 ; U50000.AF16 169.77,123.21 169.77,122.65 U50000.AF15 ; v4(174.24,129.94) 174.41,129.94 ; U50000.U30 175.66,133.42 v4(175.66,133.43) ; U50000.AA38 173.12,138.76 173.12,139.3 U50000.AA39 ; U50000.AE26 170.31,130.19 170.31,129.67 U50000.AE25 170.31,129.49 170.31,128.97 U50000.AE24 ; U50000.AH14 U50000.AH13 ; v4(170.75,132.03) 170.51,132.03 ; U50000.AK29 166.97,132.31 166.97,131.75 U50000.AK28 ; v4(174.24,126.43) 174.56,126.43 ; U50000.AC24 171.44,129.24 v4(171.44,129.26) 171.48,129.26 U50000.AC25 171.8,129.61 v4(171.44,129.97) 171.75,130.28 U50000.AC26 ; 152.2,144.33 U50000.BL46 ; v4(174.24,134.18) 174.51,134.18 ; v4(171.49,124.33) v4(172.02,124.33) ; v4(170.75,132.73) 170.55,132.73 ; v4(174.24,137.63) 174.25,137.63 U50000.W36 ; U50000.AV23 161.26,128.14 161.26,127.52 U50000.AV22 ; U50000.AY20 159.84,126.02 159.84,125.44 U50000.AY19 159.85,125.33 159.85,124.73 U50000.AY18 159.84,124.62 159.84,124.04 U50000.AY17 ; U50000.U23 176.1,128.28 176.1,128.78 U50000.U24 176.08,128.97 176.08,129.49 U50000.U25 ; v4(163.02,126.37) 162.66,126.37 ; v4(170.72,128.53) 170.46,128.53 ; U50000.AT19 U50000.AT20 ; v4(165.26,132.73) 165.57,132.73 ; v4(176.26,139.04) 176.2,139.04 ; U50000.W20 174.66,125.9 174.66,125.56 U50000.W19 U50000.W18 ; U50000.AH29 168.38,132.47 168.38,132.99 U50000.AH30 ; v4(165.26,131.33) 165.52,131.33 ; v4(174.95,133.46) 174.8,133.3 ; U50000.AV29 161.3,132.3 v4(161.03,132.03) 161.3,131.77 U50000.AV28 U50000.AV27 ; v4(163.06,127.16) 162.79,127.16 ; U50000.N19 178.89,125.29 178.89,124.77 U50000.N18 178.89,124.59 178.89,124.07 U50000.N17 U50000.N16 178.89,123.19 178.89,122.67 U50000.N15 178.89,122.49 178.89,121.97 U50000.N14 ; U50000.BB48 158.4,145.58 158.4,145.08 U50000.BB47 158.57,144.98 158.66,144.89 159.03,144.89 159.12,144.98 U50000.BA47 U50000.BA46 ; U50000.AG29 v4(168.65,132.03) ; v4(164.39,139.02) 163.87,139.02 v4(163.86,139.03) ; v4(175.65,130.63) 175.83,130.63 ; U50000.U20 176.12,126.2 176.12,126.66 U50000.U21 ; v4(169.38,122.21) 169.38,122.19 U50000.AF14 ; v4(165.13,123.62) 165.3,123.62 ; v4(163,139.04) 162.83,139.04 ; v4(172.83,137.63) 173.04,137.63 ; U50000.AE32 170.34,134.42 170.34,133.84 U50000.AE31 170.33,133.71 170.33,133.15 U50000.AE30 ; U50000.W40 174.66,140.02 174.66,139.44 U50000.W39 ; U50000.AP23 164.17,128.25 164.17,128.36 164.21,128.4 164.21,128.77 U50000.AP24 ; U50000.AH24 168.37,128.95 168.37,129.51 U50000.AH25 168.37,129.65 168.37,130.21 U50000.AH26 ; v4(164.39,137.67) 164.33,137.67 ; v4(174.24,129.26) 174.38,129.26 ; U50000.AH34 168.38,135.96 168.38,136.5 U50000.AH35 168.37,136.65 168.37,137.21 U50000.AH36 ; U50000.AC38 171.73,138.61 171.73,138.05 U50000.AC37 ; U50000.AY33 159.83,135.11 159.83,134.55 U50000.AY32 159.85,134.43 159.85,133.83 U50000.AY31 159.85,133.73 159.85,133.13 U50000.AY30 159.83,133.01 159.83,132.45 U50000.AY29 ; v4(165.81,132) 165.53,132 ; v4(165.16,129.93) 165.38,129.93 ; U50000.AE34 v4(170.75,135.53) ; v4(174.24,132.68) 174.53,132.68 ; U50000.AY45 160,143.58 160.07,143.51 160.42,143.51 160.49,143.58 U50000.AW45 160.52,143.51 160.52,143.04 160.59,142.98 160.59,142.89 U50000.AW44 U50000.AV44 ; v4(163.86,138.33) 164.1,138.33 ; U50000.AC20 171.87,126.01 171.87,125.45 U50000.AC19 ; U50000.AU43 U50000.AT42 U50000.AT40 U50000.AR40 163.48,140.16 164.02,140.16 U50000.AP40 164.18,140.16 164.72,140.16 U50000.AN40 ; v4(174.24,133.4) 174.49,133.4 ; U50000.AC23 171.87,128.11 171.87,127.55 U50000.AC22 ; v4(162.38,127.91) 162.63,127.91 ; v4(172.17,136.98) 172.05,136.98 ; U50000.BC49 157.55,146.38 ; v4(178.47,128.54) 178.62,128.54 ; U50000.N24 178.89,128.97 178.89,129.49 U50000.N25 178.89,129.67 178.89,130.19 U50000.N26 ; v4(174.24,138.33) 174.57,138.33 ; v4(165.15,127.13) 165.38,127.13
  BOTTOM w0.381: 148.2,146.07 C52003.1 148.82,145.62 ; 157.28,154.29 C7568.1 ; 156.44,154.25 C52002.1 ; 198.38,81 C7504.2 ; C7505.2 157.69,152.6 ; 195.14,80.86 C7564.1
  vias: v1(180.79,79.61) v1(180.79,79.02) v1(180.79,78.44) v1(180.79,77.8) v1(180.79,77.22) v1(181.37,79.61) v1(181.37,79.02) v1(181.37,78.44) v1(181.37,77.8) v1(181.37,77.22) v1(181.96,79.61) v1(181.96,79.02) v1(181.96,78.44) v1(181.96,77.8) v1(181.96,77.22) v1(182.57,79.61) v1(182.57,79.02) v1(182.57,78.44) v1(182.57,77.8) v1(182.57,77.22) v1(196.51,79.66) v1(196.51,79.07) v1(196.51,78.49) v1(196.51,77.85) v1(196.51,77.27) v1(197.1,79.66) v1(197.1,79.07) v1(197.1,78.49) v1(197.1,77.85) v1(197.1,77.27) v1(197.53,86.64) v1(197.53,83.82) v1(197.56,88.24) v1(197.58,85.07) v1(197.68,79.66) v1(197.68,79.07) v1(197.68,78.49) v1(197.68,77.85) v1(197.68,77.27) v1(198.29,79.66) v1(198.29,79.07) v1(198.29,78.49) v1(198.29,77.85) v1(198.29,77.27) v1(199.89,79.79) v1(201.11,79.79) v1(202.94,79.79) v1(204.16,79.79) v4(151.67,148.32) v4(151.8,146.73) v4(151.84,145.27) v4(152.61,148.9) v4(152.56,147.47) v4(152.58,146.07) v4(153.29,148.14) v4(153.27,146.81) v4(153.28,145.29) v4(153.9,146.03) v4(153.96,148.93) v4(153.96,147.47) v4(154.63,146.75) v4(154.58,144.08) v4(154.66,148.1) v4(154.65,145.38) v4(154.76,149.46) v4(155.34,146.74) v4(155.34,143.23) v4(155.45,148.19) v4(155.37,147.37) v4(155.37,146.02) v4(155.37,145.34) v4(155.37,142.52) v4(155.45,144.55) v4(156.74,144.64) v4(156.8,146.03) v4(157.24,142.46) v4(157.37,143.31) v4(157.5,145.35) v4(157.83,144.34) v4(158,141.21) v4(158.2,142.18) v4(158.56,143.1) v4(158.85,145.33) v4(159.03,141.68) v4(159.31,140.84) v4(159.57,143.19) v4(160.05,141.53) v4(160.15,142.79) v4(160.72,140.67) v4(160.93,141.83) v4(161.61,137.64) v4(161.59,134.13) v4(161.59,132.71) v4(161.65,139.73) v4(161.65,139.03) v4(161.65,127.13) v4(161.65,125.73) v4(161.65,124.33) v4(162.09,141.41) v4(162.43,139.7) v4(162.44,127.11) v4(162.46,128.55) v4(163.01,127.92) v4(163.05,123.63) v4(163.76,127.85) v4(163.79,124.3) v4(163.86,136.94) v4(164.35,127.83) v4(164.34,124.33) v4(165.15,135.53) v4(165.25,130.62) v4(165.15,125.73) v4(165.15,124.33) v4(165.75,125.03) v4(165.76,136.22) v4(165.78,134.83) v4(165.81,133.42) v4(165.82,131.32) v4(165.76,129.92) v4(165.87,139.71) v4(166.55,139.03) v4(166.55,137.63) v4(166.55,136.93) v4(166.62,129.9) v4(166.61,129.24) v4(166.58,125.05) v4(167.95,134.13) v4(167.97,123.65) v4(168.69,138.3) v4(168.67,137.64) v4(168.65,123.63) v4(169.37,139.03) v4(169.35,136.93) v4(169.35,136.23) v4(170.72,125.04) v4(170.72,122.92) v4(171.45,139.83) v4(171.5,136.21) v4(171.45,126.43) v4(171.49,122.93) v4(171.49,122.23) v4(172.02,122.93) v4(172.02,122.23) v4(172.15,139.03) v4(172.83,135.53) v4(172.83,134.83) v4(175.65,138.33) v4(175.73,124.36) v4(175.73,122.94) v4(175.73,122.22) v4(176.27,124.34) v4(176.25,123.63) v4(176.28,122.94) v4(176.27,122.21) v5(150.11,149.13) v5(150.64,149.66) v5(150.75,150.5) v5(151.58,151.24) v5(151.58,150.47) v5(152.32,151.24) v5(152.32,150.47) v5(153.08,151.24) v5(153.08,150.47) v5(153.46,152) v5(153.84,151.24) v5(153.84,150.47) v5(169.36,75.62) v5(170.12,76.48) v5(170.17,75.62) v5(170.88,76.48) v5(170.91,75.62) v5(171.65,76.48) v5(171.7,75.62) v5(172.44,76.48) v5(172.48,75.62) v5(173.17,76.48) v5(173.22,75.62) v5(173.89,77.52) v5(173.99,76.48) v5(174.03,75.62) v5(174.67,78.41) v5(174.65,77.5) v5(174.72,76.48) v5(174.77,75.62) v5(175.43,78.41) v5(175.41,77.5) v5(175.46,76.48) v5(175.51,75.62) v5(176.15,77.5) v5(176.17,78.41) v5(176.2,76.48) v5(176.24,75.62) v5(176.93,78.41) v5(176.88,77.5) v5(176.93,76.48) v5(176.98,75.62) v5(177.72,78.41) v5(177.75,77.5) v5(177.77,76.48) v5(177.77,75.62) v5(178.46,78.41) v5(178.48,77.5) v5(178.51,76.48) v5(178.51,75.62) v5(179.19,78.41) v5(179.22,77.5) v5(179.24,76.48) v5(179.24,75.62) v5(179.93,78.41) v5(179.96,77.5) v5(179.98,76.48) v5(179.98,75.62) v5(180.79,76.48) v5(180.82,75.62) v5(181.61,76.48) v5(181.58,75.62) v5(182.34,76.48) v5(182.39,75.62) v5(183.31,76.51) v5(183.26,75.62) v5(183.36,78.87) v5(183.36,78.13) v5(183.36,77.34) v5(184.04,75.62) v5(184.12,78.9) v5(184.14,78.16) v5(184.12,77.34) v5(184.09,76.51) v5(195.42,76.45) v5(195.42,75.64) v5(195.62,78.71) v5(195.67,79.5) v5(195.65,77.95) v5(195.65,77.22) v5(196.28,76.45) v5(196.26,75.64) v5(197.02,76.45) v5(197,75.64) v5(197.73,75.64) v5(197.76,76.45) v5(198.49,76.45) v5(198.47,75.64) v5(199.31,78.05) v5(199.31,77.26) v5(199.31,76.45) v5(199.31,75.64) v5(199.41,78.82) v5(200.14,78.82) v5(200.12,78.05) v5(200.12,77.26) v5(200.12,76.45) v5(200.12,75.64) v5(200.88,78.82) v5(200.86,78.05) v5(200.86,77.26) v5(200.86,76.45) v5(200.86,75.64) v5(201.62,78.82) v5(201.59,78.05) v5(201.59,77.26) v5(201.59,76.45) v5(201.59,75.64) v5(202.03,79.73) v5(202.33,78.05) v5(202.33,77.26) v5(202.33,76.45) v5(202.33,75.64) v5(202.35,78.82) v5(203.09,78.82) v5(203.07,78.05) v5(203.07,77.26) v5(203.07,76.45) v5(203.07,75.64) v5(203.83,78.82) v5(203.83,78.05) v5(203.83,77.26) v5(203.83,76.45) v5(203.83,75.64) v5(204.56,78.82) v5(204.56,78.05) v5(204.56,77.26) v5(204.56,76.45) v5(204.56,75.64) v5(205.4,77.26) v5(205.4,76.45) v5(205.4,75.64) v5(206.14,77.26) v5(206.14,76.45) v5(206.14,75.64) v5(206.95,77.26) v5(206.95,76.45)
