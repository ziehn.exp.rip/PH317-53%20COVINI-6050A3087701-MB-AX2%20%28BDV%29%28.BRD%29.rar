# Allegro board PH317-53 COVINI-6050A3087701-MB-AX2 (BDV)(.BRD).brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
FBD_WCKB23#: length 33.4
  L8 w0.097: v4(170.77,96.83) 170.77,97.13 170.67,97.23 170.48,97.23 170.38,97.13 170.38,96.7 170.64,96.44 170.93,96.44 171.14,96.64 171.14,100.22 171.13,100.23 170.57,100.79 170.57,110.23 169.57,111.23 169.57,112.16 169.18,112.55 169.11,112.55 168.71,112.94 168.71,114.07 168.95,114.32 168.95,114.72 168.85,114.83 168.85,115.57 168.9,115.61 168.9,116 168.73,116.16 168.09,116.16 167.55,116.7 167.55,117.24 167.55,117.24 167.55,118.87 168.01,119.33 171.62,119.33 v4(172.26,118.69)
  BOTTOM w0.122: v4(172.26,118.69) 172.25,118.69 172.25,118.68 172.11,118.54 172.11,118.25 172.11,118.24 172.11,118.23 172.03,118.15 U50000.AC8 ; U51100.R5 v4(170.77,96.83)
FBD_WCKB45: length 23.4
  L8 w0.097: v4(184.55,97.59) 184.69,97.72 184.69,97.91 184.91,98.14 185.53,98.14 185.82,98.43 185.82,100.31 184.93,101.2 184.93,110.09 184.47,110.55 184.47,111.91 183.28,113.1 183.28,114.46 182.81,114.93 182.81,115.49 183.02,115.7 183.02,116.02 182.78,116.26 182.53,116.26 182.3,116.5 182.3,116.68 v4(182,117.28)
  BOTTOM w0.122: v4(184.55,97.59) U51200.D11 ; v4(182,117.28) U50000.H7
FBD_WCKB45#: length 23.4
  L8 w0.097: v4(185.33,97.55) 185.25,97.47 185.03,97.47 184.91,97.59 184.91,97.82 185.01,97.92 185.63,97.92 186.04,98.34 186.04,100.4 185.15,101.29 185.15,110.18 184.69,110.64 184.69,112 183.5,113.19 183.5,114.56 183.04,115.02 183.04,115.39 183.25,115.6 183.25,116.11 183.04,116.31 183.04,116.7 182.95,116.79 182.81,116.79 182.67,116.65 v4(182.66,116.65)
  BOTTOM w0.122: U50000.H6 182.3,116.28 v4(182.66,116.65) ; v4(185.33,97.55) 185.26,97.55 U51200.D10
FBD_WCKB67: length 43.6
  L8 w0.097: v4(189.05,88.59) 188.75,88.28 188.75,88.24 188.52,88.01 186.24,88.01 186.01,88.24 186.01,88.87 186.24,89.1 187.27,89.1 187.36,89.19 187.36,89.59 187.25,89.7 186.24,89.7 186.01,89.93 186.01,90.51 186.49,90.99 186.49,93.6 186.38,93.71 186.38,94.63 186.15,94.86 185.16,94.86 184.58,94.94 184.43,94.93 184.28,94.89 183.83,94.36 183.7,94.27 183.24,94.05 182.73,93.94 182.17,93.99 182.13,94.01 181.83,94.17 180.9,95.08 180.9,100.53 181.88,101.51 181.88,105.92 180.66,107.13 180.66,111.55 179.71,112.51 179.71,113.56 179.54,113.73 179.54,115.37 179.27,115.64 179.27,116.85 179.3,116.87 179.3,117.23 179.17,117.35 v4(179.15,117.35)
  BOTTOM w0.122: v4(189.05,88.59) U51200.R4 ; U50000.M7 v4(179.15,117.35)
FBD_WCKB67#: length 43.6
  L8 w0.097: v4(188.27,88.61) 188.43,88.61 188.53,88.51 188.53,88.33 188.43,88.24 186.33,88.24 186.23,88.33 186.23,88.78 186.33,88.87 187.36,88.87 187.59,89.1 187.59,89.68 187.34,89.92 186.33,89.92 186.23,90.02 186.23,90.41 186.72,90.9 186.72,93.69 186.61,93.8 186.61,94.72 186.24,95.09 185.17,95.09 184.58,95.16 184.39,95.15 184.15,95.09 183.67,94.53 183.59,94.46 183.17,94.26 182.72,94.17 182.23,94.21 181.97,94.35 181.13,95.17 181.13,100.44 182.1,101.42 182.1,106.01 180.89,107.23 180.89,111.65 179.93,112.6 179.93,113.65 179.76,113.82 179.76,115.47 179.5,115.73 179.5,116.76 179.52,116.78 179.52,117.7 179.21,118.02 v4(179.2,118.02)
  BOTTOM w0.122: v4(179.2,118.02) U50000.M8 ; U51200.R5 188.32,88.61 v4(188.27,88.61)
FBD_ZQ_1_A: length 1.8
  TOP w0.225: R51100.1 178.15,91.7 v4(177.52,92.32)
  BOTTOM w0.3: v4(177.52,92.32) U51100.J14
FBD_ZQ_1_B: length 1.6
  TOP w0.102: v4(177.51,93.09) 177.58,93.09 R51101.1
  BOTTOM w0.3: v4(177.51,93.09) U51100.K14
FBD_ZQ_2_A: length 2.9
  TOP w0.225: v4(181.48,93.14) 181.3,93.32 180.21,93.32 v2(180.16,93.27) 179.95,93.48 R51200.1
  BOTTOM w0.3: U51200.J14 181.81,93.46 v4(181.48,93.14)
FBD_ZQ_2_B: length 3
  TOP w0.225: v4(181.44,92.34) 180.6,92.34 v2(180.1,91.84) 179.95,91.69 R51201.1
  BOTTOM w0.3: v4(181.44,92.34) 181.82,92.71 U51200.K14
FBVDD_EN_OR: length 3.1
  BOTTOM w0.102: U53590.4 122.11,48.65 v2(121.87,48.9) 121.43,48.47 R53591.1 R53590.1
FGC6_FB_EN: length 153.7
  L5 w0.102: v1(243.23,42.98) 242.25,42.98 241.12,44.12 231.07,44.12 228.91,41.96 219.07,41.96 217.78,43.26 215.1,43.26 214.64,42.8 214.48,42.8 214.48,42.8 213.8,42.8 212.91,43.69 211.23,43.69 208,46.92 152.02,46.92 151.1,46 133.36,46 133.33,46.03 127,46.03 v1(126.31,45.34)
  BOTTOM w0.089: v1(243.23,42.98) 243.1,42.98 242.86,43.22 U4710.M45
  BOTTOM w0.102: Q51595.6 126.54,42.89 126.01,43.42 ; 126.01,43.42 R51595.2 v2(124.61,43.42) 110.45,43.42 105.13,48.75 105.13,53.17 105.31,53.35 U53555.2 ; 126.01,43.42 126.44,43.84 126.44,45.22 v1(126.31,45.34)
FGC6_FB_EN#: length 2.6
  BOTTOM w0.102: Q51595.3 Q51595.2 127.43,44.89 127.86,45.32 R51596.1 127.86,46.06 v2(127.72,46.19)
FGC6_OR_NVVDD_PG: length 11.2
  BOTTOM w0.102: U53580.1 121.14,58.95 120.32,59.77 114.96,59.77 v2(114.32,59.13) 114.32,58.29 R53585.2 113,57.58 112.82,57.58 112.82,57.58 U53585.4
G_OVERT#: length 18.6
  L8 w0.102: v4(154.67,115.91) 155.01,116.26 155.01,117.8 155.08,117.86 155.08,118.38 153.36,120.09 150.51,120.09 v1(146.69,123.91)
  BOTTOM w0.102: v1(146.69,123.91) 147.01,123.59 Q51510.S 146.02,123.14 v2(144.71,121.83) 144.3,121.42 R51510.1 ; v4(154.67,115.91) U50000.BG5
GC6_FB_EN#: length 2.6
  TOP w0.102: Q51592.3 Q51592.2 153.29,88.47 v2(153.04,88.71) 152.94,88.82 R51593.1
GC6_FB_EN_PCH: length 228.8
  TOP w0.102: v1(233.7,38.81) 235.83,38.81 239.83,34.81 R4922.1 ; Q51592.6 155.31,88.97 154.85,88.51 R51592.2 154.27,86.32 151.28,86.32 149.4,88.19 v1(146.76,88.19)
  L5 w0.102: v1(130.65,43.44) 133.94,43.44 134.07,43.31 141.69,43.31 142.12,42.88 146.52,42.88 146.86,43.22 167.08,43.22 167.17,43.31 184.21,43.31 185.72,41.8 187.42,41.8 187.74,42.12 189.68,42.12 190.57,41.23 200.22,41.23 202.36,39.09 203.07,39.09 203.22,38.94 208.38,38.94 208.55,39.12 208.89,39.12 209.12,38.89 227.25,38.89 227.58,39.22 233.29,39.22 v1(233.7,38.81)
  L8 w0.102: v1(130.65,43.44) 131.21,43.99 131.21,45.62 130.93,45.89 130.93,47.13 132.11,48.31 132.11,50.74 135.07,53.7 143.26,53.7 146.46,56.9 146.46,64.4 146.46,64.58 147.08,65.19 147.08,71.31 147.08,71.49 147.58,72 147.58,73.91 147.16,74.32 147.16,87.79 v1(146.76,88.19)
  BOTTOM w0.102: U53590.2 TP53590.1 127.7,48.05 127.7,46.9 128.99,45.61 128.99,44.47 129.75,43.7 130.39,43.7 v1(130.65,43.44) 130.65,43.03 128.85,41.23 112.36,41.23 104.92,48.66 104.92,53.46 105.46,54 U53555.1
GC6_FB_EN_PCH1: length 11.8
  TOP w0.102: R4922.2 241.08,33.99 241.11,34.01 v2(241.53,34.01) 241.86,34.01 v1(242.13,34.29)
  L10 w0.102: v1(242.13,34.29) 242.67,34.83 242.67,36.27 245.44,39.03 v1(245.44,41.33)
  BOTTOM w0.089: v1(245.44,41.33) 245.44,41.65 245.22,41.87 245.22,42.49 U4710.T46
GPD7: length 6.9
  BOTTOM w0.089: 262.51,45.24 260.78,45.24 260.41,45.6 259.86,45.6 259.75,45.71 259.35,45.71 U4710.BE41
  BOTTOM w0.102: R4793.1 265.33,45.72 v2(264.54,45.72) 264.44,45.83 263.09,45.83 262.51,45.24
GPIO0_GPU_VID: length 24.3
  TOP w0.102: v4(156.79,116.59) 156.47,116.28 156.47,115.75 156.49,115.72 156.49,114.32 152.59,110.41 152.59,96.32 152.37,96.11 v2(152.37,95.46) 152.37,95.45 R51579.1
  BOTTOM w0.102: v4(156.79,116.59) U50000.BD6
GPIO1_GC6_FB_EN: length 33.2
  TOP w0.102: Q51592.5 155.88,88.47 156.13,88.73 156.13,90.22 156.91,91.01 R51570.1 TP53930.1 158.54,93.39 158.54,96.4 158.54,96.57 159.13,97.16 159.87,97.16 162.16,99.45 162.16,103.76 158.07,107.86 v4(158.07,115.9)
  BOTTOM w0.102: v4(158.07,115.9) 158.42,115.64 U50000.BB5
GPIO2_DGPU_EVENT#: length 14
  BOTTOM w0.102: U50000.BD1 157.1,110.62 156.75,110.27 R51545.1 156.75,108.67 v2(156.89,108.52) 156.89,108.52 156.89,107.52 151.62,102.25 151.32,102.25 150.8,101.73 Q51545.S
GPIO4_1V8_MAIN_EN: length 18.9
  BOTTOM w0.102: U50000.BE1 156.4,111.61 155.41,110.62 154.75,110.62 153.82,109.69 153.82,108.35 154,108.18 154.53,108.18 154.83,107.88 R51566.1 155.09,107.42 v2(155.09,106.81) 155.09,106.31 153.1,104.32 151.15,104.32 150.89,104.05 150.89,102.94 150.14,102.19 150.14,101.3 149.96,101.12 149.13,101.12 148.92,101.33 R53512.1
GPIO5_FRM_LCK#: length 9.6
  BOTTOM w0.102: R51567.1 152.34,105.89 v2(152.47,106.02) 152.7,106.25 152.7,110.04 155.3,112.64 155.3,113.04 155,113.34 U50000.BG2
GPIO6_NVVDD_PSI#: length 11.7
  BOTTOM w0.102: R51584.1 162.79,104.9 159.31,108.39 v2(158.15,108.39) 158.14,108.4 158.14,109.55 157.4,110.29 157.4,113.17 U50000.BD2
GPIO7_LCD_BL_PWM: length 27.6
  TOP w0.102: v4(156.79,117.29) 155.61,118.47 154.48,118.47 153.82,117.81 152.48,117.81 149.57,114.9 149.57,110.43 150.02,109.98 150.02,104.48 147.19,101.65 147.19,100.13 v2(147.39,99.93) 147.6,99.72 R51571.1
  BOTTOM w0.102: v4(156.79,117.29) U50000.BD7
GPIO8_FBVDD_SEL: length 26
  TOP w0.102: R51580.1 159.36,94.42 v2(159.36,94.9) v1(159.36,96.42)
  L8 w0.102: v4(153.97,115.21) 154.81,114.37 154.81,113.1 154.64,112.94 154.64,110.35 156.56,108.44 156.56,104.92 155.13,103.48 155.13,99.51 158.22,96.42 v1(159.36,96.42)
  BOTTOM w0.102: v4(153.97,115.21) U50000.BH4
GPIO9_GPU_THERMAL_ALERT#: length 9.7
  BOTTOM w0.102: R51540.1 150.64,106.63 150.62,106.66 v2(150.62,106.68) 150.62,109.77 151.59,110.75 151.82,110.75 153.29,112.23 153.29,113.87 U50000.BJ3
GPIO10_MEM_VREF_CTL: length 6.6
  BOTTOM w0.102: U50000.BD3 156.79,113.87 156.79,111.36 155.47,110.04 v2(155.47,109.5) R51572.1
GPIO11_LCD_VDD_EN: length 25.8
  TOP w0.102: R51573.1 148.93,91.82 148.93,92.98 v2(149.53,93.58) 149.53,93.84 152.18,96.49 152.18,110.58 153.59,111.99 153.59,114.07 v4(154,114.48)
  BOTTOM w0.109: v4(154,114.48) U50000.BH3
GPIO12_DGPU_PWRLEVEL: length 29.4
  L8 w0.102: v4(156.07,115.97) 155.77,115.67 155.77,115.09 155.79,115.07 155.79,113.8 154.85,112.85 154.85,110.51 156.77,108.59 156.77,104.83 155.33,103.4 155.33,99.8 157.95,97.18 159.46,97.18 160.45,96.19 v3(160.45,95.58)
  BOTTOM w0.102: v4(156.07,115.97) 156.38,116.28 U50000.BE6 ; R51550.1 160.16,94.82 160.45,95.1 v3(160.45,95.58) 160.49,95.62 Q51550.S
GPIO14_IFPA_HPD: length 7.1
  BOTTOM w0.102: R51560.1 151.3,109.52 151.97,110.19 152.14,110.19 154.64,112.69 154.64,114.53 U50000.BG4
GPIO15_IFPB_HPD: length 4.5
  BOTTOM w0.102: U50000.BG1 155,112.66 152.19,109.85 R51561.1
GPIO17_IFPD_HPD: length 7.8
  BOTTOM w0.102: U50000.BH1 152.06,110.54 151.68,110.54 150.85,109.72 150.85,108.26 v2(151.41,107.7) 151.41,107.69 R51563.1
GPIO18_IFPE_HDMI_HPD: length 175
  TOP w0.102: v3(288.36,64.88) 288.83,65.35 Q56470.3
  L8 w0.102: v1(155.9,111.64) 157.4,110.14 157.4,108.26 161.67,103.99 161.67,95.93 160.42,94.68 160.42,93.72 161.11,93.04 161.11,91.72 160.3,90.9 160.3,89.27 159.89,88.86 159.89,87.71 160.4,87.2 160.8,87.2 166.44,81.56 213.33,81.56 214.53,82.76 216.78,82.76 217.01,82.99 233.32,82.99 234.36,81.94 235.3,81.94 236.57,80.67 239.65,80.67 240.15,80.17 261.22,80.17 270.18,71.21 270.18,70.18 273.99,66.37 286,66.37 287.5,64.88 v3(288.36,64.88)
  BOTTOM w0.102: U50000.BE3 156.4,114 156.07,113.68 156.07,113.37 155.95,113.25 155.95,111.69 v1(155.9,111.64) 155.28,111.64 153.36,109.71 R51564.1
GPIO20_FL_SYNC_GPU_FGC6: length 105.8
  TOP w0.102: R51574.1 150.88,93.86 v1(150.88,94.57) 150.88,94.91 152.38,96.41 152.38,110.5 156.11,114.22 v4(156.11,115.23)
  L8 w0.102: v1(129.1,42.93) 129.51,42.52 145.07,42.52 146.15,43.61 148.71,43.61 149.85,44.74 149.85,45.33 148.89,46.28 148.89,48.29 152.47,51.87 152.47,59.12 152.47,59.54 155.07,62.14 155.07,74.23 153.97,75.33 153.97,75.5 153.97,75.5 153.97,87.74 151.61,90.1 151.61,92.1 150.88,92.83 v1(150.88,94.57)
  BOTTOM w0.102: v4(156.11,115.23) 156.11,115.29 U50000.BE5 ; v1(129.1,42.93) 129.1,42.75 128.22,41.86 v2(127.43,41.86) Q51595.5
GPIO20_OR_FGC6: length 14.9
  BOTTOM w0.102: U53585.1 109.31,56.27 v2(108.65,56.93) 107.58,58 103.31,58 102.49,57.18 102.49,55.84 R53551.2 102.26,54.6 102.26,53.53 R53555.2 103.09,52.7 U53555.4
GPIO21_GPU: length 27.4
  TOP w0.102: R51575.1 161.59,91.42 v2(162.15,91.98) 162.15,93.7 162.98,94.53 162.98,104.1 159.36,107.72 159.36,115.68 v4(159.56,115.88)
  BOTTOM w0.135: U50000.BA5 159.26,115.58 v4(159.56,115.88)
GPIO22_GPU: length 29.1
  TOP w0.102: R51568.1 162.51,91.47 162.81,91.77 v2(162.81,93.63) 163.18,94 163.18,104.18 160.49,106.87 160.49,113.48 160.5,113.49 160.5,115.48 159.72,116.26 158.49,116.26 v4(158.11,116.64)
  BOTTOM w0.135: U50000.BB6 158.42,116.36 v4(158.11,116.64)
GPIO23_GPU: length 9.1
  BOTTOM w0.102: R51576.1 153.24,107.31 v2(153.18,107.37) 152.9,107.65 152.9,109.96 155.51,112.56 155.51,113.15 155.34,113.32 155.34,113.61 155,113.96 U50000.BG3
GPIO24_IFPF_HPD: length 23.5
  TOP w0.102: v4(156.85,115.9) 156.85,114.39 152.79,110.33 152.79,97.12 v2(153.16,96.75) 153.16,94.62 R51565.1
  BOTTOM w0.121: v4(156.85,115.9) 156.87,115.88 156.87,115.81 U50000.BD5
GPIO25_FBVDD_PSI#: length 10.4
  BOTTOM w0.102: U50000.BB2 158.5,113.27 158.19,112.96 158.19,110.11 v2(158.82,109.48) 161.64,106.66 R51582.1
GPIO26_FP_FUSE: length 35.7
  TOP w0.102: v3(158.98,89.21) 158.98,88.02 R52101.2
  L8 w0.102: v3(158.98,89.21) 158.98,89.87 160.91,91.8 160.91,92.95 160.22,93.64 160.22,94.77 161.26,95.81 161.26,103.91 156.97,108.21 156.97,108.67 155.05,110.59 155.05,112.77 156.45,114.17 156.45,116.23 v4(156.05,116.63)
  BOTTOM w0.102: UU52100.C2 159.29,87.81 159.29,87.81 158.98,88.13 v3(158.98,89.21)
  BOTTOM w0.121: U50000.BE7 v4(156.05,116.63)
GPIO27_IFPC_DP_HPD: length 153.9
  TOP w0.102: v1(157.78,88.29) 158.49,89.01 158.49,89.94 v2(158.18,90.26) 158.09,90.35 R51562.1 158.09,92.16 158.75,92.82 158.75,96.49 159.21,96.96 159.96,96.96 162.37,99.37 162.37,103.84 158.27,107.94 158.27,114.59 v4(158.87,115.19)
  L8 w0.102: v1(157.78,88.29) 158.87,88.29 160.17,87 160.6,87 166.7,80.9 213.15,80.9 214.6,82.35 216.66,82.35 216.91,82.6 233.3,82.6 234.26,81.64 235.12,81.64 236.34,80.42 239.52,80.42 239.98,79.96 261.13,79.96 269.52,71.58 v1(269.52,70.97)
  BOTTOM w0.102: U50000.BA4 158.89,115.19 v4(158.87,115.19) ; v1(269.52,70.97) 270.12,70.37 Q56260.3
GPIO28_ADC_MUX_SEL: length 75
  TOP w0.102: v4(158.87,114.51) 158.48,114.11 158.48,108.02 162.57,103.93 162.57,94.89 160.27,92.59 v3(160.27,92.11) 159.79,91.63 R51569.1
  L8 w0.102: v1(152.73,50.14) 153.54,50.96 153.54,59.46 155.88,61.8 155.88,75.16 155.37,75.67 155.37,84.23 157.07,85.93 157.07,88.65 160.27,91.85 v3(160.27,92.11)
  BOTTOM w0.102: v4(158.87,114.51) U50000.BB4 ; v1(152.73,50.14) R52003.2
GPIO29_IDLE_IN_SW: length 25.6
  TOP w0.102: v4(158.86,113.84) 158.86,107.93 162.77,104.01 162.77,94.68 161.39,93.3 v2(161.39,93.02) 161.03,92.66 161.03,91.49 R51577.1
  BOTTOM w0.117: v4(158.86,113.84) U50000.BA3
GPP_A7: length 9.8
  TOP w0.102: R4813.1 265.07,47.17 v2(264.46,47.17) 264.39,47.1 261.57,47.1 261.19,46.71 260.42,46.71 258.97,48.16 257.63,48.16 v1(257.45,48.34)
  BOTTOM w0.089: v1(257.45,48.34) 257.27,48.16 257.21,48.16 U4710.BA36
GPP_B22: length 1.8
  TOP w0.102: v3(257.43,52.05) 257.43,52.13 R4826.2
  BOTTOM w0.089: U4710.BA26 257.3,52.28 257.3,52.18 v3(257.43,52.05)
GPP_F3: length 4
  BOTTOM w0.102: U4710.AM47 253.23,42.1 253.23,41.7 253.06,41.53 253.06,41.38 253.06,41.23 251.79,39.96 TP4704.1
GPP_F14: length 21.4
  TOP w0.102: R4779.1 269.36,49.46 v3(269.52,49.61) 269.64,49.48 R4787.2
  L8 w0.102: v3(269.52,49.61) 267.79,47.88 267.79,46.8 267.37,46.38 266.14,46.38 265.43,45.67 260.45,45.67 259.95,46.17 253.99,46.17 v1(253.23,45.42)
  BOTTOM w0.089: v1(253.23,45.42) 253.38,45.27 U4710.AP41
GPP_H19: length 6.6
  BOTTOM w0.089: U4710.AH46 250.48,42.67 250.48,41.76 250.25,41.53 250.25,41.19 250.46,40.98 250.46,39.09
  BOTTOM w0.102: R4811.1 250.38,37.82 250.69,38.13 250.69,38.85 v2(250.46,39.09) 250.46,39.09
GPP_H20: length 6.3
  BOTTOM w0.089: 249.19,39.09 249.19,39.67 250.01,40.49 250.01,41.58 250.3,41.87 250.3,43.17 U4710.AG45
  BOTTOM w0.102: 249.19,39.09 249.19,38.79 v2(249.2,38.79) 249.2,37.95 R4818.1
GPPJ_RCOMP: length 1.6
  TOP w0.254: R4607.1 260.35,64.97 v2(259.93,64.97) 259.53,65.37 v1(259.53,65.5)
GPU_DP_AUX: length 14.5
  TOP w0.091: C51631.2 301.97,54.11 Q51650.2 302.7,54.19 302.99,53.9 302.99,53.49 R51650.2 302.72,52.82 302.61,52.71 300.64,52.71 300.53,52.6 300.53,51.48 301.21,50.8 301.36,50.8 301.54,50.99 D56230.1 D56230.10 303.48,50.99 303.67,50.8 304.1,50.8 304.52,50.39 304.65,50.39 v1(304.85,50.58)
  BOTTOM w0.091: v1(304.85,50.58) 305.08,50.35 306.02,50.35 306.22,50.55 CN56200.16
GPU_DP_AUX#: length 14.4
  TOP w0.091: R51630.1 298.74,53.21 ; 298.74,53.21 298.74,52.84 298.85,52.73 300.22,52.73 300.34,52.62 300.34,51.4 301.13,50.61 301.42,50.61 301.54,50.49 D56230.2 D56230.9 303.48,50.49 303.6,50.61 304.02,50.61 304.44,50.19 304.57,50.19 v3(304.85,49.92) ; 298.74,53.21 298.74,53.43 Q51630.2 298.61,54.19 299.5,53.31 C51630.2
  BOTTOM w0.091: v3(304.85,49.92) 305.08,50.15 306.02,50.15 306.22,49.95 CN56200.18
GPU_EN: length 137.7
  TOP w0.102: U67000.36 134.05,51.9 134.14,51.81 134.14,51.46 v1(134.85,50.75)
  L5 w0.102: v1(148.94,77.22) 149.08,77.08 150.81,77.08 155.11,72.77 210.49,72.77 213.76,76.05 213.76,81.59 213.36,81.99 209.95,81.99 v1(203.96,87.99)
  L8 w0.102: v1(148.94,77.22) 148.94,60.9 148.87,60.83 147.04,59 147.04,56.87 143.44,53.27 137.36,53.27 v1(134.85,50.75)
  BOTTOM w0.102: TP67001.1 203.96,88.56 v1(203.96,87.99) 204.4,87.55 R55211.1 ; v1(134.85,50.75) 134.29,51.31 126.92,51.31 TP53572.1 125.99,52.24 C53572.2 124.53,52.24 124.53,52.24 R53571.2 124.04,52.28 D53571.1
GPU_EVENT_PCH#: length 172.5
  TOP w0.102: v1(231.06,41.94) 231.06,41.48 232.74,39.81 235.12,39.81 240.03,34.9 242.1,34.9 242.8,34.2 R4921.1
  L5 w0.102: v1(153.06,45.16) 153.06,44.96 154.59,43.42 166.99,43.42 167.12,43.55 184.26,43.55 185.81,42 186.93,42 187.25,42.32 189.76,42.32 190.65,41.43 202.26,41.43 202.84,40.85 229.97,40.85 v1(231.06,41.94)
  L8 w0.102: v1(153.06,45.16) 153.06,48.16 155.75,50.85 155.75,59.88 156.87,61 156.87,74.78 155.67,75.97 155.67,84.25 157.27,85.85 157.27,88.46 160.7,91.88 160.7,92.87 160.02,93.56 160.02,93.86 154.92,98.95 154.92,103.56 155.39,104.03 155.39,106.33 156.13,107.06 v1(156.13,107.52)
  BOTTOM w0.102: Q51545.D 152.75,103.68 156.13,107.07 v1(156.13,107.52) 156.13,107.62 TP51545.1
GPU_FB_VREF: length 4.2
  TOP w0.102: v4(178.5,143.19) 178.81,142.88 179.36,142.88 179.6,142.65 179.6,142.6 179.63,142.57 TP52200.1 179.63,142.07 179.5,141.94 R52200.1 C52200.1
  BOTTOM w0.254: v4(178.5,143.19) 178.49,143.19 U50000.P45
GPU_GND_SENSE: length 111.9
  TOP w0.203: v1(125.5,59.35) 125.63,59.22 125.63,51.75 127.54,49.84 128.88,49.84 R67001.2
  L8 w0.203: v1(138.05,143.49) 138.05,130.49 138.43,130.11 138.43,124.62 138.82,124.23 139.04,124.01 139.04,120.07 136.66,117.69 136.42,117.45 136.42,111.83 137.33,110.91 137.33,73.7 134.72,71.09 134.72,70.76 134.72,70.76 134.72,67.07 134.42,66.76 134.42,63.66 131.24,60.48 126.63,60.48 v1(125.5,59.35)
  BOTTOM w0.203: R52111.2 143.21,144.94 140.38,144.94 138.93,143.49 v1(138.05,143.49)
GPU_HDMI_CLKN: length 188.2
  TOP w0.076: C51700.1 282.44,71.82 282.02,71.82 v1(281.81,71.61)
  L10 w0.074: v4(154.69,121.53) 154.53,121.36 153.92,121.36 153.59,121.03 151.32,121.03 149.78,119.49 149.78,111.27 151.1,109.95 155.95,109.95 163.32,102.58 163.32,87.95 165.22,86.04 165.23,86.04 165.46,85.82 165.46,85.8 165.64,85.63 165.64,84 167.25,82.38 212.97,82.38 214.11,83.52 232.62,83.52 233.33,82.81 233.81,82.81 234.47,82.15 234.92,82.15 236.8,80.27 240.5,80.27 243.15,77.62 247.5,77.62 250,75.12 251.12,75.12 252.24,73.99 271.73,73.99 273.07,72.65 274.83,72.65 274.91,72.58 274.91,71 275.14,70.77 275.6,70.77 275.84,71 275.84,72.58 275.91,72.65 276.14,72.65 276.22,72.58 276.22,71 276.45,70.77 276.92,70.77 277.15,71 277.15,72.58 277.22,72.65 277.46,72.65 277.53,72.58 277.53,71 277.77,70.77 278.23,70.77 278.46,71 278.46,72.58 278.54,72.65 278.77,72.65 278.84,72.58 278.84,71 279.08,70.77 279.54,70.77 279.77,71 279.77,72.58 279.85,72.65 280.27,72.65 281.1,71.82 281.59,71.82 v1(281.81,71.61)
  BOTTOM w0.076: U50000.BG14 v4(154.69,121.53)
GPU_HDMI_CLKP: length 188.1
  TOP w0.076: v3(281.81,72.27) 282.09,71.99 282.35,71.99 C51701.1
  L10 w0.074: v4(154.63,120.83) 154.63,120.96 154.5,121.09 154.03,121.09 153.7,120.76 151.43,120.76 150.05,119.38 150.05,111.39 151.22,110.22 156.07,110.22 163.59,102.7 163.59,88.07 165.34,86.32 165.35,86.32 165.74,85.93 165.74,85.92 165.91,85.75 165.91,85.52 165.91,85.52 165.91,84.11 167.36,82.66 212.85,82.66 213.99,83.8 232.73,83.8 233.44,83.09 233.93,83.09 234.58,82.43 235.03,82.43 236.91,80.55 240.62,80.55 243.27,77.9 247.61,77.9 250.12,75.39 251.24,75.39 252.36,74.27 271.84,74.27 273.19,72.93 274.95,72.93 275.18,72.69 275.18,71.12 275.26,71.04 275.49,71.04 275.56,71.12 275.56,72.69 275.8,72.93 276.26,72.93 276.5,72.69 276.5,71.12 276.57,71.04 276.8,71.04 276.87,71.12 276.87,72.69 277.11,72.93 277.57,72.93 277.81,72.69 277.81,71.12 277.88,71.04 278.11,71.04 278.18,71.12 278.18,72.69 278.42,72.93 278.88,72.93 279.12,72.69 279.12,71.12 279.19,71.04 279.42,71.04 279.5,71.12 279.5,72.69 279.73,72.93 280.39,72.93 281.21,72.1 281.64,72.1 v3(281.81,72.27)
  BOTTOM w0.076: U50000.BH14 154.3,121.42 154.63,121.09 v4(154.63,120.83)
GPU_HDMI_D0N: length 189.2
  TOP w0.076: C51702.1 282.47,73.59 281.99,73.59 v1(281.8,73.41)
  L10 w0.074: v4(155.32,122.23) 155.53,122.02 155.53,121.78 155.65,121.66 155.65,121 154.82,120.16 151.52,120.16 150.49,119.14 150.49,111.52 151.11,110.9 155.93,110.9 164.12,102.71 164.12,88.08 165.5,86.7 165.51,86.7 166.12,86.09 166.12,86.08 166.29,85.9 166.29,85.36 166.29,84.27 167.52,83.04 212.7,83.04 213.84,84.18 232.89,84.18 233.6,83.47 234.08,83.47 234.74,82.81 235.19,82.81 237.07,80.93 240.88,80.93 241.41,80.4 246.37,80.4 251,75.77 271.79,75.77 274,73.56 275.92,73.56 276.15,73.8 276.15,75.55 276.23,75.62 276.46,75.62 276.53,75.55 276.53,73.8 276.77,73.56 277.23,73.56 277.46,73.8 277.46,75.55 277.54,75.62 277.77,75.62 277.84,75.55 277.84,73.8 278.08,73.56 278.54,73.56 278.77,73.8 278.77,75.55 278.85,75.62 279.08,75.62 279.15,75.55 279.15,73.8 279.39,73.56 279.85,73.56 280.09,73.8 280.09,75.55 280.16,75.62 280.39,75.62 280.46,75.55 280.46,73.8 280.7,73.56 281.65,73.56 v1(281.8,73.41)
  BOTTOM w0.076: U50000.BF14 v4(155.32,122.23)
GPU_HDMI_D0P: length 189.1
  TOP w0.076: v3(281.8,74.07) 281.8,74.02 282.06,73.77 282.5,73.77 282.75,74.02 C51703.1
  L10 w0.074: v3(281.8,74.07) 281.58,73.84 280.81,73.84 280.74,73.92 280.74,75.66 280.51,75.9 280.04,75.9 279.81,75.66 279.81,73.92 279.74,73.84 279.5,73.84 279.43,73.92 279.43,75.66 279.19,75.9 278.73,75.9 278.5,75.66 278.5,73.92 278.42,73.84 278.19,73.84 278.12,73.92 278.12,75.66 277.88,75.9 277.42,75.9 277.19,75.66 277.19,73.92 277.11,73.84 276.88,73.84 276.81,73.92 276.81,75.66 276.57,75.9 276.11,75.9 275.88,75.66 275.88,73.92 275.8,73.84 274.11,73.84 271.91,76.05 251.11,76.05 246.49,80.67 241.53,80.67 241,81.2 237.18,81.2 235.3,83.09 234.86,83.09 234.2,83.74 233.72,83.74 233,84.46 213.72,84.46 212.58,83.32 167.64,83.32 166.57,84.38 166.57,85.25 166.57,86.02 166.4,86.19 166.4,86.2 165.62,86.98 165.61,86.98 164.39,88.19 164.39,102.82 156.04,111.18 151.23,111.18 150.77,111.63 150.77,119.03 151.63,119.89 154.93,119.89 155.93,120.88 155.93,121.77 155.81,121.89 155.81,122.02 v4(156.02,122.23)
  BOTTOM w0.076: v4(156.02,122.23) 156.02,122.06 156.19,121.88 U50000.BE14
GPU_HDMI_D1N: length 189.5
  TOP w0.076: v3(281.85,76.8) 282.09,77.04 282.78,77.04 C51704.1
  L10 w0.074: v3(281.85,76.8) 282.04,76.99 282.42,76.99 283.16,76.25 283.16,71.23 282.26,70.33 273.99,70.33 270.79,73.53 252.17,73.53 250.97,74.73 249.78,74.73 247.98,76.53 242.32,76.53 242.04,76.24 239.72,76.24 239.05,75.57 236.98,75.57 236.65,75.9 236.65,79.89 234.76,81.78 234.31,81.78 233.65,82.43 233.08,82.43 232.37,83.15 214.27,83.15 213.13,82 167.09,82 165.26,83.84 165.26,84.91 162.94,87.23 162.94,102.43 157.16,108.21 154.96,108.21 153.69,109.48 150.72,109.48 149.4,110.8 149.4,119.69 151.69,121.97 154.33,121.97 155.23,122.88 v4(155.4,122.88)
  BOTTOM w0.076: v4(155.4,122.88) 155.56,122.88 155.7,122.74 U50000.BF15
GPU_HDMI_D1P: length 189.4
  TOP w0.076: v1(282.37,77.44) 282.59,77.21 282.77,77.21 C51705.1
  L10 w0.074: v1(282.37,77.44) 283.44,76.37 283.44,71.11 282.38,70.06 273.87,70.06 270.67,73.26 252.05,73.26 250.86,74.45 249.67,74.45 247.86,76.25 242.44,76.25 242.15,75.97 239.84,75.97 239.16,75.29 236.86,75.29 236.37,75.78 236.37,79.77 234.64,81.5 234.2,81.5 233.54,82.16 232.97,82.16 232.26,82.87 214.38,82.87 213.24,81.73 166.98,81.73 164.98,83.73 164.98,84.8 162.66,87.12 162.66,102.31 157.04,107.93 154.85,107.93 153.58,109.2 150.61,109.2 149.12,110.68 149.12,119.8 151.57,122.25 154.21,122.25 154.7,122.74 v4(154.7,122.88)
  BOTTOM w0.076: v4(154.7,122.88) U50000.BG15
GPU_HDMI_D2N: length 196.5
  TOP w0.076: v3(281.97,78.56) 282.24,78.83 282.77,78.83 C51706.1
  L10 w0.074: v3(281.97,78.56) 282.12,78.71 282.43,78.71 284.22,76.91 284.22,70.3 282.43,68.51 276.97,68.51 276.59,68.89 269.43,68.89 267.02,71.29 252.95,71.29 251.56,72.68 250.66,72.68 247.47,75.88 242.86,75.88 242.58,75.59 240,75.59 239.32,74.91 236.71,74.91 235.93,75.69 235.93,79.67 234.49,81.12 234.04,81.12 233.38,81.78 232.81,81.78 232.1,82.49 214.54,82.49 213.4,81.35 166.82,81.35 164.6,83.57 164.6,84.64 162.28,86.96 162.28,102.16 157.77,106.67 152.6,106.67 148.74,110.53 148.74,120.28 151.76,123.3 154.09,123.3 154.47,123.68 154.61,123.68 v4(154.66,123.63)
  BOTTOM w0.076: U50000.BG17 155,124.1 154.89,124.21 154.73,124.21 154.63,124.11 154.63,123.65 v4(154.66,123.63)
GPU_HDMI_D2P: length 196.6
  TOP w0.076: C51707.1 282.78,79 282.33,79 v1(282.12,79.21)
  L10 w0.074: v1(282.12,79.21) 282.34,78.99 282.54,78.99 284.5,77.03 284.5,70.18 282.55,68.23 276.85,68.23 276.47,68.61 269.31,68.61 266.91,71.01 252.84,71.01 251.44,72.41 250.55,72.41 247.35,75.6 242.98,75.6 242.69,75.31 240.11,75.31 239.44,74.64 236.59,74.64 235.66,75.57 235.66,79.56 234.37,80.84 233.93,80.84 233.62,81.15 233.27,81.5 232.7,81.5 231.99,82.21 214.65,82.21 213.51,81.07 166.71,81.07 164.32,83.45 164.32,84.53 162.01,86.84 162.01,102.04 157.65,106.4 152.48,106.4 148.47,110.41 148.47,120.39 151.65,123.57 153.87,123.57 v4(153.97,123.68)
  BOTTOM w0.076: v4(153.97,123.68) 154.28,123.98 U50000.BH17
GPU_HDMI_SCL: length 10.5
  BOTTOM w0.102: 148.74,115.9 150.82,117.98 152.59,117.98 U50000.BK8
  BOTTOM w0.109: 148.74,115.9 148.74,112.02 v2(148.28,111.56) 148.21,111.48 R51712.1
GPU_HDMI_SDA: length 10.6
  BOTTOM w0.102: 149.07,115.57 150.82,117.33 151.85,117.33 U50000.BL8
  BOTTOM w0.109: R51711.1 147.77,110.44 v2(147.86,110.35) 147.95,110.35 149.07,111.47 149.07,115.57
GPU_ID: length 4.4
  BOTTOM w0.102: R343.1 202.89,43.8 R338.2 202.89,43.28 v2(202.64,43.02) 202.64,42.47 203.49,41.62 U1.73
GPU_NVVDD_SENSE: length 110.8
  TOP w0.203: R67000.2 128.86,50.24 127.71,50.24 126.06,51.9 126.06,59.23 v3(126.16,59.33)
  L8 w0.203: v3(126.16,59.33) 126.9,60.07 131.41,60.07 134.83,63.5 134.83,66.59 135.13,66.9 135.13,70.93 137.74,73.54 137.74,111.08 136.83,111.99 136.83,117.28 139.44,119.9 139.44,124.18 138.83,124.78 138.83,130.28 138.45,130.66 138.45,143.13 138.73,143.41 v1(138.73,143.97)
  BOTTOM w0.203: R52110.2 143.41,145.34 140.21,145.34 138.84,143.97 v1(138.73,143.97)
GPU_OVERT_EC#: length 180.8
  L5 w0.102: v1(211.32,38) 208.86,38 208.12,38.74 203.13,38.74 202.98,38.89 202.27,38.89 200.14,41.02 190.48,41.02 189.59,41.91 187.82,41.91 187.5,41.6 185.64,41.6 184.13,43.11 167.25,43.11 167.16,43.02 146.95,43.02 146.6,42.68 146.44,42.68 142.03,42.68 141.68,43.03 130.42,43.03 129.81,43.64 v1(129.13,43.64)
  L8 w0.102: v1(144.93,123.19) 144.93,120.71 144.54,120.32 144.54,113.23 143.79,112.47 143.79,99.11 v1(143.38,98.71) 143.18,98.5 143.18,94.73 143.18,73.29 143.06,73.17 143.06,69.44 143.66,68.84 143.66,66.38 143.41,66.13 143.41,64.69 143.43,64.66 143.43,64.65 144.34,63.73 144.34,62.94 135.96,54.56 135.07,54.56 131.51,50.99 131.51,49.56 129.41,47.47 129.41,45.76 129.18,45.54 129.18,44.42 129.13,44.37 v1(129.13,43.64)
  BOTTOM w0.102: v1(144.93,123.19) 145.01,123.28 Q51510.D 144.21,124.89 R51511.1 145.03,126.12 TP51511.1 ; v1(211.32,38) 211.38,38 211.5,38.13 212.95,38.13 213.16,38.33 U1.99 ; v1(143.38,98.71) 142.96,98.71 D51510.3
GPU_OVERT_NVVDD#: length 2.3
  BOTTOM w0.102: D51510.1 144.86,96.44 v2(144.88,96.42) 144.98,96.52 R53515.1
GPU_PG: length 5.2
  TOP w0.102: v1(136.17,50.75) 135.73,51.18 135.39,51.18 135.18,51.39 135.05,51.39 134.85,51.59 U67000.38
  BOTTOM w0.102: R53531.1 135.29,48.49 R53530.2 135.59,49.7 C53530.2 136.29,50.63 v1(136.17,50.75)
GPU_PLLVDD_XS_SP: length 13.1
  TOP w0.2: v4(170.14,119.83) 170.18,119.87 C51305.1 ; C51304.1 158.44,128.96 158.72,129.24 v4(158.81,129.24) ; v4(175.35,140.87) 175.47,140.75 C51306.1
  TOP w0.254: v4(175.35,140.87) 175.58,141.1 C51301.1 ; v4(157.1,119.97) 157.1,119.71 C51302.1 C51303.1
  TOP w0.381: v4(157.1,119.97) 156.72,120.35 R51720.1
  TOP w0.508: TP51300.1 189.51,155.1 v5(189.51,155.83) ; v5(189.51,155.83) 189.46,155.87 C51300.1 ; v5(189.51,155.83) 188.76,155.83 v5(188.73,155.8) ; v5(189.51,155.83) 190.76,155.83 L51300.2
  BOTTOM w0.2: U50000.BD12 v4(157.1,119.97) 157.29,119.97 U50000.BC12
  BOTTOM w0.3: v4(175.35,140.87) 175.51,141.11 175.8,141.18 U50000.U42 ; v4(170.14,119.83) U50000.AF11 ; U50000.BB24 v4(158.81,129.24)
  vias: v4(155.28,129.23) v4(180.84,142.27)
GPU_THM_CLK: length 6.6
  BOTTOM w0.109: U1.94 211.97,40.82 211.97,41.18 211.87,41.28 211.87,41.76 212.26,42.14 v2(213.48,42.14) 213.77,42.14 214.23,42.6 R328.2 214.84,43.23 215.25,43.23 R305.2 215.82,43.8 216.02,43.8 216.02,43.8 C311.1
GPU_THM_DAT: length 8.2
  BOTTOM w0.109: R303.2 217.84,43.6 217.64,43.8 C312.1 217.37,42.99 R329.2 216.57,42.19 v2(216,42.19) 215.51,42.19 214.98,41.65 212.46,41.65 212.36,41.55 212.36,41.29 212.29,41.21 U1.95
H_PECI: length 2.5
  TOP w0.109: v3(84.99,141.01) 84.94,141.05 R4514.2
  BOTTOM w0.076: U4555.BT34 85.86,141.71 85.59,141.71 84.99,141.1 v3(84.99,141.01)
H_PM_DOWN: length 313.4
  TOP w0.102: R4513.1 83.31,140.24 v3(83.26,140.19)
  L8 w0.102: v3(83.26,140.19) 83.11,140.19 80.16,137.23 80.16,128.24 78.14,126.22 78.14,124.94 78.14,124.94 78.14,120.81 73.22,115.89 73.22,112.02 75.03,110.21 77.92,110.21 79.04,109.1 79.04,100.27 77.76,98.99 75.12,98.99 74.59,98.45 68.98,98.45 67.87,97.34 67.87,97.17 67.87,97.17 67.87,92.14 67.69,91.96 67.69,84.84 66.24,83.39 64.82,83.39 64,82.58 64,65.24 70.36,58.88 76.06,58.88 77.77,57.17 78.11,57.17 78.11,57.17 87.62,57.17 89.24,55.54 99.81,55.54 108.4,46.94 111.97,46.94 115.38,43.54 123.14,43.54 128.7,37.98 132.58,37.98 134.69,35.87 144.45,35.87 145.12,36.54 165.91,36.54 169.1,39.73 173.98,39.73 182.22,47.97 182.38,47.97 216.28,47.97 216.28,47.97 217.18,47.97 218.55,49.34 219.45,50.24 219.45,50.24 219.53,50.32 219.53,56.29 221.36,58.12 221.36,60.02 223.71,62.37 232.11,62.37 234.36,64.62 237.54,64.62 240.66,67.75 243.49,67.75 244.48,66.75 247.77,66.75 v1(248.28,66.25)
  BOTTOM w0.089: v1(248.28,66.25) 248.39,66.25 249.35,65.29 249.35,64.69 249.39,64.65 U4710.AE2
H_PM_DOWN_R: length 4.3
  TOP w0.102: v1(84.34,140.34) 84.16,140.52 R4513.2
  BOTTOM w0.076: U4555.BP31 87.17,140.21 86.11,140.21 85.84,139.93 84.75,139.93 v1(84.34,140.34)
H_PM_SYNC: length 311.1
  L8 w0.102: v3(249.82,71.86) 249.82,70.65 247.75,68.58 237.08,68.58 232.08,63.58 223.53,63.58 220.75,60.8 220.75,58.37 218.84,56.46 218.84,50.49 218.3,49.95 216.93,48.58 216.54,48.58 187,48.58 181.96,48.58 176.8,43.41 170.99,43.41 168.89,41.3 161.39,41.3 159.71,39.63 158.72,39.63 157.93,38.84 156.53,38.84 156.53,38.84 154.28,38.84 153.82,38.38 144.34,38.38 143.46,37.49 137.83,37.49 136.74,38.59 134.98,38.59 128.95,38.59 128.41,39.13 123.39,44.15 117.33,44.15 109.89,51.59 104.65,51.59 100.09,56.15 89.49,56.15 87.87,57.78 78.02,57.78 72.55,63.25 72.55,64.94 69.89,67.6 69.04,67.6 65.76,70.88 65.76,80.77 68.53,83.53 68.53,87.35 71.24,90.07 71.24,94.11 75.51,98.38 78.01,98.38 79.66,100.03 79.66,109.34 78.18,110.82 75.28,110.82 73.83,112.27 73.83,115.64 78.75,120.55 78.75,125.2 78.75,125.97 80.77,127.99 80.77,136.11 81.07,136.41 82.99,138.33 83.66,138.33 83.94,138.61 83.94,141.16 84.63,141.85 v1(88.46,141.85)
  BOTTOM w0.076: U4555.BM34 88.79,141.53 v1(88.46,141.85)
  BOTTOM w0.102: v3(249.82,71.86) 249.4,71.44 R4778.2
H_PM_SYNC_R: length 7.1
  BOTTOM w0.089: 249.27,67.75 249.27,65.63 249.53,65.37 249.53,64.77 249.64,64.66 249.64,64.28 U4710.AF3
  BOTTOM w0.102: R4778.1 249.42,70.34 v2(249.42,69.57) 248.99,69.14 248.99,68.02 249.27,67.75
H_PRDY#: length 288.1
  L5 w0.102: v1(256.87,72.65) 256.87,73.1 255.54,74.43 249.35,74.43 248.18,73.26 248.18,70.45 247.37,69.64 244.74,69.64 243.26,68.16 236.5,68.16 231.1,62.76 231.1,53.93 230.76,53.59 230.76,53.47 230.17,52.89 226.06,52.89 222.75,49.58 221.67,49.58 221.67,49.58 221.5,49.58 220.8,49.58 220.04,48.82 142.14,48.82 141.28,49.68 110.12,49.68 110.02,49.58 93.62,49.58 84.6,58.6 78.89,58.6 75.49,62 75.49,66.71 77.06,68.28 77.06,72.96 77.59,73.49 77.59,81.43 79.73,83.56 79.73,126.14 81.79,128.2 81.79,131.18 81.79,134.14 82.33,134.67 85.88,134.67 87.16,135.95 v1(87.16,136.36)
  BOTTOM w0.076: v1(87.16,136.36) 87.16,136.41 U4555.BP27
  BOTTOM w0.102: R4799.2 256.59,72.37 v1(256.87,72.65)
H_PREQ#: length 294.1
  L5 w0.102: v1(89.2,138.78) 86.04,138.78 85.57,138.31 83.66,138.31 83.49,138.13 83.23,138.13 80.95,135.85 80.95,130.84 80.95,128.67 78.89,126.61 78.89,83.91 76.76,81.78 76.76,73.84 76.22,73.31 76.22,68.63 74.65,67.06 74.65,61.65 78.54,57.76 84.25,57.76 94,48.01 130.1,48.01 130.39,48.3 130.73,48.3 130.75,48.31 139.7,48.31 140.03,47.98 220.38,47.98 221.15,48.75 221.33,48.75 221.33,48.75 223.1,48.75 226.39,52.04 230.57,52.04 231.59,53.06 231.59,53.24 231.94,53.59 231.94,62.04 234.67,64.77 240.03,64.77 240.49,64.31 243.82,64.31 244.05,64.55 244.05,67.35 245.44,68.74 247.76,68.74 249.06,70.04 249.06,71.98 249.61,72.53 251.71,72.53 252.21,72.04 255.57,72.04 v3(256.18,72.65)
  BOTTOM w0.076: U4555.BL30 89.23,138.81 89.2,138.78 v1(89.2,138.78)
  BOTTOM w0.102: R4798.2 256.18,72.31 v3(256.18,72.65)
H_PWRGD: length 313.2
  TOP w0.102: v1(83.23,138.74) 83.23,139.19 83.36,139.32 C4704.1
  L8 w0.102: v3(248.18,67.26) 247.06,68.38 237.17,68.38 231.57,62.78 223.02,62.78 220.95,60.71 220.95,58.29 219.12,56.46 219.12,50.49 219.05,50.41 217.01,48.37 216.45,48.37 216.45,48.37 186.91,48.37 182.05,48.37 176.73,43.06 171.27,43.06 169.31,41.1 161.92,41.1 160.75,39.93 160.75,38.31 159.74,37.29 137.75,37.29 136.66,38.38 135.07,38.38 128.87,38.38 123.3,43.95 115.55,43.95 112.14,47.35 111.66,47.35 107.87,51.13 104.82,51.13 100.01,55.95 89.41,55.95 87.78,57.57 77.94,57.57 76.22,59.29 70.53,59.29 64.41,65.41 64.41,80.24 66.01,81.84 66.13,81.84 68.14,83.86 68.14,90.48 68.96,91.29 68.96,92.25 75.29,98.58 75.42,98.58 77.93,98.58 79.46,100.12 79.46,109.25 78.09,110.62 75.2,110.62 73.63,112.19 73.63,115.72 78.55,120.64 78.55,125.11 78.55,126.05 80.57,128.07 80.57,136.53 82.78,138.74 v1(83.23,138.74)
  BOTTOM w0.076: v1(83.23,138.74) 83.43,138.94 84.13,138.94 84.85,139.65 85.98,139.65 U4555.BT31
  BOTTOM w0.089: 248.1,67.19 247.89,66.98 247.89,66.09 248.17,65.81 248.57,65.81 249.13,65.26 249.13,64.16 U4710.AE3
  BOTTOM w0.102: v3(248.18,67.26) 248.1,67.19
H_TCK: length 305.6
  TOP w0.109: v1(83.36,137.39) 83.11,137.64 R4508.1
  L8 w0.076: v1(83.36,137.39) 81.7,135.73 81.7,127.6 79.68,125.58 79.68,120.17 74.76,115.25 74.76,112.65 75.67,111.75 78.69,111.75 80.59,109.85 80.59,99.65 78.39,97.45 75.89,97.45 72.17,93.73 72.17,89.68 69.96,87.47 69.96,83.65 69.32,83 69.32,81.7 69.09,81.47 68.76,81.47 66.68,79.4 66.68,71.3 67.9,70.08 68.87,70.08 73.48,65.47 73.48,63.63 78.41,58.7 103.33,58.7 109.15,52.87 110.14,52.87 117.94,45.08 123.77,45.08 129.34,39.51 134.21,39.51 134.6,39.51 135.26,40.17 153.01,40.17 153.41,39.77 156.92,39.77 157.48,39.77 160.04,42.33 166.8,42.33 168.81,44.34 176.42,44.34 181.58,49.5 187.38,49.5 216.54,49.5 217.92,50.88 217.92,56.85 219.82,58.75 219.82,61.18 223.15,64.51 231.42,64.51 231.7,64.51 236.7,69.51 247.36,69.51 248.87,71.01 248.87,72.38 249.29,72.8 250.35,72.8 251.25,71.9 v3(251.25,71.9)
  BOTTOM w0.076: U4555.BR28 86.47,137.89 83.86,137.89 v1(83.36,137.39)
  BOTTOM w0.109: v3(251.25,71.9) 251.18,71.82 R4532.2
H_TDI: length 293.4
  TOP w0.109: v1(89.96,140.08) 89.95,140.09 R4515.1
  L5 w0.076: v1(89.96,140.08) 90.35,139.69 90.35,139.27 89.41,138.33 85.9,138.33 85.63,138.06 83.72,138.06 83.58,137.91 83.32,137.91 81.17,135.76 81.17,130.93 81.17,128.58 79.1,126.52 79.1,83.82 76.97,81.69 76.97,73.75 76.44,73.22 76.44,68.54 74.87,66.97 74.87,61.74 78.63,57.98 84.34,57.98 94.09,48.23 130.01,48.23 130.3,48.52 130.64,48.52 130.66,48.53 139.79,48.53 140.12,48.2 220.3,48.2 221.06,48.96 221.24,48.96 221.24,48.96 221.42,48.96 221.42,48.96 223.01,48.96 226.3,52.25 230.48,52.25 231.38,53.15 231.38,53.33 231.72,53.68 231.72,62.14 236.33,66.74 239.84,66.74 240.62,67.52 243.52,67.52 245.01,69.02 247.73,69.02 248.84,70.13 248.84,72.07 250.29,73.52 251.64,73.52 252.91,72.25 253.85,72.25 v1(254.25,72.65)
  BOTTOM w0.076: U4555.BL32 v1(89.96,140.08)
  BOTTOM w0.109: R4797.2 254.25,71.75 v1(254.25,72.65)
H_TDO: length 285.9
  TOP w0.109: v1(85.66,137.51) 86.05,137.51 R4516.1
  L5 w0.076: v1(85.66,137.51) 85.31,137.86 84.61,137.86 84.38,137.63 84.38,137.27 83.92,136.81 82.87,136.81 81.37,135.31 81.37,131.01 81.37,128.39 79.31,126.33 79.31,83.74 77.17,81.6 77.17,73.67 76.64,73.13 76.64,68.45 75.07,66.88 75.07,61.82 78.71,58.18 84.42,58.18 94.1,48.5 109.53,48.5 110.29,49.26 141.1,49.26 141.96,48.4 220.21,48.4 220.97,49.17 221.32,49.17 221.5,49.17 222.93,49.17 226.22,52.45 230.37,52.45 231.18,53.25 231.18,53.42 231.52,53.76 231.52,62.59 236.67,67.74 243.43,67.74 244.91,69.22 247.54,69.22 248.6,70.27 248.6,72.12 250.21,73.73 252.52,73.73 253.59,72.66 v3(253.59,72.65)
  BOTTOM w0.076: v1(85.66,137.51) 85.68,137.52 U4555.BT28
  BOTTOM w0.109: R4796.2 253.24,73 v3(253.59,72.65)
H_THERM#: length 4
  BOTTOM w0.109: U4450.4 145.91,113.51 144.45,112.05 R4455.2
H_THERMDA: length 94.6
  TOP w0.109: v1(145.93,111.8) 146.48,111.26 146.48,109.96 144.68,108.16 144.68,104.03 145.44,103.28 v2(145.44,101.55) 145.44,100.62 146.97,99.09 146.97,98.57 146.97,95.38 145.72,94.14 145.72,88.54 147.42,86.84 150.11,86.84 150.87,86.08 154.91,86.08 156.05,87.23 160.78,87.23 164.77,83.24 204.47,83.24 205,83.77 v1(205,84.13)
  BOTTOM w0.109: U4450.2 147.21,113.59 146.65,113.03 C4451.1 146.65,112.53 v1(145.93,111.8) ; Q4450.1 204.32,83.45 v1(205,84.13) 205.28,84.41 Q4450.3
H_THERMDC: length 95.3
  TOP w0.109: v1(205.03,84.76) 205.48,84.31 205.48,83.87 204.62,83 164.67,83 160.68,86.99 156.38,86.99 155.22,85.83 150.69,85.83 149.92,86.61 147.32,86.61 145.49,88.44 145.49,94.24 146.73,95.48 146.73,98.99 144.73,101 v2(144.73,102.72) 144.45,103 144.45,108.28 146.24,110.08 146.24,110.64 145.77,111.11 145.76,111.11 v1(145.41,111.46)
  BOTTOM w0.109: Q4450.2 204.43,85.36 v1(205.03,84.76) ; v1(145.41,111.46) 145.41,112.19 C4451.2 145.8,112.63 146.15,112.98 146.15,113.06 146.56,113.47 U4450.3
H_TMS: length 288.5
  TOP w0.109: R4510.1 84.77,138.15 v1(84.77,137.46)
  L5 w0.076: v1(84.77,137.46) 84.77,137.38 83.82,136.43 82.78,136.43 81.57,135.22 81.57,131.09 81.57,128.3 79.51,126.24 79.51,83.65 77.38,81.52 77.38,73.58 76.84,73.05 76.84,68.37 75.28,66.8 75.28,61.91 78.8,58.39 84.51,58.39 93.53,49.37 110.11,49.37 110.21,49.46 141.19,49.46 142.05,48.61 220.13,48.61 220.89,49.37 221.41,49.37 221.58,49.37 222.84,49.37 226.15,52.67 230.26,52.67 230.97,53.38 230.97,53.5 231.31,53.85 231.31,62.67 236.59,67.94 243.35,67.94 244.83,69.42 247.46,69.42 248.4,70.36 248.4,72.2 250.12,73.93 250.35,73.93 254.24,73.93 v1(255.52,72.65)
  BOTTOM w0.076: U4555.BP28 87.09,137.12 85.49,137.12 85.15,137.46 v1(84.77,137.46)
  BOTTOM w0.109: v1(255.52,72.65) 255.41,72.76 R4794.2
H_TRST#: length 295.2
  L5 w0.076: v1(87.83,139.49) 86.39,139.49 85.43,138.52 83.57,138.52 83.4,138.34 83.14,138.34 80.73,135.94 80.73,130.75 80.73,128.76 78.67,126.7 78.67,84 76.54,81.87 76.54,73.93 76.01,73.4 76.01,68.72 74.44,67.15 74.44,61.56 78.45,57.55 84.16,57.55 93.91,47.79 130.26,47.79 130.19,47.79 130.53,47.79 130.84,48.1 139.61,48.1 139.94,47.77 220.47,47.77 221.24,48.53 223.23,48.53 226.47,51.77 230.65,51.77 231.81,52.92 231.81,53.15 232.18,53.52 232.18,61.98 234.76,64.56 239.94,64.56 240.4,64.09 243.91,64.09 244.27,64.46 244.27,67.26 245.44,68.43 247.76,68.43 249.27,69.95 249.27,71.89 249.7,72.32 251.62,72.32 252.12,71.82 256.8,71.82 v3(257.6,72.62)
  BOTTOM w0.076: U4555.BP30 87.83,139.44 v1(87.83,139.49)
  BOTTOM w0.109: R4801.2 257.48,72.5 v3(257.6,72.62)
HDA_BCLK: length 283
  TOP w0.109: v1(19.34,63.69) 19.26,63.61 R506.2
  L8 w0.076: v1(19.34,63.69) 19.15,63.88 19.15,64.93 20.61,66.39 21.35,66.39 21.95,67 22.22,67.26 25.63,67.26 26.5,66.39 28.33,66.39 28.85,66.91 58.1,66.91 68.68,56.33 87.5,56.33 88.96,54.87 99.5,54.87 108.1,46.27 111.69,46.27 115.45,42.51 122.48,42.51 129.02,35.98 133.63,35.98 134.41,35.2 144.73,35.2 145.4,35.87 166.69,35.87 168.04,37.21 174.28,37.21 179.36,42.29 179.36,42.41 184.24,47.29 216,47.29 217.46,47.29 218.83,48.67 220.56,50.39 220.56,51.22 220.28,51.5 220.28,56.09 222.03,57.84 222.03,59.74 223.99,61.7 231.9,61.7 232.18,61.42 234.69,61.42 235.43,62.16 236.46,62.16 238.86,64.56 241.59,64.56 241.83,64.32 243.81,64.32 243.95,64.46 256.59,64.46 257.29,65.16 259.23,65.16 260.2,64.2 261.41,64.2 261.82,64.61 263.52,64.61 265.48,62.64 v1(265.53,62.64)
  BOTTOM w0.109: R4972.1 265.31,62.26 265.31,62.42 v1(265.53,62.64)
HDA_R_BCLK: length 7.6
  BOTTOM w0.089: 262.51,60.68 261.84,60.02 259.91,60.02 259.9,60.02 259.37,60.02 259.19,60.2 258.8,60.2 U4710.BD11
  BOTTOM w0.109: 262.51,60.68 263.24,61.42 v2(264.26,61.42) 264.5,61.17 265.05,61.17 265.07,61.2 R4972.2
HDA_R_BITCLK: length 3.8
  TOP w0.109: U500.6 19.61,59.43 19.61,59.59 19.61,59.59 19.61,60.66 20.11,61.16 v2(20.11,61.24) C510.1 R506.1
HDA_R_RST#: length 6
  BOTTOM w0.089: U4710.BE10 259.08,60.64 259.75,60.64 260.08,60.96 261.52,60.96
  BOTTOM w0.109: 261.52,60.96 261.97,60.96 v2(263.22,62.21) 263.23,62.19 R4901.2
HDA_R_SDIN0: length 4.3
  TOP w0.109: U500.8 18.84,59.45 18.84,60.2 18.31,60.73 18.31,60.99 17.26,62.04 R507.1 v2(16.25,62.04)
HDA_R_SYNC: length 4.6
  BOTTOM w0.089: U4710.BG13 260.46,58.97 260.46,58.82 260.46,58.66 260.76,58.36 261.96,58.36
  BOTTOM w0.109: R4903.2 263.27,58.6 v2(263.19,58.68) 262.84,58.32 262,58.32 261.96,58.36
HDA_RST#: length 284
  TOP w0.109: U500.11 17.55,59.49 17.55,59.97 16.53,60.99 v1(16.53,61.37)
  L8 w0.076: v1(16.53,61.37) 16.53,61.5 17.67,62.64 19.02,62.64 20.59,64.21 20.59,64.65 20.59,64.99 22.41,66.81 25.44,66.81 26.31,65.93 28.52,65.93 29.04,66.45 57.91,66.45 68.49,55.87 87.31,55.87 88.77,54.41 99.06,54.41 107.66,45.81 111.51,45.81 115.26,42.05 122.09,42.05 128.63,35.52 133.44,35.52 134.22,34.74 144.92,34.74 145.59,35.41 166.88,35.41 168.23,36.76 175.34,36.76 185.42,46.84 215.81,46.84 217.65,46.84 221.08,50.27 222.96,50.27 224.99,52.3 232.74,52.3 236,55.57 237.12,55.57 238.06,56.51 238.06,60.62 239.11,61.66 240.15,61.66 240.28,61.79 240.28,61.79 241.89,63.39 244.85,63.39 245.45,64 256.78,64 257.48,64.7 259.05,64.7 260.01,63.74 261.78,63.74 262.19,64.15 263.33,64.15 264.79,62.69 v3(264.79,62.61)
  BOTTOM w0.109: v3(264.79,62.61) 264.36,63.04 R4901.1
HDA_SDIN0: length 278.6
  TOP w0.109: v1(22.65,64.62) 22.04,65.23 18.26,65.23 v2(17.54,64.51) 17.17,64.14 R507.2
  L8 w0.076: v1(22.65,64.62) 23.11,64.16 27.76,64.16 29.44,65.84 51.06,65.84 64.49,52.42 100.03,52.42 107.25,45.2 111.25,45.2 115.01,41.44 121.84,41.44 128.38,34.91 133.19,34.91 133.97,34.13 145.17,34.13 145.84,34.8 167.13,34.8 167.69,35.36 170.21,35.36 171,36.15 175.6,36.15 185.67,46.23 215.56,46.23 215.56,46.23 217.9,46.23 217.9,46.23 221.33,49.66 223.21,49.66 225.24,51.69 232.99,51.69 236.26,54.96 237.37,54.96 238.81,56.39 238.81,56.65 240.49,58.33 241.32,58.33 241.39,58.27 241.72,58.27 242.3,58.86 245.46,58.86 246.72,60.11 246.72,60.73 247.38,61.39 247.38,61.54 248.6,62.75 248.98,62.75 249.61,63.39 253.77,63.39 254.3,62.86 254.3,61.28 256.43,59.15 261.27,59.15 v1(261.39,59.03)
  BOTTOM w0.089: v1(261.39,59.03) 261.06,59.36 261.06,59.64 260.88,59.82 259.1,59.82 U4710.BE11
HDA_SDO: length 287.3
  TOP w0.109: v1(20.43,60.65) 20.01,60.23 20.01,59.65 U500.5
  L8 w0.076: v1(20.43,60.65) 20.24,60.46 17.59,60.46 16.95,61.09 16.95,61.48 17.9,62.44 19.11,62.44 20.79,64.13 20.79,64.73 20.79,64.9 22.5,66.6 25.35,66.6 26.23,65.73 28.6,65.73 29.12,66.25 57.82,66.25 68.4,55.67 87.23,55.67 88.69,54.21 98.98,54.21 107.58,45.61 111.42,45.61 115.18,41.85 122.01,41.85 128.55,35.31 133.36,35.31 134.14,34.53 145,34.53 145.67,35.21 166.96,35.21 168.31,36.55 175.43,36.55 185.51,46.63 215.73,46.63 217.73,46.63 221.16,50.07 223.04,50.07 225.07,52.1 232.82,52.1 236.09,55.36 237.2,55.36 238.4,56.56 238.4,60.67 239.19,61.46 240.24,61.46 240.36,61.59 240.37,61.59 241.72,62.94 242.93,62.94 243.26,62.61 243.96,62.61 244.33,62.98 245.55,62.98 246.36,63.8 253.94,63.8 254.71,63.03 254.71,62.42 256.38,60.74 257.97,60.74 258.97,59.74 v3(264.77,59.74)
  BOTTOM w0.109: R4869.1 264.96,59.93 v3(264.77,59.74)
HDA_SDO_R: length 6.5
  BOTTOM w0.089: U4710.BF12 259.82,59.59 260.37,59.59
  BOTTOM w0.109: R4869.2 263.37,60.38 v2(263.32,60.33) 263.25,60.26 R4861.2 262.84,59.49 261.91,58.56 260.84,58.56 260.66,58.74 260.66,59.3 260.37,59.59
HDA_SYNC: length 284.8
  TOP w0.109: U500.10 17.95,59.48 17.95,60 17.38,60.57 17.38,61.27 v1(17.41,61.3)
  L8 w0.076: v3(265.43,58.55) 264.61,58.55 263.74,59.43 258.66,59.43 257.54,60.54 256.3,60.54 254.5,62.34 254.5,62.94 253.86,63.59 246.45,63.59 245.63,62.78 244.42,62.78 244,62.36 242.69,62.36 242.41,62.08 241.15,62.08 240.45,61.38 240.45,61.38 240.32,61.26 239.28,61.26 238.6,60.58 238.6,56.48 237.29,55.16 236.17,55.16 232.91,51.9 225.16,51.9 223.12,49.86 221.25,49.86 217.82,46.43 215.65,46.43 185.59,46.43 175.51,36.35 170.92,36.35 170.13,35.56 167.61,35.56 167.05,35 145.76,35 145.09,34.33 134.06,34.33 133.28,35.11 128.46,35.11 121.93,41.65 115.1,41.65 111.34,45.41 107.33,45.41 100.12,52.62 67.82,52.62 64.67,55.77 64.67,57.02 55.65,66.04 29.21,66.04 28.69,65.52 26.15,65.52 25.27,66.4 22.58,66.4 21,64.82 21,64.04 19.19,62.23 19.02,62.23 18.74,62.23 17.8,61.3 v1(17.41,61.3)
  BOTTOM w0.109: v3(265.43,58.55) 265.38,58.6 R4903.1
HDMI_CN_DDCCLK: length 10.4
  TOP w0.109: CN56600.15 308.09,68.97 308.09,67.76 307.68,67.36 v2(306.45,67.36) D56652.4 D56652.7 303.52,67.36 303.19,67.03 R56679.2 303.07,67.57 303.4,67.9 v1(303.4,68.28)
  BOTTOM w0.109: v1(303.4,68.28) 303.67,68.55 Q56690.3
HDMI_CN_DDCDATA: length 17.3
  TOP w0.109: R56677.2 v1(297.41,67.54) ; v1(302.71,68.3) 302.71,68.32 303.1,68.71 303.78,68.71 304.16,68.33 D56652.6 D56652.5 305.93,67.86 CN56600.16
  L3 w0.076: v1(297.41,67.54) 301.95,67.54 v1(302.71,68.3)
  L10 w0.076: v1(302.38,71.86) 302.36,71.83 302.36,68.55 302.6,68.3 v1(302.71,68.3)
  BOTTOM w0.109: v1(302.38,71.86) 302.27,71.74 Q56690.6
HDMI_CN_HPD: length 6.8
  TOP w0.102: R56621.2 305.04,64.01 C56631.1 305.05,64.92 R56620.2 305.04,65.05 305.28,65.28 306.4,65.28 v2(307.68,66.56) CN56600.19
HDMI_DDCCLK: length 3.5
  TOP w0.109: v3(251.83,61.41) 252,61.24 252.91,61.24 252.95,61.2 253.4,61.2 253.7,61.5 R4935.1
  BOTTOM w0.109: U4710.AL9 252.15,61.1 v3(251.83,61.41)
HDMI_DDCDATA: length 3.7
  TOP w0.109: R4919.1 255.49,62.67 v3(255.28,62.46)
  BOTTOM w0.089: v3(255.28,62.46) 255.03,62.71 254.78,62.71 254.44,63.05 U4710.AR3
HDMI_GPU_SCL: length 211.1
  TOP w0.109: v1(269.87,77.83) 269.87,76.91 268.17,75.21 248.56,75.21 248.12,75.64 243.46,75.64 242.93,75.11 242.93,73.43 242.2,72.71 235.52,72.71 229.81,67 222.33,67 215.29,74.04 168.2,74.04 165.55,76.68 165.55,80.86 161.61,84.81 160.52,84.81 159.58,85.75 157.43,85.75 155.85,84.17 148.4,84.17 144.44,88.14 144.44,92.69 141.99,95.13 141.99,99.65 142.62,100.28 142.62,101.28 v2(142.64,101.29) 143.58,102.24 143.58,108.86 145.34,110.62 v1(145.51,110.62)
  L10 w0.076: v1(269.87,77.83) 272.59,80.55 284.93,80.55 285.77,79.71 294.18,79.71 296.87,77.02 v1(296.87,76.81)
  BOTTOM w0.109: v1(145.51,110.62) 146.38,111.48 R51712.2 ; Q56690.4 302.04,69.58 301.37,70.26 R56691.1 301.16,70.34 300.69,70.81 300.69,73.63 299.84,74.48 298.55,74.48 296.87,76.15 v1(296.87,76.81)
HDMI_GPU_SDA: length 210.8
  TOP w0.109: v1(145.34,110.04) 145.34,109.92 144.07,108.66 144.07,100.96 145.31,99.72 v2(145.31,98.99) 145.31,97.73 144.75,97.16 144.75,97.11 144.39,96.75 144.39,93.71 144.93,93.17 144.93,88.34 148.61,84.66 155.65,84.66 157.22,86.24 159.79,86.24 160.73,85.3 161.81,85.3 166.04,81.06 166.04,76.88 168.4,74.53 215.49,74.53 222.53,67.49 229.61,67.49 235.32,73.2 242,73.2 242.44,73.64 242.44,75.31 243.43,76.31 248.16,76.31 248.76,75.7 267.97,75.7 v1(269.29,77.02)
  L10 w0.076: v1(269.29,77.02) 269.29,78.72 271.57,81 285.16,81 286,80.17 294.37,80.17 297.33,77.21 297.33,75.77 298.27,74.83 300.58,74.83 303.55,71.86 v1(304.44,71.86)
  BOTTOM w0.109: v1(304.44,71.86) 304.11,71.53 R56692.1 303.83,71.5 303.83,71.2 303.67,71.04 Q56690.1 ; R51711.2 145.83,110.04 v1(145.34,110.04)
HDMI_HPDET: length 1.6
  TOP w0.089: TP4807.1 252.88,61.93 v1(253.21,61.6)
  BOTTOM w0.089: v1(253.21,61.6) 253.71,61.1 U4710.AP9
HDMI_ISP_SCL: length 9.2
  TOP w0.109: U56400.10 v1(290.91,70.74)
  L8 w0.076: v1(290.91,70.74) 291.62,71.45 296.19,71.45 v3(297.02,70.62)
  BOTTOM w0.109: R56676.1 v3(297.02,70.62)
HDMI_ISP_SDA: length 11.7
  TOP w0.109: R56673.1 298.17,65.28 v1(297.96,65.48) ; v1(291.61,70.64) 291.4,70.86 291.4,71.43 291.31,71.52 U56400.11
  L3 w0.076: v1(291.61,70.64) 291.97,70.29 291.97,68.08 292.91,67.14 295.25,67.14 296.67,65.71 296.68,65.71 296.91,65.48 v1(297.96,65.48)
HDMI_MB_HPD#: length 47.9
  TOP w0.102: Q56470.6 290.7,63.73 v3(291.61,63.73) 291.77,63.88 R56472.1
  L8 w0.102: v3(291.61,63.73) 292.55,62.79 293.13,62.79 294.2,61.72 294.2,60.54 291.68,58.02 282.27,58.02 277.92,53.67 269.8,53.67 267.64,51.51 267.64,49.7 266.31,48.37 261.52,48.37 v1(261.26,48.62)
  BOTTOM w0.089: v1(261.26,48.62) 260.83,48.62 260.34,48.14 259.58,48.14 U4710.BF35
HDMI_MPC_SCL: length 17.5
  TOP w0.109: U56400.33 288.51,78.17 288.17,78.51 287.68,78.51 287.6,78.59 286.48,78.59 v1(285.95,79.12) 285.95,79.69 R56463.1 ; R56413.1 286.16,70.64 v3(286.25,70.64) 286.25,70.82 287.04,71.6 U56400.1
  L5 w0.076: v3(286.25,70.64) 285.16,71.73 285.16,78.34 v1(285.95,79.12)
HDMI_MPC_SDA: length 17.4
  TOP w0.109: R56414.1 285.65,69.4 286.4,70.15 286.48,70.15 286.94,70.62 v1(287.02,70.62) 287.19,70.79 287.35,70.79 287.71,71.15 U56400.2 ; v1(286.71,79.12) 286.71,79.56 R56462.1 287.96,78.92 288.49,78.92 288.91,78.5 U56400.32
  L5 w0.076: v1(286.71,79.12) 285.67,78.08 285.67,71.96 v1(287.02,70.62)
HDMI_NV_Q_HPD: length 4.2
  TOP w0.102: v2(289.99,66.37) 289.86,66.25 R56470.2 ; v2(289.99,66.37) 289.99,66.72 R56471.1 ; v2(289.99,66.37) Q56470.2 Q56470.5
