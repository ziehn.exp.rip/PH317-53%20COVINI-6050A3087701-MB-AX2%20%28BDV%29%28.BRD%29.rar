# Allegro board PH317-53 COVINI-6050A3087701-MB-AX2 (BDV)(.BRD).brd (continued)
## Placement (name value [footprint] x y rotation side) (continued)
R4719  33_5%_2  [RSC_100X050X040_2]  246.41 68.82 90 bottom
R4720  10K_5%_2  [RSC_100X050X040_2]  253.13 36.15 270 bottom
R4721  33_5%_2  [RSC_100X050X040_2]  257.22 35.28 90 bottom
R4722  60.4_1%_2  [RSC_100X050X040_2]  67.43 69.9 0 bottom
R4723  10K_5%_2  [RSC_100X050X040_2]  266.42 48.06 90 top
R4724  10K_5%_2  [RSC_100X050X040_2]  260.14 71.4 90 bottom
R4725  20K_5%_2  [RSC_100X050X040_2]  262.28 71 0 bottom
R4726  10K_5%_2  [RSC_100X050X040_2]  255.93 48.03 270 top
R4727  10K_5%_2  [RSC_100X050X040_2]  254.28 48.03 270 top
R4728  10K_5%_2  [RSC_100X050X040_2]  258.21 32.79 270 top
R4729  100K_5%_2  [RSC_100X050X040_2]  271.7 56.14 270 top
R4731  20K_5%_2  [RSC_100X050X040_2]  258.62 66.07 180 top
R4732  20K_5%_2  [RSC_100X050X040_2]  259.25 71.4 90 bottom
R4733  10K_5%_2_DY  [RSC_100X050X040_2]  263.75 51.69 0 bottom
R4736  1K_5%_2  [RSC_100X050X040_2]  250.67 75.9 180 bottom
R4739  1K_5%_2  [RSC_100X050X040_2]  67.43 69.02 180 bottom
R4742  100K_5%_2  [RSC_100X050X040_2]  64.33 66.83 0 bottom
R4743  200_5%_2  [RSC_100X050X040_2]  249.04 75.9 180 bottom
R4747  1K_5%_2  [RSC_100X050X040_2]  259.15 32.79 270 top
R4748  75K_1%_2  [RSC_100X050X040_2]  267.2 57.23 0 bottom
R4749  10K_5%_2  [RSC_100X050X040_2]  249.96 35.92 0 bottom
R4750  0_5%_2  [RSC_100X050X040_2]  266.54 38.33 270 bottom
R4751  0_5%_2  [RSC_100X050X040_2]  239.14 31.52 270 bottom
R4752  47K_5%_2  [RSC_100X050X040_2]  238.78 29.42 180 bottom
R4753  33_5%_2  [RSC_100X050X040_2]  265.02 40.97 270 bottom
R4754  10K_1%_2_DY  [RSC_100X050X040_2]  246.88 36.6 90 bottom
R4755  10K_1%_2_DY  [RSC_100X050X040_2]  266.09 51.08 180 bottom
R4756  113_1%_2  [RSC_100X050X040_2]  238.3 69.57 90 bottom
R4757  10K_1%_2_DY  [RSC_100X050X040_2]  246 36.6 90 bottom
R4758  1K_5%_2  [RSC_100X050X040_2]  237.41 69.57 90 bottom
R4759  1K_5%_2  [RSC_100X050X040_2]  239.19 69.57 90 bottom
R4760  10K_5%_2  [RSC_100X050X040_2]  252.24 36.15 270 bottom
R4761  10K_1%_2_DY  [RSC_100X050X040_2]  248.71 36.45 90 bottom
R4762  27K_1%_2  [RSC_100X050X040_2]  245.82 33.05 180 bottom
R4763  10K_1%_2_DY  [RSC_100X050X040_2]  244.57 48.47 270 top
R4764  27K_1%_2  [RSC_100X050X040_2]  243.13 33.07 270 bottom
R4765  10K_1%_2_DY  [RSC_100X050X040_2]  242.8 48.34 270 top
R4766  10K_1%_2_DY  [RSC_100X050X040_2]  243.68 48.34 270 top
R4767  10K_5%_2  [RSC_100X050X040_2]  247.77 37.37 270 bottom
R4768  10K_1%_2_DY  [RSC_100X050X040_2]  245.46 48.52 270 top
R4769  1K_5%_2  [RSC_100X050X040_2]  154.96 36.48 0 bottom
R4770  short_0402_5  [RSC_100X050X040_2_SHORT]  112.47 59.08 90 bottom
R4771  470_5%_2  [RSC_100X050X040_2]  113.36 59.08 90 bottom
R4772  short_0402_5  [RSC_100X050X040_2_SHORT]  267.2 59.01 0 bottom
R4773  10K_1%_2_DY  [RSC_100X050X040_2]  241.91 47.98 270 top
R4774  10K_5%_2  [RSC_100X050X040_2]  251.36 36.15 270 bottom
R4775  2.2K_5%_2  [RSC_100X050X040_2]  266.32 56.21 0 bottom
R4776  0_5%_2  [RSC_100X050X040_2]  272.59 56.14 270 top
R4777  short_0402_5  [RSC_100X050X040_2_SHORT]  267.2 58.12 0 bottom
R4778  30_5%_2  [RSC_100X050X040_2]  249.4 70.79 90 bottom
R4779  100K_5%_2_DY  [RSC_100X050X040_2]  268.32 49.46 180 top
R4780  100K_5%_2_DY  [RSC_100X050X040_2]  268.25 41.84 0 bottom
R4781  100K_5%_2_DY  [RSC_100X050X040_2]  268.53 40.54 90 bottom
R4782  100K_5%_2_DY  [RSC_100X050X040_2]  268.25 42.73 0 bottom
R4783  10K_5%_2  [RSC_100X050X040_2]  250.67 48.67 180 top
R4784  100K_5%_2_DY  [RSC_100X050X040_2]  268.55 48.44 180 top
R4785  6 20_5%  [RSC_100X050X040_2]  247.6 68.69 90 bottom
R4786  1K_5%_2  [RSC_100X050X040_2]  248.48 68.69 270 bottom
R4787  100K_5%_2  [RSC_100X050X040_2]  270.74 49.48 180 top
R4788  100K_5%_2  [RSC_100X050X040_2]  266.28 40.76 0 bottom
R4789  100K_5%_2  [RSC_100X050X040_2]  266.28 39.87 0 bottom
R4790  100K_5%_2  [RSC_100X050X040_2]  268.25 43.62 180 bottom
R4791  100K_5%_2  [RSC_100X050X040_2]  270.96 48.59 180 top
R4792  30_5%_2  [RSC_100X050X040_2]  252.29 69.96 180 top
R4793  100K_5%_2  [RSC_100X050X040_2]  265.35 45.32 270 bottom
R4794  0_5%_2  [RSC_100X050X040_2]  254.99 73.99 0 bottom
R4795  0_5%_3  [RSC_160X080X055_2]  244.4 30.89 270 bottom
R4796  0_5%_2  [RSC_100X050X040_2]  253.01 72.57 90 bottom
R4797  0_5%_2  [RSC_100X050X040_2]  253.87 70.95 90 bottom
R4798  0_5%_2  [RSC_100X050X040_2]  255.7 71.4 90 bottom
R4799  0_5%_2  [RSC_100X050X040_2]  256.59 71.4 90 bottom
R4800  22_5%_2  [RSC_100X050X040_2]  259.15 49.56 0 top
R4801  0_5%_2  [RSC_100X050X040_2]  257.48 71.4 90 bottom
R4802  10K_5%_2_DY  [RSC_100X050X040_2]  266.19 52.07 180 bottom
R4803  10K_5%_2_DY  [RSC_100X050X040_2]  255.11 53.22 270 top
R4804  10K_5%_2  [RSC_100X050X040_2]  264.03 41.79 90 bottom
R4805  10K_5%_2  [RSC_100X050X040_2]  263.98 44 0 bottom
R4806  2.2K_5%_2_DY  [RSC_100X050X040_2]  254.99 59.69 0 top
R4807  2.2K_5%_2_DY  [RSC_100X050X040_2]  254.4 63.27 0 top
R4808  2.2K_5%_2_DY  [RSC_100X050X040_2]  254.99 58.8 0 top
R4809  2.2K_5%_2_DY  [RSC_100X050X040_2]  254.99 60.58 0 top
R4810  2.2K_5%_2  [RSC_100X050X040_2]  260.78 56.11 270 top
R4811  10K_5%_2  [RSC_100X050X040_2]  249.96 36.81 180 bottom
R4812  2.2K_5%_2  [RSC_100X050X040_2]  261.67 56.11 270 top
R4813  10K_5%_2  [RSC_100X050X040_2]  265.53 48.06 90 top
R4815  10K_5%_2_DY  [RSC_100X050X040_2]  259.58 51.24 180 top
R4818  10K_5%_2  [RSC_100X050X040_2]  249.37 37.7 0 bottom
R4819  10K_5%_2  [RSC_100X050X040_2]  255.57 56.16 180 top
R4820  10K_5%_2  [RSC_100X050X040_2]  270.56 58.6 270 top
R4822  10K_5%_2  [RSC_100X050X040_2]  237.72 34.04 0 top
R4823  0_5%_2  [RSC_100X050X040_2]  265.88 49.53 180 top
R4824  10K_5%_2  [RSC_100X050X040_2]  267.97 54.28 90 bottom
R4825  2.2K_5%_2  [RSC_100X050X040_2]  258.7 56.49 270 top
R4826  1K_5%_2_DY  [RSC_100X050X040_2]  256.77 53.22 270 top
R4827  2.2K_5%_2  [RSC_100X050X040_2]  259.58 56.49 270 top
R4828  2.2K_5%_2  [RSC_100X050X040_2]  263.75 52.58 180 bottom
R4831  100K_5%_2_DY  [RSC_100X050X040_2]  268.32 50.37 0 top
R4832  0_5%_2  [RSC_100X050X040_2]  157.38 36.48 180 bottom
R4833  1M_5%_2  [RSC_100X050X040_2]  261.08 33.3 180 top
R4834  10K_5%_1  [RSC_060X030X030_2]  246.86 35.18 0 bottom
R4835  20K_5%_2  [RSC_100X050X040_2]  244.95 35.59 270 bottom
R4836  100K_5%_2  [RSC_100X050X040_2]  270.99 50.37 180 top
R4837  100K_5%_2_DY  [RSC_100X050X040_2]  267.46 54.77 0 top
R4838  100K_5%_2  [RSC_100X050X040_2]  268.68 53.06 180 top
R4839  100K_5%_2_DY  [RSC_100X050X040_2]  268.32 51.26 0 top
R4840  30_5%_2  [RSC_100X050X040_2]  135.48 121.14 90 bottom
R4841  100K_5%_2  [RSC_100X050X040_2]  270.99 51.26 180 top
R4842  100K_5%_2_DY  [RSC_100X050X040_2]  270.71 53.04 180 top
R4843  100K_5%_2  [RSC_100X050X040_2]  270.71 52.15 180 top
R4846  15_5%_2  [RSC_100X050X040_2]  264.54 32.72 270 top
R4847  15_5%_2  [RSC_100X050X040_2]  262.99 32.72 270 top
R4848  15_5%_2  [RSC_100X050X040_2]  267.31 33 270 top
R4849  15_5%_2  [RSC_100X050X040_2]  265.43 32.46 270 top
R4850  33_5%_2  [RSC_100X050X040_2]  270.51 33.2 270 top
R4851  short_0603_25  [RSC_160X080X080_2_25_SHORT]  234.95 37.44 270 bottom
R4852  33_5%_2  [RSC_100X050X040_2]  268.6 33.2 180 top
R4853  100K_5%_2  [RSC_100X050X040_2]  258.37 71.4 270 bottom
R4854  100K_5%_2  [RSC_100X050X040_2]  251.74 60.48 0 top
R4858  100K_5%_2  [RSC_100X050X040_2]  252.7 63.38 180 top
R4859  100K_5%_2  [RSC_100X050X040_2]  262.07 54.51 0 top
R4861  1K_5%_2  [RSC_100X050X040_2]  263.67 59.49 180 bottom
R4862  10M_5%_2  [RSC_100X050X040_2]  262.64 37.23 180 bottom
R4864  short_0603_25  [RSC_160X080X080_2_25_SHORT]  241.86 72.88 180 bottom
R4869  33_5%_2  [RSC_100X050X040_2]  264.54 60.38 180 bottom
R4870  100_5%_2  [RSC_100X050X040_2]  240.1 36.07 180 bottom
R4872  100_5%_2  [RSC_100X050X040_2]  241.73 36.07 180 bottom
R4873  10K_5%_2  [RSC_100X050X040_2]  267.31 48.06 270 top
R4874  short_0402_15  [RSC_100X050X040_2_15_SHORT]  241.5 34.8 270 bottom
R4875  short_0402_15  [RSC_100X050X040_2_15_SHORT]  240.59 34.8 270 bottom
R4876  100_5%_2_DY  [RSC_100X050X040_2]  252.12 72.55 270 bottom
R4879  51_5%_2  [RSC_100X050X040_2]  252.98 70.95 90 bottom
R4880  51_5%_2  [RSC_100X050X040_2]  252.47 73.99 180 bottom
R4881  51_5%_2  [RSC_100X050X040_2]  250.29 65.28 180 top
R4882  10K_5%_2  [RSC_100X050X040_2]  256.59 58.37 0 top
R4890  1K_5%_2  [RSC_100X050X040_2]  252.07 70.95 90 bottom
R4891  2.2K_5%_2  [RSC_100X050X040_2]  250.4 63.69 0 top
R4892  60.4_1%_2  [RSC_100X050X040_2]  243.86 67.31 0 top
R4897  100K_5%_2_DY  [RSC_100X050X040_2]  264.69 47.98 0 bottom
R4898  1M_5%_2  [RSC_100X050X040_2]  245.95 70.29 180 bottom
R4900  0_5%_2  [RSC_100X050X040_2]  249.7 58.02 90 top
R4901  33_5%_2  [RSC_100X050X040_2]  264.18 62.61 270 bottom
R4902  0_5%_2  [RSC_100X050X040_2]  266.09 48.21 90 bottom
R4903  33_5%_2  [RSC_100X050X040_2]  264.41 58.6 180 bottom
R4904  0_5%_2_DY  [RSC_100X050X040_2]  267.36 47.78 180 bottom
R4906  0_5%_2  [RSC_100X050X040_2]  253.21 52.2 90 top
R4908  0_5%_2  [RSC_100X050X040_2]  266.06 49.71 180 bottom
R4909  10K_5%_2_DY  [RSC_100X050X040_2]  255.62 51.26 0 top
R4911  100K_5%_2  [RSC_100X050X040_2]  263.78 48.87 180 bottom
R4912  10K_5%_2_DY  [RSC_100X050X040_2]  263.37 48.8 0 top
R4913  2.2K_5%_2  [RSC_100X050X040_2]  263.62 54.21 270 bottom
R4915  short_0402_15  [RSC_100X050X040_2_15_SHORT]  258.49 59.97 90 top
R4916  0_5%_2  [RSC_100X050X040_2]  256.59 59.26 180 top
R4918  0_5%_2  [RSC_100X050X040_2]  249.81 56.75 180 top
R4919  2.2K_5%_2_DY  [RSC_100X050X040_2]  255.06 64.16 180 top
R4920  0_5%_2  [RSC_100X050X040_2]  250.59 58.02 270 top
R4921  0_5%_2  [RSC_100X050X040_2]  243.23 34.04 0 top
R4922  0_5%_2  [RSC_100X050X040_2]  240.26 33.99 0 top
R4924  0_5%_2  [RSC_100X050X040_2]  250.77 59.29 180 top
R4927  30_5%_2  [RSC_100X050X040_2]  254.35 69.6 0 top
R4928  20_5%_2  [RSC_100X050X040_2]  137.61 121.69 270 bottom
R4930  30_5%_2  [RSC_100X050X040_2]  255.62 70.36 270 top
R4935  2.2K_5%_2_DY  [RSC_100X050X040_2]  254.86 61.5 0 top
R4972  33_5%_2  [RSC_100X050X040_2]  265.1 61.62 270 bottom
R5000  100K_5%_2  [RSC_100X050X040_2]  156.03 43.18 0 bottom
R5001  0_5%_2  [RSC_100X050X040_2]  158.77 39.55 180 bottom
R6050  100_5%_2  [RSC_100X050X040_2]  28.37 30.2 180 top
R6051  100_5%_2  [RSC_100X050X040_2]  30.22 33.94 180 top
R6098  4.7K_5%_3  [RSC_160X080X080_2]  45.92 50.96 0 bottom
R6900  10K_5%_2  [RSC_100X050X040_2]  190.62 32.64 270 bottom
R6901  0_5%_2  [RSC_100X050X040_2]  191.89 33.07 0 bottom
R6980  short_0402_5  [RSC_100X050X040_2_SHORT]  189.71 32.64 270 bottom
R6987  short_0402_5  [RSC_100X050X040_2_SHORT]  191.82 29.09 180 bottom
R6988  0_5%_2  [RSC_100X050X040_2]  190.24 31.32 0 bottom
R7001  0_5%_2  [RSC_100X050X040_2]  65.35 74.17 0 bottom
R7002  0_5%_2  [RSC_100X050X040_2]  211.25 19.92 180 top
R7003  47K_5%_2  [RSC_100X050X040_2]  188.59 27.94 180 bottom
R7004  0_5%_2  [RSC_100X050X040_2]  59.99 33.94 180 bottom
R7006  10K_5%_2  [RSC_100X050X040_2]  220.62 47.78 90 bottom
R7007  100K_5%_2  [RSC_100X050X040_2]  59.99 33.02 180 bottom
R7008  10K_5%_2  [RSC_100X050X040_2]  64.08 73.89 270 bottom
R7009  0_5%_2  [RSC_100X050X040_2]  269.49 46.64 0 top
R7010  10K_5%_2  [RSC_100X050X040_2]  268.55 47.55 0 top
R7012  1K_5%_2  [RSC_100X050X040_2]  218.18 30.56 90 top
R7013  200K_5%_2  [RSC_100X050X040_2]  192.3 30.41 0 bottom
R7014  100K_5%_2  [RSC_100X050X040_2]  220.16 29.21 0 bottom
R7015  10K_5%_2  [RSC_100X050X040_2]  217.29 30.56 270 top
R7016  10K_5%_2  [RSC_100X050X040_2]  67.03 101.45 90 bottom
R7017  10K_5%_2  [RSC_100X050X040_2]  213.66 19.92 180 top
R7018  0_5%_2  [RSC_100X050X040_2]  67.92 101.45 270 bottom
R7019  0_5%_2  [RSC_100X050X040_2]  221.48 27.97 270 bottom
R7021  0_5%_2  [RSC_100X050X040_2]  220.6 27.97 270 bottom
R7024  1K_5%_2  [RSC_100X050X040_2]  226.79 28.91 180 bottom
R7027  100_5%_2  [RSC_100X050X040_2]  95.04 56.95 90 bottom
R7029  10K_1%_2  [RSC_100X050X040_2]  278.41 66.02 270 bottom
R7030  200K_5%_2_DY  [RSC_100X050X040_2]  227.23 48.39 90 top
R7031  100K_5%_2  [RSC_100X050X040_2]  247.52 28.76 180 bottom
R7032  100K_5%_2  [RSC_100X050X040_2]  247.85 31.37 90 bottom
R7033  0_5%_2  [RSC_100X050X040_2]  190.24 30.41 0 bottom
R7034  150_5%_3  [RSC_160X080X080_2]  224.1 50.6 90 top
R7035  150_5%_3  [RSC_160X080X080_2]  74.44 93.78 90 bottom
R7037  10K_5%_2  [RSC_100X050X040_2]  191.89 32.19 180 bottom
R7038  100K_5%_2  [RSC_100X050X040_2]  70.13 95 270 bottom
R7039  100K_5%_2  [RSC_100X050X040_2]  70.13 93.4 90 bottom
R7040  100K_5%_2  [RSC_100X050X040_2]  96.34 56.54 180 bottom
R7041  10K_5%_2  [RSC_100X050X040_2]  77.29 56.09 180 bottom
R7042  short_0402_5  [RSC_100X050X040_2_SHORT]  77.21 57 180 bottom
R7043  100K_5%_2  [RSC_100X050X040_2]  65.5 110.14 270 bottom
R7044  100K_5%_2  [RSC_100X050X040_2]  66.39 110.14 270 bottom
R7054  47K_5%_2  [RSC_100X050X040_2]  71.09 98.17 90 bottom
R7063  short_0402_5  [RSC_100X050X040_2_SHORT]  67.79 89.92 270 bottom
R7065  100K_5%_2  [RSC_100X050X040_2]  67.79 91.55 90 bottom
R7066  100K_5%_2  [RSC_100X050X040_2]  65.22 89.28 0 bottom
R7068  0_5%_2  [RSC_100X050X040_2]  66.87 89.92 270 bottom
R7069  0_5%_2  [RSC_100X050X040_2]  72.34 90.48 270 bottom
R7070  0_5%_2  [RSC_100X050X040_2]  69.21 92.1 180 bottom
R7501  0_5%_3  [RSC_160X080X055_2]  26.18 28.81 180 top
R7601  10K_5%_2  [RSC_100X050X040_2]  21.89 32.21 0 top
R7602  100_5%_2  [RSC_100X050X040_2]  24.18 28.81 180 top
R7603  100K_5%_2  [RSC_100X050X040_2]  24.46 32.08 0 top
R7604  10K_5%_2_DY  [RSC_100X050X040_2]  21.89 33.1 0 top
R50010  10K_1%_2  [RSC_100X050X040_2]  143.76 126.24 0 bottom
R50011  10K_1%_2  [RSC_100X050X040_2]  143.94 123.73 270 bottom
R50012  10K_1%_2  [RSC_100X050X040_2]  141.78 120.91 0 bottom
R50020  100K_1%_2  [RSC_100X050X040_2]  145.97 38.64 0 bottom
R50021  100K_1%_2  [RSC_100X050X040_2]  149.09 39.86 270 bottom
R50022  100K_1%_2_DY  [RSC_100X050X040_2]  147.93 41.89 0 bottom
R50090  0_5%_3  [RSC_160X080X055_2]  141.2 142.6 270 bottom
R50091  2.49K_1%_2  [RSC_100X050X040_2]  146.76 142.9 180 bottom
R50120  60.4K_1%_2_DY  [RSC_100X050X040_2]  179.98 151.84 0 bottom
R50121  60.4K_1%_2_DY  [RSC_100X050X040_2]  160.02 152.2 90 bottom
R50220  60.4K_1%_2_DY  [RSC_100X050X040_2]  191.79 133.71 0 bottom
R50221  60.4K_1%_2_DY  [RSC_100X050X040_2]  192.22 148.01 90 top
R50320  60.4K_1%_2_DY  [RSC_100X050X040_2]  195.02 115.6 0 top
R50321  60.4K_1%_2_DY  [RSC_100X050X040_2]  193.42 133.71 180 bottom
R50420  60.4K_1%_2_DY  [RSC_100X050X040_2]  168.53 113.11 90 top
R50421  60.4K_1%_2_DY  [RSC_100X050X040_2]  184.35 105.36 270 top
R50500  121_1%_2  [RSC_100X050X040_2]  174.1 169.35 90 top
R50501  121_1%_2  [RSC_100X050X040_2]  174.1 167.73 270 top
R50505  10K_1%_2  [RSC_100X050X040_2]  179.73 166.75 270 top
R50506  10K_1%_2  [RSC_100X050X040_2]  187.62 165.58 270 bottom
R50510  1K_1%_2  [RSC_100X050X040_2]  186.45 167.95 180 top
R50600  121_1%_2  [RSC_100X050X040_2]  170.85 168 270 top
R50601  121_1%_2  [RSC_100X050X040_2]  170.88 169.69 90 top
R50605  10K_1%_2  [RSC_100X050X040_2]  164.79 169.75 90 top
R50606  10K_1%_2  [RSC_100X050X040_2]  156.67 167.7 90 bottom
R50610  1K_1%_2  [RSC_100X050X040_2]  158.18 168.67 270 top
R50700  121_1%_2  [RSC_100X050X040_2]  208.22 149.78 90 top
R50701  121_1%_2  [RSC_100X050X040_2]  207.02 149.85 90 top
R50705  10K_1%_2  [RSC_100X050X040_2]  207.77 144.22 0 top
R50706  10K_1%_2  [RSC_100X050X040_2]  206.03 135.94 0 bottom
R50710  1K_1%_2  [RSC_100X050X040_2]  206.65 137.37 0 top
R50800  121_1%_2  [RSC_100X050X040_2]  207 151.95 180 top
R50801  121_1%_2  [RSC_100X050X040_2]  208.7 152 0 top
R50805  10K_1%_2  [RSC_100X050X040_2]  208.78 158.02 0 top
R50806  10K_1%_2  [RSC_100X050X040_2]  205.55 166.16 180 bottom
R50810  1K_1%_2  [RSC_100X050X040_2]  207.08 165.27 270 top
R50900  121_1%_2  [RSC_100X050X040_2]  207.59 110.75 0 top
R50901  121_1%_2  [RSC_100X050X040_2]  205.97 110.74 180 top
R50905  10K_1%_2  [RSC_100X050X040_2]  205.46 105.34 180 top
R50906  10K_1%_2  [RSC_100X050X040_2]  204.26 97.36 180 bottom
R50910  1K_1%_2  [RSC_100X050X040_2]  207.64 99.5 270 top
R51000  121_1%_2  [RSC_100X050X040_2]  206.66 113.43 180 top
R51001  121_1%_2  [RSC_100X050X040_2]  208.35 113.4 0 top
R51005  10K_1%_2  [RSC_100X050X040_2]  208.25 119.92 0 top
R51006  10K_1%_2  [RSC_100X050X040_2]  206.57 127.69 0 bottom
R51010  1K_1%_2  [RSC_100X050X040_2]  207.32 126.25 180 top
R51100  121_1%_2  [RSC_100X050X040_2]  178.15 90.93 270 top
R51101  121_1%_2  [RSC_100X050X040_2]  178.3 94.24 90 top
R51105  10K_1%_2  [RSC_100X050X040_2]  172.66 94.55 90 top
R51106  10K_1%_2  [RSC_100X050X040_2]  164.79 96.14 90 bottom
R51110  1K_1%_2  [RSC_100X050X040_2]  166.34 93.25 270 top
R51200  121_1%_2  [RSC_100X050X040_2]  179.95 94.48 90 top
R51201  121_1%_2  [RSC_100X050X040_2]  179.95 90.63 270 top
R51205  10K_1%_2  [RSC_100X050X040_2]  186.15 91.58 270 top
R51206  10K_1%_2  [RSC_100X050X040_2]  194.26 95 90 bottom
R51210  1K_1%_2  [RSC_100X050X040_2]  193.14 92.18 180 top
R51316  10K_1%_2  [RSC_100X050X040_2]  150.11 108.52 270 bottom
R51321  100K_1%_2  [RSC_100X050X040_2]  144.37 108.87 180 bottom
R51400  10K_1%_2  [RSC_100X050X040_2]  154.25 84.53 90 bottom
R51401  33_1%_2  [RSC_100X050X040_2]  157.93 84.99 180 bottom
R51402  33_1%_2  [RSC_100X050X040_2]  155.8 94.75 90 bottom
R51403  33_1%_2  [RSC_100X050X040_2]  154.53 94.24 0 bottom
R51421  100K_1%_2  [RSC_100X050X040_2]  154.53 95.13 0 bottom
R51422  10K_1%_2  [RSC_100X050X040_2]  155.55 84.46 0 bottom
R51423  100K_1%_2  [RSC_100X050X040_2]  157.07 95.28 180 bottom
R51424  10K_1%_2_DY  [RSC_100X050X040_2]  157.07 93.6 0 bottom
R51430  100K_1%_2_DY  [RSC_100X050X040_2]  147.85 92.03 0 top
R51431  100K_1%_2  [RSC_100X050X040_2]  147.85 92.92 180 top
R51432  100K_1%_2_DY  [RSC_100X050X040_2]  150.8 98.3 0 top
R51433  100K_1%_2  [RSC_100X050X040_2]  150.8 97.41 180 top
R51434  100K_1%_2_DY  [RSC_100X050X040_2]  148.49 90.73 90 top
R51435  100K_1%_2  [RSC_100X050X040_2]  149.76 90.53 0 top
R51436  100K_1%_2  [RSC_100X050X040_2]  154.23 91.72 180 top
R51437  100K_1%_2_DY  [RSC_100X050X040_2]  151.74 91.72 180 top
R51438  100K_1%_2_DY  [RSC_100X050X040_2]  154.23 90.73 180 top
R51439  100K_1%_2  [RSC_100X050X040_2]  151.76 90.73 180 top
R51440  100K_1%_2_DY  [RSC_100X050X040_2]  154.23 93.02 180 top
R51441  100K_1%_2  [RSC_100X050X040_2]  151.66 92.89 180 top
R51500  2K_1%_2  [RSC_100X050X040_2]  148.26 99.67 270 top
R51501  2K_1%_2  [RSC_100X050X040_2]  149.15 99.67 270 top
R51507  10K_1%_2  [RSC_100X050X040_2]  148.1 124.74 90 bottom
R51508  10K_1%_2  [RSC_100X050X040_2]  148.1 123.12 270 bottom
R51510  10K_1%_2  [RSC_100X050X040_2]  143.84 121.85 90 bottom
R51511  10K_1%_2  [RSC_100X050X040_2]  143.79 125.3 180 bottom
R51512  10K_1%_2  [RSC_100X050X040_2]  147.72 126.19 180 bottom
R51521  33_1%_2  [RSC_100X050X040_2]  131.67 44.66 270 bottom
R51522  33_1%_2  [RSC_100X050X040_2]  131.29 47.96 90 bottom
R51523  2.2K_5%_2  [RSC_100X050X040_2]  133.16 45.65 0 bottom
R51524  2.2K_5%_2  [RSC_100X050X040_2]  133.17 46.56 0 bottom
R51525  0_5%_2  [RSC_100X050X040_2]  145.97 126.52 90 bottom
R51526  0_5%_2_DY  [RSC_100X050X040_2]  147.72 127.13 180 bottom
R51531  33_1%_2  [RSC_100X050X040_2]  138.4 44.83 180 bottom
R51532  33_1%_2  [RSC_100X050X040_2]  135.25 43.62 0 bottom
R51533  2.2K_5%_2  [RSC_100X050X040_2]  138.53 43.95 0 bottom
R51534  2.2K_5%_2  [RSC_100X050X040_2]  137.69 43.06 0 bottom
R51540  10K_1%_2  [RSC_100X050X040_2]  150.64 105.46 270 bottom
R51545  10K_1%_2  [RSC_100X050X040_2]  157.17 109.4 0 bottom
R51550  10K_1%_2  [RSC_100X050X040_2]  158.57 94.39 270 bottom
R51560  10K_1%_2  [RSC_100X050X040_2]  151.3 108.99 270 bottom
R51561  10K_1%_2  [RSC_100X050X040_2]  152.19 108.99 270 bottom
R51562  10K_1%_2  [RSC_100X050X040_2]  158.52 91.09 0 top
R51563  10K_1%_2  [RSC_100X050X040_2]  151.84 106.86 0 bottom
R51564  10K_1%_2  [RSC_100X050X040_2]  153.36 109.07 270 bottom
R51565  10K_1%_2  [RSC_100X050X040_2]  153.59 94.62 0 top
R51566  10K_1%_2  [RSC_100X050X040_2]  154.4 107.67 180 bottom
R51567  10K_1%_2  [RSC_100X050X040_2]  151.91 105.21 180 bottom
R51568  2.2K_5%_2  [RSC_100X050X040_2]  162.51 90.73 270 top
R51569  10K_1%_2  [RSC_100X050X040_2]  159.79 90.73 270 top
R51570  10K_1%_2  [RSC_100X050X040_2]  157.22 90.58 270 top
R51571  100K_1%_2  [RSC_100X050X040_2]  148.03 98.43 0 top
R51572  1K_1%_2  [RSC_100X050X040_2]  154.28 109.07 270 bottom
R51573  10K_1%_2  [RSC_100X050X040_2]  149.76 91.42 0 top
R51574  10K_1%_2  [RSC_100X050X040_2]  149.76 92.31 0 top
R51575  100K_1%_2  [RSC_100X050X040_2]  161.59 90.73 270 top
R51576  100K_1%_2  [RSC_100X050X040_2]  153.67 106.53 0 bottom
R51577  10K_1%_2  [RSC_100X050X040_2]  160.7 90.73 270 top
R51579  0_5%_2  [RSC_100X050X040_2]  151.94 94.62 180 top
R51580  0_5%_2  [RSC_100X050X040_2]  160.14 94.06 0 top
R51582  0_5%_2  [RSC_100X050X040_2]  164.08 106.66 0 bottom
R51583  10K_1%_2  [RSC_100X050X040_2]  164.84 104.85 0 bottom
R51584  0_5%_2  [RSC_100X050X040_2]  163.22 104.85 0 bottom
R51585  10K_1%_2_DY  [RSC_100X050X040_2]  164.08 105.77 0 bottom
R51586  10K_1%_2  [RSC_100X050X040_2]  165.33 106.3 270 bottom
R51587  10K_1%_2_DY  [RSC_100X050X040_2]  166.21 106.3 90 bottom
R51592  10K_1%_2  [RSC_100X050X040_2]  154.43 86.9 0 top
R51593  100K_1%_2  [RSC_100X050X040_2]  152.17 88.4 270 top
R51595  10K_1%_2  [RSC_100X050X040_2]  125.96 43.84 270 bottom
R51596  100K_1%_2  [RSC_100X050X040_2]  127.43 45.37 180 bottom
R51615  1K_1%_2  [RSC_100X050X040_2]  155.08 126.98 0 top
R51616  0_5%_3  [RSC_160X080X055_2]  155.07 128.6 270 top
R51630  100K_1%_2  [RSC_100X050X040_2]  298.32 53.22 180 top
R51640  100K_1%_2  [RSC_100X050X040_2]  299.18 61.29 180 top
R51650  100K_1%_2  [RSC_100X050X040_2]  303.15 53.22 180 top
R51660  100K_1%_2  [RSC_100X050X040_2]  302.21 61.29 180 top
R51670  10K_1%_2  [RSC_100X050X040_2]  296.03 62.49 90 top
R51671  10K_1%_2  [RSC_100X050X040_2]  296.29 67.29 0 top
R51672  10K_1%_2  [RSC_100X050X040_2]  297.43 64.39 90 top
R51680  10K_1%_2  [RSC_100X050X040_2]  294.2 62.49 90 top
R51681  10K_1%_2  [RSC_100X050X040_2]  294.08 67.19 90 top
R51682  10K_1%_2  [RSC_100X050X040_2]  294.99 67.19 90 top
R51711  0_5%_2  [RSC_100X050X040_2]  146.66 110.44 180 bottom
R51712  0_5%_2  [RSC_100X050X040_2]  147.06 111.48 180 bottom
R51720  0_5%_3  [RSC_160X080X055_2]  156.72 122.15 90 top
R51721  1K_1%_2  [RSC_100X050X040_2]  156.44 123.77 0 top
R51750  10K_1%_2  [RSC_100X050X040_2]  159.34 123.02 180 top
R51751  10K_1%_2  [RSC_100X050X040_2]  161.19 118.6 180 top
R51752  0_5%_2  [RSC_100X050X040_2]  163.09 115.22 90 top
R51753  10K_1%_2  [RSC_100X050X040_2]  157.5 93.58 0 top
R51900  10K_1%_2  [RSC_100X050X040_2]  162.53 120.58 270 top
R51902  10K_1%_2  [RSC_100X050X040_2]  163.98 120.93 0 top
R51903  10K_1%_2  [RSC_100X050X040_2]  165.2 117.71 90 top
R52000  0_5%_2  [RSC_100X050X040_2]  149.53 52.68 0 bottom
R52001  0_5%_2  [RSC_100X050X040_2]  140.64 47.27 0 bottom
R52002  0_5%_2_DY  [RSC_100X050X040_2]  154.94 40.87 0 bottom
R52003  0_5%_2  [RSC_100X050X040_2]  149.73 50.14 0 bottom
R52006  1K_1%_2  [RSC_100X050X040_2]  148.89 55.25 90 bottom
R52007  30K_1%_2_DY  [RSC_100X050X040_2]  148 55.25 90 bottom
R52008  0_5%_2  [RSC_100X050X040_2]  143.13 55.07 90 bottom
R52009  0_5%_2  [RSC_100X050X040_2]  144.01 55.07 90 bottom
R52010  287_1%_2  [RSC_100X050X040_2]  149.7 47.83 180 bottom
R52011  0_5%_2  [RSC_100X050X040_2]  148.84 46 90 bottom
R52012  100_1%_2  [RSC_100X050X040_2]  147.95 46 90 bottom
R52013  649_1%_2  [RSC_100X050X040_2]  146.43 45.42 0 bottom
R52014  75K_1%_2  [RSC_100X050X040_2]  146.43 44.53 180 bottom
R52020  287_1%_2  [RSC_100X050X040_2]  140.56 45.62 90 bottom
R52021  0_5%_2  [RSC_100X050X040_2]  145.18 45.83 90 bottom
R52022  100_1%_2  [RSC_100X050X040_2]  144.29 45.83 90 bottom
R52023  649_1%_2  [RSC_100X050X040_2]  142.72 46.16 0 bottom
R52024  75K_1%_2  [RSC_100X050X040_2]  142.47 44.38 180 bottom
R52036  10K_1%_2  [RSC_100X050X040_2]  142.24 55.07 90 bottom
R52037  10K_1%_2  [RSC_100X050X040_2]  141.35 55.07 90 bottom
R52038  10K_1%_2  [RSC_100X050X040_2]  140.69 51.34 180 bottom
R52039  10K_1%_2  [RSC_100X050X040_2]  140.69 50.17 180 bottom
R52050  365K_1%_2  [RSC_100X050X040_2]  145.06 57.46 270 bottom
R52051  681K_1%_2  [RSC_100X050X040_2]  144.17 59.06 90 bottom
R52053  243K_1%_2  [RSC_100X050X040_2]  145.95 57.46 90 bottom
R52054  90.9K_1%_2  [RSC_100X050X040_2]  145.95 59.06 270 bottom
R52055  10K_1%_2  [RSC_100X050X040_2]  145.06 59.06 270 bottom
R52060  49.9K_1%_2  [RSC_100X050X040_2]  150.44 58.17 90 bottom
R52061  10K_1%_2  [RSC_100X050X040_2]  149.53 53.75 180 bottom
R52070  10K_1%_2  [RSC_100X050X040_2]  151.56 43.11 180 bottom
R52071  100K_1%_2  [RSC_100X050X040_2]  151.56 42.22 0 bottom
R52072  10K_1%_2_DY  [RSC_100X050X040_2]  150.49 40.03 90 bottom
R52073  0_5%_3  [RSC_160X080X055_2]  151.3 45.49 90 bottom
R52074  0_5%_3_DY  [RSC_160X080X055_2]  150.19 45.49 90 bottom
R52080  0_5%_2  [RSC_100X050X040_2]  140.64 48.16 0 bottom
R52081  0_5%_2  [RSC_100X050X040_2]  140.66 52.71 0 bottom
R52101  10K_1%_2  [RSC_100X050X040_2]  159.43 87.99 180 top
R52102  2.21K_1%_2  [RSC_100X050X040_2]  161.72 88.67 180 bottom
R52110  0_5%_2  [RSC_100X050X040_2]  143.99 145.49 180 bottom
R52111  0_5%_2  [RSC_100X050X040_2]  143.99 144.58 180 bottom
R52200  49.9_1%_2  [RSC_100X050X040_2]  179.93 141.28 0 top
R52210  40.2_1%_2  [RSC_100X050X040_2]  178.68 141.52 270 top
R52211  40.2_1%_2  [RSC_100X050X040_2]  177.78 141.52 270 top
R52212  40.2_1%_2  [RSC_100X050X040_2]  176.89 141.92 270 top
R52230  2_1%_2  [RSC_100X050X040_2]  186.53 153.82 90 top
R52231  2_1%_2  [RSC_100X050X040_2]  185.62 153.82 90 top
R53500  0_5%_2  [RSC_100X050X040_2]  108.66 51.31 0 bottom
R53501  100K_1%_2_DY  [RSC_100X050X040_2]  111.17 52.25 270 bottom
R53505  10K_1%_2  [RSC_100X050X040_2]  111.08 48.88 270 bottom
R53510  10K_1%_2  [RSC_100X050X040_2]  144.57 102.14 270 bottom
R53511  10K_1%_2  [RSC_100X050X040_2]  144.93 103.41 0 bottom
R53512  0_5%_3  [RSC_160X080X055_2]  148.33 101.93 90 bottom
R53515  0_5%_3  [RSC_160X080X055_2]  144.98 98 90 bottom
R53520  100K_1%_2  [RSC_100X050X040_2]  142.36 103.36 180 bottom
R53530  10K_1%_2  [RSC_100X050X040_2]  134.87 49.41 0 bottom
R53531  0_5%_2  [RSC_100X050X040_2]  134.87 48.49 180 bottom
R53540  100K_1%_2  [RSC_100X050X040_2]  117.7 47.5 180 bottom
R53541  10K_1%_2  [RSC_100X050X040_2]  117.95 50.8 180 bottom
R53550  0_5%_2_DY  [RSC_100X050X040_2]  107.24 56.98 90 bottom
R53551  0_5%_2  [RSC_100X050X040_2]  102.99 55.76 270 bottom
R53552  100K_1%_2  [RSC_100X050X040_2]  111.17 54.49 90 bottom
R53555  100K_1%_2  [RSC_100X050X040_2]  102.74 53.47 270 bottom
R53570  100K_1%_2  [RSC_100X050X040_2]  122.4 51.24 180 bottom
R53571  10K_1%_2  [RSC_100X050X040_2]  124.08 51.82 90 bottom
R53573  0_5%_2  [RSC_100X050X040_2]  122.4 56.04 180 bottom
R53574  0_5%_2_DY  [RSC_100X050X040_2]  124.33 56.57 180 bottom
R53580  100K_1%_2  [RSC_100X050X040_2]  119.55 55.73 0 bottom
R53581  0_5%_3  [RSC_160X080X055_2]  118.08 57.15 270 bottom
R53583  0_5%_3  [RSC_160X080X055_2]  124.1 58.19 90 bottom
R53584  0_5%_3_DY  [RSC_160X080X055_2]  122.96 58.19 90 bottom
R53585  100K_1%_2  [RSC_100X050X040_2]  113.31 56.85 90 bottom
R53590  100K_1%_2  [RSC_100X050X040_2]  120.67 49.38 180 bottom
R53591  33K_1%_2  [RSC_100X050X040_2]  120.67 48.47 180 bottom
R55210  10K_1%_2  [RSC_100X050X040_2]  202.8 88.78 0 bottom
R55211  10K_1%_2  [RSC_100X050X040_2]  203.97 87.35 180 bottom
R55215  2.2_5%_5  [RSC_200X125X130_2]  198.46 88.24 180 bottom
R55216  2.2_5%_5  [RSC_200X125X130_2]  198.46 86.64 180 bottom
R55217  2.2_5%_5  [RSC_200X125X130_2]  198.46 85.04 180 bottom
R55218  2.2_5%_5  [RSC_200X125X130_2]  198.46 83.44 180 bottom
R55220  10K_1%_2  [RSC_100X050X040_2]  207.57 169.93 180 bottom
R55221  10K_1%_2  [RSC_100X050X040_2]  204.95 170.72 90 bottom
R55225  2.2_5%_5  [RSC_200X125X130_2]  207.31 178.34 90 bottom
R55226  2.2_5%_5  [RSC_200X125X130_2]  204.1 178.33 90 bottom
R55227  2.2_5%_5  [RSC_200X125X130_2]  202.5 178.33 90 bottom
R55228  2.2_5%_5  [RSC_200X125X130_2]  205.71 178.34 90 bottom
R55230  10K_1%_2  [RSC_100X050X040_2]  203.98 168.23 0 top
R55231  10K_1%_2  [RSC_100X050X040_2]  201.14 168.23 180 top
R55235  2.2_5%_5  [RSC_200X125X130_2]  212.35 169.87 270 top
R55236  2.2_5%_5  [RSC_200X125X130_2]  210.75 169.87 270 top
R55237  2.2_5%_5  [RSC_200X125X130_2]  209.15 169.87 270 top
R55238  2.2_5%_5  [RSC_200X125X130_2]  207.55 169.87 270 top
R55600  0_5%_3  [RSC_160X080X055_2]  142.19 105.31 0 bottom
R55601  0_5%_2  [RSC_100X050X040_2]  141.22 99.11 270 bottom
R55602  10K_1%_2  [RSC_100X050X040_2]  140.31 99.11 270 bottom
R55810  4.7K_5%_2  [RSC_100X050X040_2]  292.15 47.98 270 top
R55811  4.7K_5%_2_DY  [RSC_100X050X040_2]  293.09 47.98 270 top
R55812  4.7K_5%_2_DY  [RSC_100X050X040_2]  293.09 61.32 90 top
R55813  4.7K_5%_2_DY  [RSC_100X050X040_2]  292 61.32 90 top
R55814  4.7K_5%_2_DY  [RSC_100X050X040_2]  291.11 61.32 90 top
R55815  4.7K_5%_2_DY  [RSC_100X050X040_2]  289.84 61.32 90 top
R55816  4.7K_5%_2_DY  [RSC_100X050X040_2]  288.95 61.32 90 top
R55817  4.7K_5%_2_DY  [RSC_100X050X040_2]  288.06 58.75 180 top
R55818  4.7K_5%_2_DY  [RSC_100X050X040_2]  296.08 58.68 0 top
R55819  4.7K_5%_2_DY  [RSC_100X050X040_2]  296.08 59.59 0 top
R55820  0_5%_3  [RSC_160X080X055_2]  287.73 50.04 0 top
R55821  0_5%_3  [RSC_160X080X055_2]  287.7 48.87 0 top
R55830  100K_1%_2_DY  [RSC_100X050X040_2]  291.26 47.98 270 top
R55831  4.7K_5%_2_DY  [RSC_100X050X040_2]  289.43 47.98 270 top
R55832  4.7K_5%_2_DY  [RSC_100X050X040_2]  290.34 47.98 270 top
R56200  1M_5%_2  [RSC_100X050X040_2]  300.66 49.74 270 top
R56201  5.1M_5%_2  [RSC_100X050X040_2]  305.15 53.67 0 bottom
R56202  0_5%_2  [RSC_100X050X040_2]  305.71 48.42 0 top
R56250  2.2_5%_5  [RSC_200X125X130_2]  296.86 37.81 0 bottom
R56251  0_5%_2  [RSC_100X050X040_2]  300.73 33.91 0 bottom
R56260  100K_1%_2  [RSC_100X050X040_2]  269.64 67.29 0 bottom
R56261  100K_1%_2  [RSC_100X050X040_2]  271.68 66.93 270 bottom
R56270  100K_1%_2  [RSC_100X050X040_2]  276.22 66.93 0 bottom
R56271  100K_1%_2  [RSC_100X050X040_2]  275.23 66.04 180 bottom
R56280  100K_1%_2  [RSC_100X050X040_2]  272.95 66.93 0 bottom
R56281  100K_1%_2  [RSC_100X050X040_2]  272.95 66.02 180 bottom
R56282  10K_1%_2_DY  [RSC_100X050X040_2]  272.23 70.64 180 bottom
R56290  0_5%_2_DY  [RSC_100X050X040_2]  298.68 34.22 270 bottom
R56410  10K_1%_2  [RSC_100X050X040_2]  287.96 80.72 90 top
R56411  10K_1%_2  [RSC_100X050X040_2]  288.85 80.72 90 top
R56412  11K_1%_2_DY  [RSC_100X050X040_2]  292.81 70.26 0 top
R56413  10K_1%_2  [RSC_100X050X040_2]  284.73 68.79 270 top
R56414  10K_1%_2  [RSC_100X050X040_2]  285.65 68.79 270 top
R56430  22K_1%_2  [RSC_100X050X040_2]  291.21 67.34 180 top
R56431  100K_1%_2_DY  [RSC_100X050X040_2]  291.21 66.45 0 top
R56432  22K_1%_2_DY  [RSC_100X050X040_2]  287.8 69.17 180 top
R56433  100K_1%_2  [RSC_100X050X040_2]  287.8 68.28 0 top
R56435  1K_1%_2  [RSC_100X050X040_2]  289.51 68.28 180 top
R56436  1K_1%_2_DY  [RSC_100X050X040_2]  289.51 69.17 0 top
R56440  0_5%_3  [RSC_160X080X055_2]  292.53 79.63 90 top
R56450  0_5%_3  [RSC_160X080X055_2]  282.9 81 270 top
R56451  0_5%_3  [RSC_160X080X055_2]  284.02 81 270 top
R56452  0_5%_3_DY  [RSC_160X080X055_2]  295.5 79.12 180 top
R56453  0_5%_3  [RSC_160X080X055_2]  294.92 80.85 270 top
R56462  0_5%_2_DY  [RSC_100X050X040_2]  287.02 80.29 90 top
R56463  0_5%_2_DY  [RSC_100X050X040_2]  286.13 80.29 90 top
R56470  100K_1%_2  [RSC_100X050X040_2]  288.79 66.25 0 top
R56471  1K_1%_2  [RSC_100X050X040_2]  289.12 67.16 180 top
R56472  10K_1%_2  [RSC_100X050X040_2]  291.77 64.95 90 top
R56620  22_1%_2  [RSC_100X050X040_2]  304.62 64.93 0 top
R56621  47K_5%_2  [RSC_100X050X040_2]  304.62 63.1 0 top
R56670  1K_1%_2  [RSC_100X050X040_2]  300.22 68.08 90 bottom
R56671  22_1%_2  [RSC_100X050X040_2]  300 64.01 90 top
R56672  2K_1%_2  [RSC_100X050X040_2]  300.89 64.01 270 top
R56673  22_1%_2  [RSC_100X050X040_2]  299.18 65.28 0 top
R56674  22_1%_2  [RSC_100X050X040_2]  299.01 69.73 0 bottom
R56675  2K_1%_2  [RSC_100X050X040_2]  301.49 68.43 180 bottom
R56676  22_1%_2  [RSC_100X050X040_2]  299.01 70.62 0 bottom
R56677  22_1%_2  [RSC_100X050X040_2]  298.45 67.54 180 top
R56678  2K_1%_2  [RSC_100X050X040_2]  298.45 66.63 180 top
R56679  22_1%_2  [RSC_100X050X040_2]  303.07 66.6 90 top
R56680  2K_1%_2  [RSC_100X050X040_2]  301.8 64.01 270 top
R56681  0_5%_2  [RSC_100X050X040_2]  301.57 74.7 0 top
R56682  0_5%_2  [RSC_100X050X040_2]  301.57 73.82 0 top
R56683  0_5%_2  [RSC_100X050X040_2]  299.97 73.21 0 top
R56684  0_5%_2  [RSC_100X050X040_2]  299.97 72.32 0 top
R56685  0_5%_2  [RSC_100X050X040_2]  299.97 71.4 0 top
R56686  0_5%_2  [RSC_100X050X040_2]  299.97 70.51 0 top
R56687  0_5%_2  [RSC_100X050X040_2]  301.57 69.93 0 top
R56688  0_5%_2  [RSC_100X050X040_2]  301.57 69.04 0 top
R56690  1K_1%_2  [RSC_100X050X040_2]  303.37 72.42 180 bottom
R56691  1.8K_1%_2  [RSC_100X050X040_2]  301.37 70.77 90 bottom
R56692  1.8K_1%_2  [RSC_100X050X040_2]  303.37 71.53 180 bottom
R60000  0.005_1%_6  [RSC_320X160X080_4_P2]  45.42 39.52 270 bottom
R60001  0.01_1%_6  [RSC_320X160X089_4_P2]  37.34 28.84 90 bottom
R60002  200K_1%_2  [RSC_100X050X040_2]  50.62 48.47 90 bottom
R60003  51K_1%_2  [RSC_100X050X040_2]  51.53 48.47 90 bottom
R60004  4.3K_5%_2  [RSC_100X050X040_2]  51.86 46.3 180 bottom
R60005  4.3K_5%_2  [RSC_100X050X040_2]  51.86 45.38 180 bottom
R60007  10K_5%_2  [RSC_100X050X040_2]  51.86 47.21 180 bottom
R60008  10_5%_2  [RSC_100X050X040_2]  61.13 42.8 0 bottom
R60009  10_5%_5  [RSC_200X125X115_2]  51.69 41.25 270 bottom
R60010  10_5%_2  [RSC_100X050X040_2]  61.13 45.29 0 bottom
R60011  4.3K_5%_2  [RSC_100X050X040_2]  61.24 46.21 0 bottom
R60012  10_5%_2  [RSC_100X050X040_2]  61.54 47.53 0 bottom
R60013  20K_1%_2  [RSC_100X050X040_2]  61.41 40.55 270 bottom
R60014  49.9K_1%_2  [RSC_100X050X040_2]  60.5 40.55 90 bottom
R60015  2.2_5%_3  [RSC_160X080X080_2]  56.05 41.08 180 bottom
R60016  2.2_5%_3  [RSC_160X080X080_2]  47.55 25.83 0 bottom
R60017  470K_5%_2  [RSC_100X050X040_2]  35.76 43.92 0 bottom
R60018  470K_5%_2  [RSC_100X050X040_2]  35.76 44.84 0 bottom
R60019  1M_5%_2  [RSC_100X050X040_2]  45.57 48.67 180 bottom
R60020  3M_5%_2  [RSC_100X050X040_2]  45.57 47.77 0 bottom
R60021  short_0402_15  [RSC_100X050X040_2_15_SHORT]  78.91 157.28 270 top
R60022  0_5%_2_DY  [RSC_100X050X040_2]  58.49 50.02 270 bottom
R60023  100K_5%_2  [RSC_100X050X040_2]  48 44.2 0 bottom
R60024  100K_5%_2  [RSC_100X050X040_2]  48 45.1 0 bottom
R60026  1K_5%_2  [RSC_100X050X040_2]  37.66 47.89 90 bottom
R60110  RSC_0402  [RSC_100X050X040_2]  192.77 28.64 180 top
R60115  3.3_5%_3  [RSC_160X080X055_2]  195.09 27.98 90 top
R60166  RSC_0603  [RSC_160X080X080_2]  197.74 26.98 0 top
R60199  short_0402_15  [RSC_100X050X040_2_15_SHORT]  194.05 29.01 90 top
R60203  short_0402_15  [RSC_100X050X040_2_15_SHORT]  245.11 20.48 270 top
R60204  0_5%_2  [RSC_100X050X040_2]  241.86 21.01 0 top
R60205  100K_5%_2  [RSC_100X050X040_2]  239.85 19.87 0 top
R60215  0_5%_3  [RSC_160X080X055_2]  246.32 28.35 90 top
R60216  RSC_0603  [RSC_160X080X080_2]  248.94 26.99 0 top
R60239  1K_5%_2  [RSC_100X050X040_2]  243.86 19.97 0 top
R60253  short_0402_15  [RSC_100X050X040_2_15_SHORT]  60.52 76.41 180 bottom
R60254  0_5%_2  [RSC_100X050X040_2]  63.78 76.79 90 bottom
R60265  0_5%_3  [RSC_160X080X055_2]  60.73 83.59 90 bottom
R60266  RSC_0603_DY  [RSC_160X080X080_2]  57.34 84.17 180 bottom
R60289  1K_1%_2  [RSC_100X050X040_2]  60.52 75.52 180 bottom
R60300  10.2K_1%_2  [RSC_100X050X040_2]  65.76 79.91 270 bottom
R60301  10K_1%_2  [RSC_100X050X040_2]  66.11 81.16 0 bottom
R60302  short_0402_5  [RSC_100X050X040_2_SHORT]  66.11 82.05 180 bottom
R60315  short_0603_25  [RSC_160X080X080_2_25_SHORT]  68.31 80.39 180 bottom
R60316  RSC_0603  [RSC_160X080X080_2]  66.75 76.36 180 bottom
R60344  RSC_0402  [RSC_100X050X040_2]  66.65 79.91 270 bottom
R60346  short_0402_15  [RSC_100X050X040_2_15_SHORT]  67.38 83.57 180 bottom
R60347  RSC_0402  [RSC_100X050X040_2]  66.24 77.58 180 bottom
R60348  RSC_0402  [RSC_100X050X040_2]  67.94 81.41 180 bottom
R60349  short_0402_15  [RSC_100X050X040_2_15_SHORT]  74.19 86.59 90 bottom
R60400  324K_1%_2  [RSC_100X050X040_2]  75.79 59.11 270 bottom
R60401  100K_1%_2  [RSC_100X050X040_2]  75.26 57.84 180 bottom
R60505  RSC_0603  [RSC_160X080X080_2]  69.82 100.28 270 bottom
R60506  2.2_5%_3  [RSC_160X080X080_2]  71.57 99.67 180 bottom
R60515  2.2_5%_3  [RSC_160X080X080_2]  70.19 102.66 270 bottom
R60516  RSC_0603  [RSC_160X080X080_2]  73.53 101.73 0 bottom
R60522  100K_5%_2  [RSC_100X050X040_2]  69.42 109.46 270 bottom
R60523  470K_5%_2  [RSC_100X050X040_2]  68.51 109.46 90 bottom
R60524  RSC_0402  [RSC_100X050X040_2]  67.28 109.76 90 bottom
R60525  RSC_0402  [RSC_100X050X040_2]  65.43 108.87 180 bottom
R60526  short_0402_15  [RSC_100X050X040_2_15_SHORT]  68.81 101.45 270 bottom
R60529  short_0402_5  [RSC_100X050X040_2_SHORT]  70.31 109.46 270 bottom
R60600  20.5K_1%_2  [RSC_100X050X040_2]  212.88 20.82 180 top
R60601  10K_1%_2  [RSC_100X050X040_2]  212.77 22.99 270 top
R60900  100K_1%_2  [RSC_100X050X040_2]  219.17 53.56 270 bottom
R60901  133K_1%_2  [RSC_100X050X040_2]  219.52 52.29 180 bottom
R60905  RSC_0402  [RSC_100X050X040_2]  219.52 51.38 180 bottom
R60915  0_5%_3  [RSC_160X080X055_2]  226.62 52.26 0 bottom
R60916  RSC_0603  [RSC_160X080X080_2]  223.85 61.31 0 bottom
R60920  1K_5%_2  [RSC_100X050X040_2]  219.59 54.81 0 bottom
R66000  short_0402_5  [RSC_100X050X040_2_SHORT]  81.07 160.68 90 bottom
R66001  RSC_0402  [RSC_100X050X040_2]  81.07 162.28 90 bottom
R66005  33.2K_1%_2  [RSC_100X050X040_2]  89.15 165.3 180 top
R66015  3.3_5%_3  [RSC_160X080X055_2]  99.67 175.24 270 bottom
R66016  10_5%_3  [RSC_160X080X080_2]  97.89 168.23 180 top
R66017  2.2_5%_3  [RSC_160X080X080_2]  97.01 174.63 180 bottom
R66018  short_0402_15  [RSC_100X050X040_2_15_SHORT]  99.64 159.59 90 top
R66019  220_1%_2  [RSC_100X050X040_2]  99.64 161.19 270 top
R66025  3.3_5%_3  [RSC_160X080X055_2]  110.03 175.29 270 bottom
R66026  10_5%_3  [RSC_160X080X080_2]  108.38 168.23 180 top
R66027  2.2_5%_3  [RSC_160X080X080_2]  107.37 174.67 180 bottom
R66028  short_0402_15  [RSC_100X050X040_2_15_SHORT]  110.03 159.54 90 top
R66029  220_1%_2  [RSC_100X050X040_2]  110.03 161.14 270 top
R66035  3.3_5%_3  [RSC_160X080X055_2]  120.44 175.26 270 bottom
R66036  10_5%_3  [RSC_160X080X080_2]  118.82 168.23 180 top
R66037  2.2_5%_3  [RSC_160X080X080_2]  117.77 174.67 180 bottom
R66038  short_0402_15  [RSC_100X050X040_2_15_SHORT]  120.42 159.54 90 top
R66039  220_1%_2  [RSC_100X050X040_2]  120.42 161.14 270 top
R66045  3.3_5%_3  [RSC_160X080X055_2]  130.81 175.26 270 bottom
R66046  10_5%_3  [RSC_160X080X080_2]  129.23 168.28 180 top
R66047  2.2_5%_3  [RSC_160X080X080_2]  128.14 174.67 180 bottom
R66048  short_0402_15  [RSC_100X050X040_2_15_SHORT]  130.81 159.57 90 top
R66049  220_1%_2  [RSC_100X050X040_2]  130.81 161.19 270 top
R66090  130K_1%_2  [RSC_100X050X040_2]  82.42 172.21 90 bottom
R66091  24.9K_1%_2  [RSC_100X050X040_2]  83.31 172.21 90 bottom
R66092  4.3K_1%_2  [RSC_100X050X040_2]  84.2 172.21 90 bottom
R66093  110K_1%_2  [RSC_100X050X040_2]  85.09 170.53 90 bottom
R66100  100_1%_2  [RSC_100X050X040_2]  80.72 157.28 90 top
R66101  45.3_1%_2  [RSC_100X050X040_2]  81.63 157.28 90 top
R66102  49.9_1%_2  [RSC_100X050X040_2]  81.58 159.94 270 top
R66103  10_1%_2  [RSC_100X050X040_2]  80.44 159.66 270 top
R66104  RSC_0402  [RSC_100X050X040_2]  79.83 157.28 90 top
R66105  75_1%_2  [RSC_100X050X040_2]  79.55 159.66 270 top
R66107  26.7K_1%_2  [RSC_100X050X040_2]  89.13 163.04 90 top
R66109  2_5%_2  [RSC_100X050X040_2]  84.76 172.65 270 top
R66112  93.1K_1%_2  [RSC_100X050X040_2]  92.25 168.48 0 top
R66113  10_1%_2  [RSC_100X050X040_2]  97.99 159.59 270 top
R66114  4.64K_1%_2  [RSC_100X050X040_2]  90.09 168.71 180 top
R66115  RSC_0402  [RSC_100X050X040_2]  89.76 169.98 0 top
R66122  93.1K_1%_2  [RSC_100X050X040_2]  93.09 170.26 0 top
R66123  10_1%_2  [RSC_100X050X040_2]  108.4 159.54 270 top
R66124  4.64K_1%_2  [RSC_100X050X040_2]  92.25 169.37 180 top
R66132  93.1K_1%_2  [RSC_100X050X040_2]  93.09 171.14 0 top
R66133  10_1%_2  [RSC_100X050X040_2]  118.79 159.54 270 top
R66134  4.64K_1%_2  [RSC_100X050X040_2]  92.5 172.04 180 top
R66136  RSC_0402  [RSC_100X050X040_2]  89.15 171.91 180 top
R66137  RSC_0402  [RSC_100X050X040_2]  77.42 173.2 180 top
R66142  93.1K_1%_2  [RSC_100X050X040_2]  79.04 173.2 0 top
R66143  10_1%_2  [RSC_100X050X040_2]  129.16 159.57 270 top
R66144  4.64K_1%_2  [RSC_100X050X040_2]  78.41 171.55 0 top
R66150  100K_1%_NTC  [RSC_100X050X055_2]  94.01 156.14 270 bottom
R66151  75K_1%_2  [RSC_100X050X040_2]  92.15 166.19 270 top
R66152  165K_1%_2  [RSC_100X050X040_2]  90.47 166.55 90 top
R66160  100K_1%_NTC  [RSC_100X050X055_2]  94.46 169.47 90 bottom
R66161  short_0402_15  [RSC_100X050X040_2_15_SHORT]  87.15 171.12 90 top
R66162  18.7K_1%_2  [RSC_100X050X040_2]  93.57 169.47 90 bottom
R66170  49.9_1%_2  [RSC_100X050X040_2]  92.8 162.74 270 top
R66171  1K_1%_2  [RSC_100X050X040_2]  90.75 163.17 180 top
R66172  3K_1%_2  [RSC_100X050X040_2]  92.43 164.95 0 top
R66180  short_0402_15  [RSC_100X050X040_2_15_SHORT]  92.07 160.48 180 top
R66181  short_0402_15  [RSC_100X050X040_2_15_SHORT]  92.07 161.37 180 top
R66182  1K_1%_2  [RSC_100X050X040_2]  89.18 161.44 270 top
R66195  short_0402_15  [RSC_100X050X040_2_15_SHORT]  81.07 172.74 270 top
R66197  16K_1%_2  [RSC_100X050X040_2]  81.48 171.5 0 top
R66199  1K_5%_2  [RSC_100X050X040_2]  87.5 172.36 180 top
R66305  13K_1%_2  [RSC_100X050X040_2]  78.01 166.4 90 top
R66311  51_5%_2  [RSC_100X050X040_2]  82.06 148.99 225 bottom
R66315  2.2_5%_3  [RSC_160X080X080_2]  78.93 148.3 225 bottom
R66316  10_5%_3  [RSC_160X080X080_2]  65.76 130.49 90 bottom
R66317  2.2_5%_3  [RSC_160X080X080_2]  83.19 147.51 225 bottom
R66318  short_0402_15  [RSC_100X050X040_2_15_SHORT]  65.86 124.64 90 bottom
R66319  short_0402_15  [RSC_100X050X040_2_15_SHORT]  65.86 126.26 270 bottom
R66393  25.5K_1%_2  [RSC_100X050X040_2]  81.43 168.71 270 bottom
R66407  32.4K_1%_2  [RSC_100X050X040_2]  80.01 164.82 0 bottom
R66412  54.9K_1%_2  [RSC_100X050X040_2]  74.45 167.51 90 top
R66413  10_1%_2  [RSC_100X050X040_2]  77.14 168.83 180 top
R66414  5.1K_1%_2  [RSC_100X050X040_2]  75.64 170.13 270 top
R66424  1K_5%_2  [RSC_100X050X040_2]  76.2 171.76 90 top
R66450  100K_1%_NTC  [RSC_100X050X055_2]  65.83 122.99 270 bottom
R66451  75K_1%_2  [RSC_100X050X040_2]  74.45 165.91 90 top
R66452  165K_1%_2  [RSC_100X050X040_2]  75.33 166.7 90 top
R66460  100K_1%_NTC  [RSC_100X050X055_2]  68.02 138.03 270 bottom
R66461  short_0402_15  [RSC_100X050X040_2_15_SHORT]  78.74 170.34 270 bottom
R66462  18.7K_1%_2  [RSC_100X050X040_2]  67.1 138.03 270 bottom
R66470  49.9_1%_2  [RSC_100X050X040_2]  75.64 162.82 0 top
R66471  1K_1%_2  [RSC_100X050X040_2]  77.24 163.53 180 top
R66472  3K_1%_2  [RSC_100X050X040_2]  75.64 164.6 0 top
R66480  short_0402_15  [RSC_100X050X040_2_15_SHORT]  78.02 158.09 270 top
R66481  short_0402_15  [RSC_100X050X040_2_15_SHORT]  77.13 158.09 270 top
R66482  1K_1%_2  [RSC_100X050X040_2]  77.47 161.39 270 top
R66602  RSC_0402  [RSC_100X050X040_2]  83.49 157.96 270 top
R66605  40.2K_1%_2  [RSC_100X050X040_2]  84.63 162.28 270 bottom
R66607  127K_1%  [RSC_100X050X040_2]  82.85 162.28 90 bottom
R66615  2.2_5%_3  [RSC_160X080X080_2]  146.19 167.66 90 bottom
R66616  RSC_0603  [RSC_160X080X080_2]  141.5 170.95 90 top
R66618  short_0402_15  [RSC_100X050X040_2_15_SHORT]  139.29 163.86 180 top
R66619  220_1%_2  [RSC_100X050X040_2]  139.29 164.75 180 top
R66650  100K_1%_NTC  [RSC_100X050X055_2]  136.88 160.28 180 bottom
R66651  10_1%_2  [RSC_100X050X040_2]  84.91 159.21 0 top
R66652  14K_1%_2  [RSC_100X050X040_2]  84.91 155.65 0 top
R66653  7.5K_1%_2  [RSC_100X050X040_2]  84.91 156.54 0 top
R66670  1K_1%_2  [RSC_100X050X040_2]  87.04 157.83 90 top
R66680  short_0402_15  [RSC_100X050X040_2_15_SHORT]  92.66 159.31 180 top
R66681  short_0402_15  [RSC_100X050X040_2_15_SHORT]  92.66 158.42 180 top
R66682  2K_1%_2  [RSC_100X050X040_2]  89.08 157.45 180 top
R66683  6.98K_1%_2  [RSC_100X050X040_2]  89.38 159.59 90 top
R66690  130K_1%_2  [RSC_100X050X040_2]  82.32 168.71 270 bottom
R66693  37.4K_1%_2  [RSC_100X050X040_2]  81.96 162.28 90 bottom
R67000  0_5%_2  [RSC_100X050X040_2]  129.54 50.5 180 top
R67001  0_5%_2  [RSC_100X050X040_2]  129.54 49.61 180 top
R67002  100_1%_2  [RSC_100X050X040_2]  130.79 50.79 90 top
R67003  100_1%_2  [RSC_100X050X040_2]  130.81 48.72 180 top
R67004  0_5%_2  [RSC_100X050X040_2]  132.41 47.83 0 top
R67005  RSC_0402_NTC  [RSC_100X050X040_2]  130.81 47.83 0 top
R67006  4.99K_1%_2  [RSC_100X050X040_2]  133.88 48.7 90 top
R67007  4.99K_1%_2  [RSC_100X050X040_2]  134.77 48.7 90 top
R67008  0_5%_2  [RSC_100X050X040_2]  135.68 48.7 90 top
R67009  0_5%_2  [RSC_100X050X040_2]  136.28 60.04 180 top
R67010  0_5%_2  [RSC_100X050X040_2]  136.6 48.7 90 top
R67012  0_5%_2  [RSC_100X050X040_2]  138.45 50.12 0 top
R67013  10K_5%_2  [RSC_100X050X040_2]  138.81 51.39 90 top
R67014  RSC_0402  [RSC_100X050X040_2]  138.59 52.64 180 top
R67016  RSC_0603  [RSC_160X080X080_2]  165.2 58.64 0 bottom
R67017  2K_5%_2  [RSC_100X050X040_2]  157.78 54.22 0 bottom
R67026  RSC_0603  [RSC_160X080X080_2]  175.16 58.65 0 bottom
R67027  2K_5%_2  [RSC_100X050X040_2]  167.68 54.22 0 bottom
R67036  RSC_0603  [RSC_160X080X080_2]  185.15 58.65 0 bottom
R67037  2K_5%_2  [RSC_100X050X040_2]  177.66 54.25 0 bottom
R67046  RSC_0603  [RSC_160X080X080_2]  195.19 58.65 0 bottom
R67047  2K_5%_2  [RSC_100X050X040_2]  187.67 54.3 0 bottom
R67056  RSC_0603  [RSC_160X080X080_2]  205.17 58.65 0 bottom
R67057  2K_5%_2  [RSC_100X050X040_2]  197.7 54.27 0 bottom
R67066  RSC_0603  [RSC_160X080X080_2]  215.2 58.65 0 bottom
R67067  2K_5%_2  [RSC_100X050X040_2]  207.73 54.3 0 bottom
R67080  RSC_0402  [RSC_100X050X040_2]  128.39 51.74 90 top
R67081  1K_5%_2  [RSC_100X050X040_2]  130.57 59.53 270 top
R67082  1K_5%_2  [RSC_100X050X040_2]  131.46 59.53 270 top
R67083  1K_5%_2  [RSC_100X050X040_2]  132.35 59.53 270 top
R67084  1K_5%_2  [RSC_100X050X040_2]  133.24 59.53 270 top
R67085  1K_5%_2  [RSC_100X050X040_2]  134.13 59.53 270 top
R67086  1K_5%_2  [RSC_100X050X040_2]  135.02 59.53 270 top
R67087  66.5K_1%_2  [RSC_100X050X040_2]  127.12 58.4 90 top
R67088  1M_1%_2  [RSC_100X050X040_2]  128.9 58.88 90 top
R67089  RSC_0402  [RSC_100X050X040_2]  129.02 56.25 90 top
R67090  0_5%_2  [RSC_100X050X040_2]  127.75 55.71 180 top
R67091  4.99K_1%_2  [RSC_100X050X040_2]  128.25 53.91 180 top
R67092  402_1%_2  [RSC_100X050X040_2]  127 54.36 90 top
R67093  61.9K_1%_2  [RSC_100X050X040_2]  128.74 52.99 180 top
R67094  150_1%_2  [RSC_100X050X040_2]  129.28 51.74 270 top
R67095  RSC_0402  [RSC_100X050X040_2]  134.16 57.18 270 bottom
R67096  RSC_0402  [RSC_100X050X040_2]  135.05 57.18 270 bottom
R67099  0.005_1%_6  [RSC_320X160X080_4_P2]  160.4 46.74 0 top
R67199  0.005_1%_6  [RSC_320X160X080_4_P2]  169.03 45.72 90 bottom
R67200  100_5%_2  [RSC_100X050X040_2]  231.13 83.47 90 bottom
R67201  short_0402_5  [RSC_100X050X040_2_SHORT]  238.99 72.27 90 bottom
R67202  short_0402_5  [RSC_100X050X040_2_SHORT]  239.87 72.27 90 bottom
R67203  100_5%_2  [RSC_100X050X040_2]  242.52 74.63 0 bottom
R67204  4.7K_1%_2  [RSC_100X050X040_2]  245.92 80.7 180 bottom
R67205  7.87K_1%_2  [RSC_100X050X040_2]  243.4 79.81 180 bottom
R67206  25.5K_1%_2  [RSC_100X050X040_2]  243.4 78.92 0 bottom
R67207  60.4K_1%_2  [RSC_100X050X040_2]  243.4 80.7 0 bottom
R67208  short_0402_15  [RSC_100X050X040_2_15_SHORT]  245.92 79.81 180 bottom
R67209  10_5%_3  [RSC_160X080X080_2]  235.91 78.41 180 bottom
R67211  short_0402_5  [RSC_100X050X040_2_SHORT]  238.38 80.52 270 bottom
R67212  0_5%_2  [RSC_100X050X040_2]  245.01 78.92 0 bottom
R67215  2.2_5%_3  [RSC_160X080X080_2]  236.24 80.45 180 bottom
R67216  RSC_0603  [RSC_160X080X080_2]  215.46 77.32 90 bottom
R67217  432K_1%_2  [RSC_100X050X040_2]  243.46 76.41 180 bottom
R67218  2.2_5%_2  [RSC_100X050X040_2]  244.7 76.05 90 bottom
R67219  short_0402_5  [RSC_100X050X040_2_SHORT]  240.81 80.52 270 bottom
R67220  short_0402_5  [RSC_100X050X040_2_SHORT]  241.7 80.52 270 bottom
R67225  2.2_5%_3  [RSC_160X080X080_2]  235.94 74.48 180 bottom
R67226  RSC_0603  [RSC_160X080X080_2]  230.55 74.2 180 top
R67230  RSC_0402  [RSC_100X050X040_2]  244.6 81.33 90 top
R67231  RSC_0402  [RSC_100X050X040_2]  243.71 81.33 270 top
R67233  137K_1%_2  [RSC_100X050X040_2]  236.32 71.66 90 bottom
R67400  20.5K_1%_2  [RSC_100X050X040_2]  196.23 171.73 180 top
R67401  10K_1%_2  [RSC_100X050X040_2]  197.89 172.64 180 top
R67405  10K_5%_2  [RSC_100X050X040_2]  196.27 172.65 180 top
R67415  0_5%_3  [RSC_160X080X055_2]  197.91 178.74 90 top
R67416  RSC_0603  [RSC_160X080X080_2]  200.81 173.66 270 top
R67420  1K_1%_2  [RSC_100X050X040_2]  196.23 170.83 180 top
R67600  68K_1%_2  [RSC_100X050X040_2]  154.7 172.49 270 bottom
R67601  100K_1%_2  [RSC_100X050X040_2]  152.88 172.49 90 bottom
S2  -  [SCREW420_700_1P]  141.1 115.5 0 top
S3  -  [SCREW420_700_1P]  158.13 101.32 0 top
S4  -  [SCREW420_700_1P]  149.21 158.87 0 top
S5  -  [SCREW420_700_1P]  141.1 149.5 0 top
S6  -  [SCREW420_700_1P]  68.1 149.5 0 top
S7  -  [SCREW420_700_1P]  68.1 115.5 0 top
S9  -  [SCREW420_700_1P]  200.72 131.7 0 top
S10  -  [SCREW280_850_700_1P]  148.7 176.5 180 bottom
S11  -  [SCREW280_900_550_NP_1P]  11.26 27.7 270 top
S12  -  [SCREW390_700_1P]  294.65 89.56 0 top
S13  -  [SCREW280_700_1P]  285.55 131.16 0 top
S14  -  [SCREW280_700_1P]  308.15 89.56 0 top
S15  -  [SCREW280_700_1P]  303.25 170.11 0 top
S16  -  [SCREW280_850_700_1P]  90.2 176.4 180 bottom
S17  -  [SCREW280_700_1P]  312.81 4 0 top
S18  -  [SCREW280_700_1P]  214.7 92 0 top
S19  -  [SCREW280_700_1P]  26 79.28 0 top
S20  -  [SCREW280_700_1P]  213.22 177 0 top
S21  -  [SCREW280_700_1P]  68.18 177 0 top
S22  -  [SCREW280_700_1P]  300.7 79.28 0 top
S23  -  [SCREW280_700_1P]  162.7 22.15 0 top
S24  -  [SCREW280_700_1P]  63.2 98.4 0 top
S25  -  [SCREW390_850_700_1P]  301.2 44 180 bottom
S26  -  [SCREW390_1160_850_1P]  159.2 78 0 top
S27  -  [SCREW390_850_700_1P]  69.7 64 180 bottom
S28  -  [SCREW500_800_NP_1P]  259 89.28 270 top
S33  -  [SCREW500_900_NP_1P]  289.75 142.16 0 top
