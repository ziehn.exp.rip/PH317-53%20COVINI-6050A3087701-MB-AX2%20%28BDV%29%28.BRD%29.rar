# Allegro board PH317-53 COVINI-6050A3087701-MB-AX2 (BDV)(.BRD).brd (continued)
## Footprints (pads in the part's own frame, mm; a bottom-side part is the same pattern mirrored in y, then rotated) (continued)
IC-HALL_MST_3_SMD_105
  rect 0.787x0.787 smd: GND(0,1.01) OUTPUT(0.95,-1.01) VDD(-0.95,-1.01)
IC-MEMORY_MICRO_1400X1200X110
  round 0.381 smd: A1(4.875,-6.375) A2(4.125,-6.375) A3(3.375,-6.375) A4(2.625,-6.375) A5(1.875,-6.375) A10(-1.875,-6.375) A11(-2.625,-6.375) A12(-3.375,-6.375) A13(-4.125,-6.375) A14(-4.875,-6.375) B1(4.875,-5.625) B2(4.125,-5.625) B3(3.375,-5.625) B4(2.625,-5.625) B5(1.875,-5.625) B10(-1.875,-5.625) B11(-2.625,-5.625) B12(-3.375,-5.625) B13(-4.125,-5.625) B14(-4.875,-5.625) C1(4.875,-4.875) C2(4.125,-4.875) C3(3.375,-4.875) C4(2.625,-4.875) C5(1.875,-4.875) C10(-1.875,-4.875) C11(-2.625,-4.875) C12(-3.375,-4.875) C13(-4.125,-4.875) C14(-4.875,-4.875) D1(4.875,-4.125) D2(4.125,-4.125) D3(3.375,-4.125) D4(2.625,-4.125) D5(1.875,-4.125) D10(-1.875,-4.125) D11(-2.625,-4.125) D12(-3.375,-4.125) D13(-4.125,-4.125) D14(-4.875,-4.125) E1(4.875,-3.375) E2(4.125,-3.375) E3(3.375,-3.375) E4(2.625,-3.375) E5(1.875,-3.375) E10(-1.875,-3.375) E11(-2.625,-3.375) E12(-3.375,-3.375) E13(-4.125,-3.375) E14(-4.875,-3.375) F1(4.875,-2.625) F2(4.125,-2.625) F3(3.375,-2.625) F4(2.625,-2.625) F5(1.875,-2.625) F10(-1.875,-2.625) F11(-2.625,-2.625) F12(-3.375,-2.625) F13(-4.125,-2.625) F14(-4.875,-2.625) G1(4.875,-1.875) G2(4.125,-1.875) G3(3.375,-1.875) G4(2.625,-1.875) G5(1.875,-1.875) G10(-1.875,-1.875) G11(-2.625,-1.875) G12(-3.375,-1.875) G13(-4.125,-1.875) G14(-4.875,-1.875) H1(4.875,-1.125) H2(4.125,-1.125) H3(3.375,-1.125) H4(2.625,-1.125) H5(1.875,-1.125) H10(-1.875,-1.125) H11(-2.625,-1.125) H12(-3.375,-1.125) H13(-4.125,-1.125) H14(-4.875,-1.125) J1(4.875,-0.375) J2(4.125,-0.375) J3(3.375,-0.375) J4(2.625,-0.375) J5(1.875,-0.375) J10(-1.875,-0.375) J11(-2.625,-0.375) J12(-3.375,-0.375) J13(-4.125,-0.375) J14(-4.875,-0.375) K1(4.875,0.375) K2(4.125,0.375) K3(3.375,0.375) K4(2.625,0.375) K5(1.875,0.375) K10(-1.875,0.375) K11(-2.625,0.375) K12(-3.375,0.375) K13(-4.125,0.375) K14(-4.875,0.375) L1(4.875,1.125) L2(4.125,1.125) L3(3.375,1.125) L4(2.625,1.125) L5(1.875,1.125) L10(-1.875,1.125) L11(-2.625,1.125) L12(-3.375,1.125) L13(-4.125,1.125) L14(-4.875,1.125) M1(4.875,1.875) M2(4.125,1.875) M3(3.375,1.875) M4(2.625,1.875) M5(1.875,1.875) M10(-1.875,1.875) M11(-2.625,1.875) M12(-3.375,1.875) M13(-4.125,1.875) M14(-4.875,1.875) N1(4.875,2.625) N2(4.125,2.625) N3(3.375,2.625) N4(2.625,2.625) N5(1.875,2.625) N10(-1.875,2.625) N11(-2.625,2.625) N12(-3.375,2.625) N13(-4.125,2.625) N14(-4.875,2.625) P1(4.875,3.375) P2(4.125,3.375) P3(3.375,3.375) P4(2.625,3.375) P5(1.875,3.375) P10(-1.875,3.375) P11(-2.625,3.375) P12(-3.375,3.375) P13(-4.125,3.375) P14(-4.875,3.375) R1(4.875,4.125) R2(4.125,4.125) R3(3.375,4.125) R4(2.625,4.125) R5(1.875,4.125) R10(-1.875,4.125) R11(-2.625,4.125) R12(-3.375,4.125) R13(-4.125,4.125) R14(-4.875,4.125) T1(4.875,4.875) T2(4.125,4.875) T3(3.375,4.875) T4(2.625,4.875) T5(1.875,4.875) T10(-1.875,4.875) T11(-2.625,4.875) T12(-3.375,4.875) T13(-4.125,4.875) T14(-4.875,4.875) U1(4.875,5.625) U2(4.125,5.625) U3(3.375,5.625) U4(2.625,5.625) U5(1.875,5.625) U10(-1.875,5.625) U11(-2.625,5.625) U12(-3.375,5.625) U13(-4.125,5.625) U14(-4.875,5.625) V1(4.875,6.375) V2(4.125,6.375) V3(3.375,6.375) V4(2.625,6.375) V5(1.875,6.375) V10(-1.875,6.375) V11(-2.625,6.375) V12(-3.375,6.375) V13(-4.125,6.375) V14(-4.875,6.375)
KK-6019B1184301-001
  oval 0.297x0.711 smd: 1(-1.2,-0.966) 2(-0.8,-0.966) 3(-0.4,-0.966) 4(0,-0.966) 5(0.4,-0.966) 6(0.8,-0.966) 7(1.2,-0.966) 8(1.2,0.966) 9(0.8,0.966) 10(0.4,0.966) 11(0,0.966) 12(-0.4,0.966) 13(-0.8,0.966) 14(-1.2,0.966)
  rect 2.489x0.889 smd: 15(0,0)
LED_EVERLI_R_D_300X200X100
  rect 1.499x1.499 smd: 1(-1.75,0) 2(1.75,0)
  rect 0.889x0.889 smd: 3(0,0.65)
LQFP_1400X1400X160_128_040
  rect 0.297x1.473 smd: 1(-6.2,-7.8) 2(-5.799,-7.8) 3(-5.4,-7.8) 4(-5.001,-7.8) 5(-4.6,-7.8) 6(-4.201,-7.8) 7(-3.8,-7.8) 8(-3.401,-7.8) 9(-3,-7.8) 10(-2.601,-7.8) 11(-2.2,-7.8) 12(-1.801,-7.8) 13(-1.4,-7.8) 14(-1.001,-7.8) 15(-0.599,-7.8) 16(-0.201,-7.8) 17(0.201,-7.8) 18(0.599,-7.8) 19(1.001,-7.8) 20(1.4,-7.8) 21(1.801,-7.8) 22(2.2,-7.8) 23(2.601,-7.8) 24(3,-7.8) 25(3.401,-7.8) 26(3.8,-7.8) 27(4.201,-7.8) 28(4.6,-7.8) 29(5.001,-7.8) 30(5.4,-7.8) 31(5.799,-7.8) 32(6.2,-7.8) 65(6.2,7.8) 66(5.799,7.8) 67(5.4,7.8) 68(5.001,7.8) 69(4.6,7.8) 70(4.201,7.8) 71(3.8,7.8) 72(3.401,7.8) 73(3,7.8) 74(2.601,7.8) 75(2.2,7.8) 76(1.801,7.8) 77(1.4,7.8) 78(1.001,7.8) 79(0.599,7.8) 80(0.201,7.8) 81(-0.201,7.8) 82(-0.599,7.8) 83(-1.001,7.8) 84(-1.4,7.8) 85(-1.801,7.8) 86(-2.2,7.8) 87(-2.601,7.8) 88(-3,7.8) 89(-3.401,7.8) 90(-3.8,7.8) 91(-4.201,7.8) 92(-4.6,7.8) 93(-5.001,7.8) 94(-5.4,7.8) 95(-5.799,7.8) 96(-6.2,7.8)
  rect 1.473x0.297 smd: 33(7.8,-6.2) 34(7.8,-5.799) 35(7.8,-5.4) 36(7.8,-5.001) 37(7.8,-4.6) 38(7.8,-4.201) 39(7.8,-3.8) 40(7.8,-3.401) 41(7.8,-3) 42(7.8,-2.601) 43(7.8,-2.2) 44(7.8,-1.801) 45(7.8,-1.4) 46(7.8,-1.001) 47(7.8,-0.599) 48(7.8,-0.201) 49(7.8,0.201) 50(7.8,0.599) 51(7.8,1.001) 52(7.8,1.4) 53(7.8,1.801) 54(7.8,2.2) 55(7.8,2.601) 56(7.8,3) 57(7.8,3.401) 58(7.8,3.8) 59(7.8,4.201) 60(7.8,4.6) 61(7.8,5.001) 62(7.8,5.4) 63(7.8,5.799) 64(7.8,6.2) 97(-7.8,6.2) 98(-7.8,5.799) 99(-7.8,5.4) 100(-7.8,5.001) 101(-7.8,4.6) 102(-7.8,4.201) 103(-7.8,3.8) 104(-7.8,3.401) 105(-7.8,3) 106(-7.8,2.601) 107(-7.8,2.2) 108(-7.8,1.801) 109(-7.8,1.4) 110(-7.8,1.001) 111(-7.8,0.599) 112(-7.8,0.201) 113(-7.8,-0.201) 114(-7.8,-0.599) 115(-7.8,-1.001) 116(-7.8,-1.4) 117(-7.8,-1.801) 118(-7.8,-2.2) 119(-7.8,-2.601) 120(-7.8,-3) 121(-7.8,-3.401) 122(-7.8,-3.8) 123(-7.8,-4.201) 124(-7.8,-4.6) 125(-7.8,-5.001) 126(-7.8,-5.4) 127(-7.8,-5.799) 128(-7.8,-6.2)
LS_100X050X055_2
  custom 0.112x0.112 smd: 1(-0.427,0) 2(0.424,0)
LS_125X100X065_4_055
  rect 0.508x0.305 smd: 1(-0.625,0.275) 2(-0.625,-0.275) 3(0.625,-0.275) 4(0.625,0.275)
LS_160X080X095_2
  rect 0.813x0.813 smd: 1(-0.6,0) 2(0.6,0)
LS_200X120X140_4_080
  rect 0.889x0.406 smd: 1(-0.851,0.401) 2(-0.851,-0.401) 3(0.851,-0.401) 4(0.851,0.401)
LS_200X125X110_2
  rect 0.813x1.295 smd: 1(-0.9,0) 2(0.9,0)
LS_250X200X120_2_170
  rect 0.889x2.108 smd: 1(-0.85,0) 2(0.85,0)
LS_400X400X180_2_280
  rect 1.194x3.708 smd: 1(-1.4,0) 2(1.4,0)
LS_485X470X300_2_500
  rect 2.007x2.489 smd: 1(-2.499,0) 2(2.499,0)
LS_500X500X200_2_340_P2
  rect 1.6x3.988 smd: 1(-1.702,0) 2(1.702,0)
LS_540X520X180_4_P2
  rect 0.381x0.457 smd: (-2.569,0.007) (2.569,0)
  custom 0.476x0.476 smd: 1(-2.047,0.635) 2(2.047,0.635)
  rect 1.295x0.254 smd: 3(-1.743,0) 4(1.743,0)
LS_660X660X240_2_555
  rect 1.854x3.505 smd: 1(-2.776,0) 2(2.776,0)
LS_660X660X300_4_P3
  rect 0.381x0.457 smd: (-3.296,0.002) (3.294,0.001)
  custom 0.462x0.462 smd: 1(-2.776,1.008) 2(2.776,1.008)
  rect 1.295x0.254 smd: 3(-2.503,0) 4(2.501,0)
LS_660X660X300_4_P4
  rect 0.381x0.457 smd: (-3.784,-0.002) (3.784,0.001)
  custom 0.591x0.591 smd: 1(-3.025,1.008) 2(3.025,1.008)
  rect 1.778x0.254 smd: 3(-2.733,0) 4(2.733,0)
LS_660X660X400_4_P2
  rect 0.457x0.457 smd: (-3.747,0) (3.744,0.002)
  custom 0.591x0.591 smd: 1(-3.025,1.008) 2(3.025,1.008)
  rect 1.702x0.254 smd: 3(-2.695,0) 4(2.695,0)
LS_700X660X300_2_555
  rect 1.953x3.505 smd: 1(-2.776,0) 2(2.776,0)
LS_1100X720X390_4
  rect 0.381x0.457 smd: (-5.827,0) (5.828,0)
  custom 0.749x0.749 smd: 1(-4.75,0.762) 2(4.75,0.762)
  rect 2.413x0.254 smd: 3(-4.458,0) 4(4.458,0)
LS_1120X720X400_4
  rect 0.381x0.457 smd: (-5.827,0) (5.828,0)
  custom 0.749x0.749 smd: 1(-4.75,0.762) 2(4.75,0.762)
  rect 2.413x0.254 smd: 3(-4.458,0) 4(4.458,0)
LS_SHORT_0504
  rect 0.889x0.127 smd: (0,-0.275) (0,0.275)
  rect 0.508x0.305 smd: 1(-0.625,0.275) 2(-0.625,-0.275) 3(0.625,-0.275) 4(0.625,0.275)
MOSFET_300X300X090_8_065
  rect 0.432x0.869 smd: 1(-0.975,-1.4) 2(-0.325,-1.4) 3(0.325,-1.4) 4(0.975,-1.4)
  custom 0.636x0.636 smd: 5(0.975,1.527)
  rect 0.432x0.744 smd: 6(0.325,1.527) 7(-0.325,1.527) 8(-0.975,1.527)
MOSFET_300X300X100_8_065
  rect 0.432x0.869 smd: 1(-0.975,-1.4) 2(-0.325,-1.4) 3(0.325,-1.4) 4(0.975,-1.4)
  custom 0.636x0.636 smd: 5(0.975,1.527)
  rect 0.432x0.744 smd: 6(0.325,1.527) 7(-0.325,1.527) 8(-0.975,1.527)
MOSFET_300X300X112_8_065
  rect 0.432x0.869 smd: 1(-0.975,-1.4) 2(-0.325,-1.4) 3(0.325,-1.4) 4(0.975,-1.4)
  custom 0.636x0.636 smd: 5(0.975,1.527)
  rect 0.432x0.744 smd: 6(0.325,1.527) 7(-0.325,1.527) 8(-0.975,1.527)
MOSFET_500X600X100_8_127
  rect 0.61x1.473 smd: 1(-1.905,-2.756) 2(-0.635,-2.756) 3(0.635,-2.756) 4(1.905,-2.756)
  custom 1.274x1.274 smd: 5(1.905,2.797)
  rect 0.61x1.245 smd: 6(0.635,2.797) 7(-0.635,2.797) 8(-1.905,2.797)
MQFN_600X600X100_48_040_T1
  rect 0.297x0.864 smd: 1(-2.2,-2.901) 2(-1.801,-2.901) 3(-1.4,-2.901) 4(-1.001,-2.901) 5(-0.599,-2.901) 6(-0.201,-2.901) 7(0.201,-2.901) 8(0.599,-2.901) 9(1.001,-2.901) 10(1.4,-2.901) 11(1.801,-2.901) 12(2.2,-2.901) 25(2.2,2.901) 26(1.801,2.901) 27(1.4,2.901) 28(1.001,2.901) 29(0.599,2.901) 30(0.201,2.901) 31(-0.201,2.901) 32(-0.599,2.901) 33(-1.001,2.901) 34(-1.4,2.901) 35(-1.801,2.901) 36(-2.2,2.901)
  rect 0.864x0.297 smd: 13(2.901,-2.2) 14(2.901,-1.801) 15(2.901,-1.4) 16(2.901,-1.001) 17(2.901,-0.599) 18(2.901,-0.201) 19(2.901,0.201) 20(2.901,0.599) 21(2.901,1.001) 22(2.901,1.4) 23(2.901,1.801) 24(2.901,2.2) 37(-2.901,2.2) 38(-2.901,1.801) 39(-2.901,1.4) 40(-2.901,1.001) 41(-2.901,0.599) 42(-2.901,0.201) 43(-2.901,-0.201) 44(-2.901,-0.599) 45(-2.901,-1.001) 46(-2.901,-1.4) 47(-2.901,-1.801) 48(-2.901,-2.2)
  rect 4.394x4.394 smd: 49(0,0)
MSOP_300X300X110_8_065_P3
  rect 0.508x1.295 smd: 1(-0.975,-2.197) 2(-0.325,-2.197) 3(0.325,-2.197) 4(0.975,-2.197) 5(0.975,2.197) 6(0.325,2.197) 7(-0.325,2.197) 8(-0.975,2.197)
POWERPAD1X1M
  custom 0.194x0.194 smd: 1(-0.437,0) 2(0.437,0)
POWERPAD_2_0610
  custom 0.252x0.252 smd: 1(0,0) 2(1.27,0)
POWERPAD_4_0610_SHORT
  rect 0.229x0.838 smd: (0.17,-0.775)
  rect 0.635x0.229 smd: (0.577,-0.47)
  rect 0.399x0.254 smd: (1.185,-0.607)
  custom 0.252x0.252 smd: 1(0,0) 2(1.27,0)
  rect 0.635x0.635 smd: 3(0.577,-0.876)
  rect 0.399x0.5 smd: 4(1.185,-0.944)
PQFN_500X500X080_31_050_T2
  rect 0.356x0.686 smd: 1(-1.75,-2.4) 2(-1.25,-2.4) 3(-0.75,-2.4) 4(-0.25,-2.4) 5(0.25,-2.4) 6(0.75,-2.4) 7(1.25,-2.4) 8(1.75,-2.4) 17(1.25,2.4) 18(0.75,2.4) 19(0.25,2.4) 20(-0.25,2.4) 21(-0.75,2.4) 22(-1.25,2.4) 23(-1.75,2.4)
  rect 0.686x0.356 smd: 9(2.4,-1.75) 10(2.4,-1.25) 13(2.4,0.75) 14(2.4,1.25) 15(2.4,1.75) 25(-2.4,1.25) 26(-2.4,0.75) 28(-2.4,-0.25) 29(-2.4,-0.75) 30(-2.4,-1.25) 31(-2.4,-1.75)
  custom 0.279x0.279 smd: 11(2.4,-0.75)
  custom 0.508x0.508 smd: 12(2.4,0.25)
  rect 3.861x0.686 smd: 16(1.75,2.4)
  rect 0.686x1.346 smd: 24(-2.4,1.75)
  rect 0.635x0.356 smd: 27(-2.4,0.25)
  rect 1.422x1.118 smd: 32(-1.05,-1.185)
  rect 0.559x0.297 smd: 33(-1.66,0.225)
PUMBAA-6011A0029102-004
  rect 0.889x0.658 smd: 1(-1.1,0) 2(1.1,0)
QFN_300X200X100_12_050
  rect 0.356x1.575 smd: 1(-0.5,-0.55) 2(0.5,-0.55) 7(0,0.55)
  rect 0.787x0.356 smd: 3(1.45,-0.75) 4(1.45,-0.25) 5(1.45,0.25) 6(1.45,0.75) 9(-1.45,0.75) 10(-1.45,0.25) 11(-1.45,-0.25) 12(-1.45,-0.75)
  rect 0.356x0.787 smd: 8(-0.5,0.95)
QFN_300X200X100_13_050
  rect 0.356x1.575 smd: 1(-0.5,-0.55) 2(0.5,-0.55) 8(0,0.55)
  rect 0.787x0.356 smd: 3(1.45,-0.75) 4(1.45,-0.25) 5(1.45,0.25) 6(1.45,0.75) 10(-1.45,0.75) 11(-1.45,0.25) 12(-1.45,-0.25) 13(-1.45,-0.75)
  rect 0.356x0.787 smd: 7(0.5,0.95) 9(-0.5,0.95)
QFN_300X300X080_16_050_T1
  custom 0.089x0.089 smd: 1(-0.752,-1.476) 2(-0.249,-1.476) 3(0.249,-1.476) 4(0.752,-1.476) 5(1.476,-0.752) 6(1.476,-0.249) 7(1.476,0.249) 8(1.476,0.752) 9(0.752,1.476) 10(0.249,1.476) 11(-0.249,1.476) 12(-0.752,1.476) 13(-1.476,0.752) 14(-1.476,0.249) 15(-1.476,-0.249) 16(-1.476,-0.752)
  rect 1.702x1.702 smd: 17(0,0)
QFN_300X300X080_20_040_T2
  rect 0.297x0.686 smd: 1(-0.8,-1.4) 2(-0.401,-1.4) 3(0,-1.4) 4(0.401,-1.4) 5(0.8,-1.4) 11(0.8,1.4) 12(0.401,1.4) 13(0,1.4) 14(-0.401,1.4) 15(-0.8,1.4)
  rect 0.686x0.297 smd: 6(1.4,-0.8) 7(1.4,-0.401) 8(1.4,0) 9(1.4,0.401) 10(1.4,0.8) 16(-1.4,0.8) 17(-1.4,0.401) 18(-1.4,0) 19(-1.4,-0.401) 20(-1.4,-0.8)
  rect 1.702x1.702 smd: 21(0,0)
QFN_300X300X090_20_045_T1
  custom 0.074x0.074 smd: 1(-0.9,-1.45) 5(0.9,-1.45) 6(1.45,-0.9) 10(1.45,0.9) 11(0.9,1.45) 15(-0.9,1.45) 16(-1.45,0.9) 20(-1.45,-0.9)
  rect 0.297x0.787 smd: 2(-0.45,-1.45) 3(0,-1.45) 4(0.45,-1.45) 12(0.45,1.45) 13(0,1.45) 14(-0.45,1.45)
  rect 0.787x0.297 smd: 7(1.45,-0.45) 8(1.45,0) 9(1.45,0.45) 17(-1.45,0.45) 18(-1.45,0) 19(-1.45,-0.45)
  custom 0.15x0.15 smd: 21(0,0)
QFN_300X300X090_20_045_T2
  custom 0.075x0.075 smd: 1(-0.9,-1.45) 5(0.9,-1.45) 6(1.45,-0.9) 10(1.45,0.9) 11(0.9,1.45) 15(-0.9,1.45) 16(-1.45,0.9) 20(-1.45,-0.9)
  rect 0.297x0.762 smd: 2(-0.45,-1.45) 3(0,-1.45) 4(0.45,-1.45) 12(0.45,1.45) 13(0,1.45) 14(-0.45,1.45)
  rect 0.762x0.297 smd: 7(1.45,-0.45) 8(1.45,0) 9(1.45,0.45) 17(-1.45,0.45) 18(-1.45,0) 19(-1.45,-0.45)
  rect 1.092x1.092 smd: 21(0,0)
QFN_300X300X100_16_050_P1
  rect 0.356x2.184 smd: 1(-0.5,-0.75) 2(0.5,-0.75) 9(0,0.75)
  rect 0.787x0.356 smd: 3(1.45,-1.25) 4(1.45,-0.75) 5(1.45,-0.25) 6(1.45,0.25) 7(1.45,0.75) 8(1.45,1.25) 11(-1.45,1.25) 12(-1.45,0.75) 13(-1.45,0.25) 14(-1.45,-0.25) 15(-1.45,-0.75) 16(-1.45,-1.25)
  rect 0.356x0.965 smd: 10(-0.5,1.359)
QFN_400X400X100_32_040_T2
  custom 0.074x0.074 smd: 1(-1.4,-1.862) 8(1.4,-1.862) 9(1.862,-1.4) 16(1.862,1.4) 17(1.4,1.862) 24(-1.4,1.862) 25(-1.862,1.4) 32(-1.862,-1.4)
  rect 0.297x0.66 smd: 2(-1.001,-1.862) 3(-0.599,-1.862) 4(-0.201,-1.862) 5(0.201,-1.862) 6(0.599,-1.862) 7(1.001,-1.862) 18(1.001,1.862) 19(0.599,1.862) 20(0.201,1.862) 21(-0.201,1.862) 22(-0.599,1.862) 23(-1.001,1.862)
  rect 0.66x0.297 smd: 10(1.862,-1.001) 11(1.862,-0.599) 12(1.862,-0.201) 13(1.862,0.201) 14(1.862,0.599) 15(1.862,1.001) 26(-1.862,1.001) 27(-1.862,0.599) 28(-1.862,0.201) 29(-1.862,-0.201) 30(-1.862,-0.599) 31(-1.862,-1.001)
  rect 2.794x2.794 smd: 33(0,0)
QFN_500X500X080_32_050_T7
  custom 0.089x0.089 smd: 1(-1.75,-2.499) 2(-1.25,-2.499) 3(-0.752,-2.499) 4(-0.249,-2.499) 5(0.249,-2.499) 6(0.752,-2.499) 7(1.25,-2.499) 8(1.75,-2.499) 9(2.499,-1.75) 10(2.499,-1.25) 11(2.499,-0.752) 12(2.499,-0.249) 13(2.499,0.249) 14(2.499,0.752) 15(2.499,1.25) 16(2.499,1.75) 17(1.75,2.499) 18(1.25,2.499) 19(0.752,2.499) 20(0.249,2.499) 21(-0.249,2.499) 22(-0.752,2.499) 23(-1.25,2.499) 24(-1.75,2.499) 25(-2.499,1.75) 26(-2.499,1.25) 27(-2.499,0.752) 28(-2.499,0.249) 29(-2.499,-0.249) 30(-2.499,-0.752) 31(-2.499,-1.25) 32(-2.499,-1.75)
  rect 3.505x3.505 smd: 33(0,0)
QFN_500X500X090_40_040_T2
  rect 0.297x0.965 smd: 1(-1.801,-2.55) 2(-1.4,-2.55) 3(-1.001,-2.55) 4(-0.599,-2.55) 5(-0.201,-2.55) 6(0.201,-2.55) 7(0.599,-2.55) 8(1.001,-2.55) 9(1.4,-2.55) 10(1.801,-2.55) 21(1.801,2.55) 22(1.4,2.55) 23(1.001,2.55) 24(0.599,2.55) 25(0.201,2.55) 26(-0.201,2.55) 27(-0.599,2.55) 28(-1.001,2.55) 29(-1.4,2.55) 30(-1.801,2.55)
  rect 0.965x0.297 smd: 11(2.55,-1.801) 12(2.55,-1.4) 13(2.55,-1.001) 14(2.55,-0.599) 15(2.55,-0.201) 16(2.55,0.201) 17(2.55,0.599) 18(2.55,1.001) 19(2.55,1.4) 20(2.55,1.801) 31(-2.55,1.801) 32(-2.55,1.4) 33(-2.55,1.001) 34(-2.55,0.599) 35(-2.55,0.201) 36(-2.55,-0.201) 37(-2.55,-0.599) 38(-2.55,-1.001) 39(-2.55,-1.4) 40(-2.55,-1.801)
  rect 3.505x3.505 smd: 41(0,0)
QFN_500X500X100_40_040_T6
  rect 0.297x0.787 smd: 1(-1.8,-2.45) 2(-1.4,-2.45) 3(-1,-2.45) 4(-0.6,-2.45) 5(-0.2,-2.45) 6(0.2,-2.45) 7(0.6,-2.45) 8(1,-2.45) 9(1.4,-2.45) 10(1.8,-2.45) 21(1.8,2.45) 22(1.4,2.45) 23(1,2.45) 24(0.6,2.45) 25(0.2,2.45) 26(-0.2,2.45) 27(-0.6,2.45) 28(-1,2.45) 29(-1.4,2.45) 30(-1.8,2.45)
  rect 0.787x0.297 smd: 11(2.45,-1.8) 12(2.45,-1.4) 13(2.45,-1) 14(2.45,-0.6) 15(2.45,-0.2) 16(2.45,0.2) 17(2.45,0.6) 18(2.45,1) 19(2.45,1.4) 20(2.45,1.8) 31(-2.45,1.8) 32(-2.45,1.4) 33(-2.45,1) 34(-2.45,0.6) 35(-2.45,0.2) 36(-2.45,-0.2) 37(-2.45,-0.6) 38(-2.45,-1) 39(-2.45,-1.4) 40(-2.45,-1.8)
  rect 3.708x3.708 smd: 41(0,0)
QFN_600X600X090_48_040_T13
  rect 0.297x0.737 smd: 1(-2.2,-2.875) 2(-1.801,-2.875) 3(-1.4,-2.875) 4(-1.001,-2.875) 5(-0.599,-2.875) 6(-0.201,-2.875) 7(0.201,-2.875) 8(0.599,-2.875) 9(1.001,-2.875) 10(1.4,-2.875) 11(1.801,-2.875) 12(2.2,-2.875) 25(2.2,2.875) 26(1.801,2.875) 27(1.4,2.875) 28(1.001,2.875) 29(0.599,2.875) 30(0.201,2.875) 31(-0.201,2.875) 32(-0.599,2.875) 33(-1.001,2.875) 34(-1.4,2.875) 35(-1.801,2.875) 36(-2.2,2.875)
  rect 0.737x0.297 smd: 13(2.875,-2.2) 14(2.875,-1.801) 15(2.875,-1.4) 16(2.875,-1.001) 17(2.875,-0.599) 18(2.875,-0.201) 19(2.875,0.201) 20(2.875,0.599) 21(2.875,1.001) 22(2.875,1.4) 23(2.875,1.801) 24(2.875,2.2) 37(-2.875,2.2) 38(-2.875,1.801) 39(-2.875,1.4) 40(-2.875,1.001) 41(-2.875,0.599) 42(-2.875,0.201) 43(-2.875,-0.201) 44(-2.875,-0.599) 45(-2.875,-1.001) 46(-2.875,-1.4) 47(-2.875,-1.801) 48(-2.875,-2.2)
  rect 4.496x4.496 smd: 49(0,0)
QFN_600X600X100_52_040_T1
  custom 0.074x0.074 smd: 1(-2.4,-2.885) 13(2.4,-2.885) 14(2.885,-2.4) 26(2.885,2.4) 27(2.4,2.885) 39(-2.4,2.885) 40(-2.885,2.4) 52(-2.885,-2.4)
  rect 0.297x0.711 smd: 2(-2.002,-2.885) 3(-1.6,-2.885) 4(-1.201,-2.885) 5(-0.8,-2.885) 6(-0.401,-2.885) 7(0,-2.885) 8(0.401,-2.885) 9(0.8,-2.885) 10(1.201,-2.885) 11(1.6,-2.885) 12(2.002,-2.885) 28(2.002,2.885) 29(1.6,2.885) 30(1.201,2.885) 31(0.8,2.885) 32(0.401,2.885) 33(0,2.885) 34(-0.401,2.885) 35(-0.8,2.885) 36(-1.201,2.885) 37(-1.6,2.885) 38(-2.002,2.885)
  rect 0.711x0.297 smd: 15(2.885,-2.002) 16(2.885,-1.6) 17(2.885,-1.201) 18(2.885,-0.8) 19(2.885,-0.401) 20(2.885,0) 21(2.885,0.401) 22(2.885,0.8) 23(2.885,1.201) 24(2.885,1.6) 25(2.885,2.002) 41(-2.885,2.002) 42(-2.885,1.6) 43(-2.885,1.201) 44(-2.885,0.8) 45(-2.885,0.401) 46(-2.885,0) 47(-2.885,-0.401) 48(-2.885,-0.8) 49(-2.885,-1.201) 50(-2.885,-1.6) 51(-2.885,-2.002)
  rect 4.801x4.801 smd: 53(0,0)
RANGER11-6010A0057701-003
  rect 0.813x0.813 smd: 1(-0.6,0) 2(0.6,0)
RANGERS-6010B0044902-001
  rect 0.813x0.813 smd: 1(-0.6,0) 2(0.6,0)
REBORN-6010B0044901-003
  rect 0.813x0.813 smd: 1(-0.787,0) 2(0.787,0)
RJ45_SIGAT_8_SS_N_470
  round 1.194 hole 0.889: 1(3.57,4.63) 2(2.55,5.73) 3(1.53,4.63) 4(0.51,5.73) 5(-0.51,4.63) 6(-1.53,5.73) 7(-2.55,4.63) 8(-3.57,5.73)
  oval 0.991x2.388 hole 0.61x2.007: G1(9.15,0) G2(-9.15,0) G3(9.15,-6.3) G4(-9.15,-6.3)
RSC_060X030X030_2
  custom 0.075x0.075 smd: 1(-0.249,0) 2(0.249,0)
RSC_100X050X035_2
  custom 0.112x0.112 smd: 1(-0.427,0) 2(0.424,0)
RSC_100X050X040_2
  custom 0.112x0.112 smd: 1(-0.427,0) 2(0.424,0)
RSC_100X050X040_2_15_NSP_SHORT
  rect 0.457x0.381 smd: (0,0)
  custom 0.112x0.112 smd: 1(-0.427,0) 2(0.424,0)
RSC_100X050X040_2_15_SHORT
  rect 0.457x0.381 smd: (0,0)
  custom 0.112x0.112 smd: 1(-0.427,0) 2(0.424,0)
RSC_100X050X040_2_NSP_SHORT
  rect 0.508x0.127 smd: (0,0)
  custom 0.112x0.112 smd: 1(-0.427,0) 2(0.424,0)
RSC_100X050X040_2_SHORT
  rect 0.508x0.127 smd: (0,0)
  custom 0.112x0.112 smd: 1(-0.427,0) 2(0.424,0)
RSC_100X050X055_2
  custom 0.112x0.112 smd: 1(-0.427,0) 2(0.424,0)
RSC_160X080X055_2
  rect 0.813x0.813 smd: 1(-0.6,0) 2(0.6,0)
RSC_160X080X080_2
  rect 0.813x0.813 smd: 1(-0.6,0) 2(0.6,0)
RSC_160X080X080_2_25_SHORT
  rect 0.508x0.635 smd: (0,0)
  rect 0.813x0.813 smd: 1(-0.6,0) 2(0.6,0)
RSC_200X125X115_2
  rect 0.813x1.295 smd: 1(-0.9,0) 2(0.9,0)
RSC_200X125X130_2
  rect 0.813x1.295 smd: 1(-0.9,0) 2(0.9,0)
RSC_320X160X080_4_P2
  rect 0.254x0.508 smd: (-1.741,0.001) (1.741,0.001)
  custom 0.349x0.349 smd: 1(-1.989,0.508) 2(1.989,0.508)
  rect 0.914x0.254 smd: 3(-1.168,0) 4(1.168,0)
RSC_320X160X089_4_P2
  rect 0.254x0.508 smd: (-1.741,0.001) (1.741,0.001)
  custom 0.349x0.349 smd: 1(-1.989,0.508) 2(1.989,0.508)
  rect 0.914x0.254 smd: 3(-1.168,0) 4(1.168,0)
SCREW280_700_1P
  round 7.01 hole 2.794: 1(0,0)
SCREW280_850_700_1P
  round 7.01 hole 2.794: 1(0,0)
SCREW280_900_550_NP_1P
  round 2.794 hole 2.794 unplated: (0,0)
  custom 2.248x2.248 hole 0.406: 1(0,2.159)
SCREW280_900_700_1P
  round 8.992 hole 2.794: 1(0,0)
SCREW390_700_1P
  round 7.01 hole 3.912: 1(0,0)
SCREW390_850_700_1P
  round 7.01 hole 3.912: 1(0,0)
SCREW390_1160_850_1P
  round 11.608 hole 3.912: 1(0,0)
SCREW420_700_1P
  round 7.01 hole 4.191: 1(0,0)
SCREW500_800_NP_1P
  round 5.004 hole 5.004 unplated: (0,0)
  custom 1.999x1.999 hole 0.406: 1(0,3.15)
SCREW500_900_NP_1P
  round 5.004 hole 5.004 unplated: (0,0)
  custom 2.248x2.248 hole 0.406: 1(0,3.429)
SKT-BIOS_ACES_970X920X500
  rect 0.889x1.346 smd: 1(2.576,3.675) 2(1.306,3.675) 3(0.036,3.675) 4(-1.234,3.675) 5(-1.234,-3.675) 6(0.036,-3.675) 7(1.306,-3.675) 8(2.576,-3.675)
SMDTEST26
  round 0.66 smd: 1(0,0)
SNAPE-6014B0296001-003
  rect 0.381x0.457 smd: (-6.372,0) (6.372,0)
  custom 0.772x0.772 smd: 1(-4.75,1.008) 2(4.75,1.008)
  rect 3.531x0.254 smd: 3(-4.47,0) 4(4.47,0)
SON_200X200X080_8_050_T1
  rect 0.356x0.584 smd: 1(-0.752,-0.95) 2(-0.249,-0.95) 3(0.249,-0.95) 4(0.752,-0.95) 5(0.752,0.95) 6(0.249,0.95) 7(-0.249,0.95) 8(-0.752,0.95)
  rect 1.6x0.899 smd: 9(0,0)
SOP_490X390X175_8_127
  rect 0.66x1.651 smd: 1(-1.905,-2.667) 2(-0.635,-2.667) 3(0.635,-2.667) 4(1.905,-2.667) 5(1.905,2.667) 6(0.635,2.667) 7(-0.635,2.667) 8(-1.905,2.667)
SOP_528X528X216_8_127
  rect 0.66x1.524 smd: 1(-1.905,-3.747) 2(-0.635,-3.747) 3(0.635,-3.747) 4(1.905,-3.747) 5(1.905,3.747) 6(0.635,3.747) 7(-0.635,3.747) 8(-1.905,3.747)
SOP_1560X850X240_24_127
  rect 0.813x1.549 smd: 1(-6.985,-4.475) 2(-5.715,-4.475) 3(-4.445,-4.475) 4(-3.175,-4.475) 5(-1.905,-4.475) 6(-0.635,-4.475) 7(0.635,-4.475) 8(1.905,-4.475) 9(3.175,-4.475) 10(4.445,-4.475) 11(5.715,-4.475) 12(6.985,-4.475) 13(6.985,4.475) 14(5.715,4.475) 15(4.445,4.475) 16(3.175,4.475) 17(1.905,4.475) 18(0.635,4.475) 19(-0.635,4.475) 20(-1.905,4.475) 21(-3.175,4.475) 22(-4.445,4.475) 23(-5.715,4.475) 24(-6.985,4.475)
SOT23_290X160X145_3_095
  rect 0.61x0.94 smd: 1(-0.95,-1.225) 2(0.95,-1.225) 3(0,1.225)
SOT23_292X130X110_3_095
  rect 0.787x0.889 smd: D(0,1) G(-0.95,-1) S(0.95,-1)
SOT323_200X125X110_3_065_P3
  rect 0.66x0.864 smd: D(0,0.925) G(-0.65,-0.925) S(0.65,-0.925)
SOT363_205X125X110_6_065_P3
  rect 0.457x0.508 smd: 1(-0.65,-0.95) 2(0,-0.95) 3(0.65,-0.95) 4(0.65,0.95) 5(0,0.95) 6(-0.65,0.95)
SSOP_200X125X100_5_065
  rect 0.406x1.016 smd: 1(-0.65,-1.049) 2(0,-1.049) 3(0.65,-1.049) 4(0.65,1.049) 5(-0.65,1.049)
STD_R_FF45031_D30007_M20375_SN
  round 3.505 hole 3.2: 1(0,0)
SWCH-TACT_DIP_4_SMD_V_060
  rect 0.559x0.559 smd: 1(-1.275,0.58) 2(1.275,0.58) 3(-1.275,-0.58) 4(1.275,-0.58)
TDFN_200X200X080_8_050_T6
  rect 0.356x0.61 smd: 1(-0.75,-0.97)
  oval 0.356x0.61 smd: 2(-0.25,-0.97) 3(0.25,-0.97) 4(0.75,-0.97) 5(0.75,0.97) 6(0.25,0.97) 7(-0.25,0.97) 8(-0.75,0.97)
  rect 1.295x0.787 smd: 9(0,0)
TP24
  round 0.61 smd: 1(0,0)
TQFN_400X400X080_24_050_T6
  rect 0.356x0.787 smd: 1(-1.25,-2) 2(-0.75,-2) 3(-0.25,-2) 4(0.25,-2) 5(0.75,-2) 6(1.25,-2) 13(1.25,2) 14(0.75,2) 15(0.25,2) 16(-0.25,2) 17(-0.75,2) 18(-1.25,2)
  rect 0.787x0.356 smd: 7(2,-1.25) 8(2,-0.75) 9(2,-0.25) 10(2,0.25) 11(2,0.75) 12(2,1.25) 19(-2,1.25) 20(-2,0.75) 21(-2,0.25) 22(-2,-0.25) 23(-2,-0.75) 24(-2,-1.25)
  rect 2.692x2.692 smd: 25(0,0)
TQFN_450X250X080_30_040_T1
  custom 0.074x0.074 smd: 1(-1.8,-1.25) 2(-1.4,-1.25) 3(-1,-1.25) 4(-0.6,-1.25) 5(-0.2,-1.25) 6(0.2,-1.25) 7(0.6,-1.25) 8(1,-1.25) 9(1.4,-1.25) 10(1.8,-1.25) 11(2.25,-0.8) 12(2.25,-0.4) 13(2.25,0) 14(2.25,0.4) 15(2.25,0.8) 16(1.8,1.25) 17(1.4,1.25) 18(1,1.25) 19(0.6,1.25) 20(0.2,1.25) 21(-0.2,1.25) 22(-0.6,1.25) 23(-1,1.25) 24(-1.4,1.25) 25(-1.8,1.25) 26(-2.25,0.8) 27(-2.25,0.4) 28(-2.25,0) 29(-2.25,-0.4) 30(-2.25,-0.8)
  rect 3.2x1.194 smd: 31(0,0)
TQFN_500X300X080_21_040
  rect 0.305x1.6 smd: 1(-1.475,-1) 2(-0.825,-1) 3(0.275,-1) 4(1.375,-1) 12(0.825,1) 13(-0.275,1) 14(-1.475,1)
  rect 0.914x0.297 smd: 5(2.375,-1.2) 6(2.375,-0.8) 7(2.375,-0.4) 9(2.375,0.4) 10(2.375,0.8) 11(2.375,1.2) 16(-2.375,0.8) 17(-2.375,0.4) 18(-2.375,0) 19(-2.375,-0.4) 20(-2.375,-0.8)
  custom 0.229x0.229 smd: 8(2.375,0)
  custom 0.197x0.197 smd: 15(-2.375,1.2) 21(-2.375,-1.2)
TQFN_900X350X084_42_050_T4
  rect 0.356x0.711 smd: 1(-4,-1.59) 2(-3.5,-1.59) 3(-3,-1.59) 4(-2.499,-1.59) 5(-2.002,-1.59) 6(-1.501,-1.59) 7(-1.001,-1.59) 8(-0.5,-1.59) 9(0,-1.59) 10(0.5,-1.59) 11(1.001,-1.59) 12(1.501,-1.59) 13(2.002,-1.59) 14(2.499,-1.59) 15(3,-1.59) 16(3.5,-1.59) 17(4,-1.59) 22(4,1.59) 23(3.5,1.59) 24(3,1.59) 25(2.499,1.59) 26(2.002,1.59) 27(1.501,1.59) 28(1.001,1.59) 29(0.5,1.59) 30(0,1.59) 31(-0.5,1.59) 32(-1.001,1.59) 33(-1.501,1.59) 34(-2.002,1.59) 35(-2.499,1.59) 36(-3,1.59) 37(-3.5,1.59) 38(-4,1.59)
  rect 0.711x0.356 smd: 18(4.341,-0.752) 19(4.341,-0.249) 20(4.341,0.249) 21(4.341,0.752) 39(-4.341,0.752) 40(-4.341,0.249) 41(-4.341,-0.249) 42(-4.341,-0.752)
  rect 7.01x1.803 smd: 43(0,0)
TSEMT6_160X120X050_6_050_2
  rect 0.356x0.584 smd: 1(-0.5,-0.7) 2(0,-0.7) 3(0.5,-0.7) 4(0.5,0.7) 5(0,0.7) 6(-0.5,0.7)
TSMOS_530X555X100_8_127_T2
  rect 0.66x0.635 smd: 1(-1.905,-2.835) 2(-0.635,-2.835) 3(0.635,-2.835) 5(1.905,2.835) 6(0.635,2.835) 7(-0.635,2.835) 8(-1.905,2.835)
  custom 0.486x0.486 smd: 4(1.905,-2.835)
  rect 3.988x2.159 smd: 9(0,0.526)
TSOT23_290X130X110_3_096
  rect 0.508x1.295 smd: B(-0.96,-1.049) C(0,1.049) E(0.96,-1.049)
TSOT23_290X130X110_3_096_P1
  rect 0.508x1.295 smd: 1(-0.96,-1.049) 2(0.96,-1.049) 3(0,1.049)
TSOT23_290X160X090_6_095_P2
  rect 0.508x1.194 smd: 1(-0.95,-1.5) 2(0,-1.5) 3(0.95,-1.5) 4(0.95,1.5) 5(0,1.5) 6(-0.95,1.5)
TSOT23_290X160X125_5_095
  rect 0.508x1.27 smd: 1(-0.965,-1.27) 2(0,-1.27) 3(0.965,-1.27) 4(1.016,1.27) 5(-0.965,1.27)
TSOT23_290X160X130_6_095
  rect 0.508x1.194 smd: 1(-0.95,-1.5) 2(0,-1.5) 3(0.95,-1.5) 4(0.95,1.5) 5(0,1.5) 6(-0.95,1.5)
TSOT23_292X130X120_3_095
  rect 0.711x0.787 smd: 1(-0.95,-1.025) 2(0,1.025) 3(0.95,-1.025)
TSOT23_292X130X120_3_095_P2
  rect 0.711x0.787 smd: D(0,1.025) G(-0.95,-1.025) S(0.95,-1.025)
TSOT23_295X160X140_5_095
  rect 0.559x0.787 smd: 1(-0.95,-1.2) 2(0,-1.2) 3(0.95,-1.2) 4(0.95,1.2) 5(-0.95,1.2)
TSOT353_200X125X110_5_065
  rect 0.457x0.889 smd: 1(-0.65,-1.001) 2(0,-1.001) 3(0.65,-1.001) 4(0.65,1.001) 5(-0.65,1.001)
TSOT353_205X125X110_5_065
  rect 0.457x0.991 smd: 1(-0.65,-1.001) 2(0,-1.001) 3(0.65,-1.001) 4(0.65,1.001) 5(-0.65,1.001)
TSSOT23_290X160X135_5_095
  rect 0.66x1.016 smd: 1(-0.95,-1.295) 2(0,-1.295) 3(0.95,-1.295) 4(0.95,1.295) 5(-0.95,1.295)
TSSOT23_292X130X111_3_096
  rect 0.787x0.889 smd: 1(-0.955,-1.001) 2(0.955,-1.001) 3(0,1.001)
TSSOT323_200X125X100_3_065
  rect 0.711x0.889 smd: 1(-0.65,-0.95) 2(0.65,-0.95) 3(0,0.95)
unnamed#2
  round 4.013 hole 4.013 unplated: (0,0)
unnamed#3
  rect 2.007x2.007 smd: (0,0) (0,0)
USB3_TCONN_9_DIP_RS_S_040_326_1
  round 1.346 hole 0.838: 1(3.5,2.43) 2(1,2.43) 3(-1,2.43) 4(-3.5,2.43) 5(-4,0.93) 6(-2,0.93) 7(0,0.93) 8(2,0.93) 9(4,0.93)
  oval 1.397x3.2 hole 0.787x2.591: G1(7.85,0) G2(-7.85,0)
  oval 1.397x2.311 hole 0.787x1.702: G3(7.85,-6.8) G4(-7.85,-6.8)
USB31_SIGAT_24_DIP_S_060_193_1
  round 0.686 hole 0.686 unplated: (-3.45,0)
  oval 0.838x0.66 hole 0.838x0.66 unplated: (3.45,0)
  rect 0.356x0.686 smd: A1(-2.75,-0.09) A2(-2.25,-0.09) A3(-1.75,-0.09) A4(-1.25,-0.09) A5(-0.75,-0.09) A6(-0.25,-0.09) A7(0.25,-0.09) A8(0.75,-0.09) A9(1.25,-0.09) A10(1.75,-0.09) A11(2.25,-0.09) A12(2.75,-0.09)
  oval 1.143x0.66 hole 0.889x0.406: B1(3.2,-1.14) B12(-3.2,-1.14)
  round 0.66 hole 0.406: B2(2.5,-2.04) B3(1.7,-2.04) B4(1.3,-1.14) B5(0.85,-2.04) B6(0.4,-1.14) B7(-0.4,-1.14) B8(-0.85,-2.04) B9(-1.3,-1.14) B10(-1.7,-2.04) B11(-2.5,-2.04)
  oval 0.991x1.6 hole 0.508x1.092: G1(-4.475,0.4) G6(4.475,0.4)
  oval 0.991x2.007 hole 0.508x1.499: G2(-6.075,-1.94) G3(-6.075,-5.8) G4(6.075,-5.8) G5(6.075,-1.94)
  rect 0.508x0.305 smd: G7(3.2,0.69) G8(1,0.69) G9(-1,0.69) G10(-3.2,0.69)
VQFN_500X500X100_32_050_T2
  custom 0.089x0.089 smd: 1(-1.75,-2.474) 2(-1.25,-2.474) 3(-0.752,-2.474) 4(-0.249,-2.474) 5(0.249,-2.474) 6(0.752,-2.474) 7(1.25,-2.474) 8(1.75,-2.474) 9(2.474,-1.75) 10(2.474,-1.25) 11(2.474,-0.752) 12(2.474,-0.249) 13(2.474,0.249) 14(2.474,0.752) 15(2.474,1.25) 16(2.474,1.75) 25(-2.474,1.75) 26(-2.474,1.25) 27(-2.474,0.752) 28(-2.474,0.249) 29(-2.474,-0.249) 30(-2.474,-0.752) 31(-2.474,-1.25) 32(-2.474,-1.75)
  custom 0.09x0.09 smd: 17(1.75,2.474) 18(1.25,2.474) 19(0.752,2.474) 20(0.249,2.474) 21(-0.249,2.474) 22(-0.752,2.474) 23(-1.25,2.474) 24(-1.75,2.474)
  rect 3.454x3.454 smd: 33(0,0)
WDFN_300X300X080_10_050_T1
  rect 0.356x0.787 smd: 1(-1.016,-1.499) 2(-0.508,-1.499) 3(0,-1.499) 4(0.508,-1.499) 5(1.016,-1.499) 6(1.016,1.499) 7(0.508,1.499) 8(0,1.499) 9(-0.508,1.499) 10(-1.016,1.499)
  rect 2.388x1.6 smd: 11(0,0)
WLCSP_092X142X047_6_050
  round 0.356 smd: A1(0.25,-0.5) A2(-0.25,-0.5) B1(0.25,0) B2(-0.25,0) C1(0.25,0.5) C2(-0.25,0.5)
WQFN_400X400X080_28_040_T1
  custom 0.074x0.074 smd: 1(-1.2,-2) 2(-0.8,-2) 3(-0.4,-2) 4(0,-2) 5(0.4,-2) 6(0.8,-2) 7(1.2,-2) 8(2,-1.2) 9(2,-0.8) 10(2,-0.4) 11(2,0) 12(2,0.4) 13(2,0.8) 14(2,1.2) 15(1.2,2) 16(0.8,2) 17(0.4,2) 18(0,2) 19(-0.4,2) 20(-0.8,2) 21(-1.2,2) 22(-2,1.2) 23(-2,0.8) 24(-2,0.4) 25(-2,0) 26(-2,-0.4) 27(-2,-0.8) 28(-2,-1.2)
  rect 2.591x2.591 smd: 29(0,0)
WTB_ACES_2_100_SMD_R_M_295_4
  rect 0.61x1.549 smd: 1(-0.5,4.05) 2(0.501,4.05)
  rect 1.194x1.803 smd: 3(-1.801,0.177) 4(1.801,0.177)
WTB_ACES_4_100_SMD_R_M_295
  rect 0.61x1.549 smd: 1(-1.501,3.873) 2(-0.5,3.873) 3(0.5,3.873) 4(1.501,3.873)
  rect 1.194x1.803 smd: G1(-2.802,0) G2(2.802,0)
WTB_ACES_4_125_SMD_R_M_215
  rect 0.787x1.905 smd: 1(-1.875,4.875) 2(-0.625,4.875) 3(0.625,4.875) 4(1.875,4.875)
  rect 1.295x3.353 smd: G1(-4.725,-0.05) G2(4.725,-0.05)
WTB_ACES_8_150_SMD_R_M_445
  custom 0.212x0.212 smd: 1(-5.25,3.625) 2(-3.75,3.625) 3(-2.25,3.625) 4(-0.75,3.625) 5(0.75,3.625) 6(2.25,3.625) 7(3.75,3.625) 8(5.25,3.625)
WTB_ACES_8_200_SMD_R_M_226_2
  rect 0.559x1.295 smd: 1(-7.013,5.047) 2(-5.013,5.047) 3(-3.013,5.047) 4(-1.013,5.047) 5(0.987,5.047) 6(2.987,5.047) 7(4.987,5.047) 8(6.987,5.047)
  rect 1.295x2.057 smd: G1(-10.113,0.022) G2(10.087,0.022)
WTB_ACES_40_050_SMD_V_F_140_2
  rect 0.356x1.372 smd: 1(-9.751,-1.951) 2(-9.251,-1.951) 3(-8.75,-1.951) 4(-8.25,-1.951) 5(-7.75,-1.951) 6(-7.249,-1.951) 7(-6.749,-1.951) 8(-6.248,-1.951) 9(-5.751,-1.951) 10(-5.25,-1.951) 11(-4.75,-1.951) 12(-4.249,-1.951) 13(-3.752,-1.951) 14(-3.251,-1.951) 15(-2.751,-1.951) 16(-2.25,-1.951) 17(-1.75,-1.951) 18(-1.25,-1.951) 19(-0.749,-1.951) 20(-0.249,-1.951) 21(0.249,-1.951) 22(0.752,-1.951) 23(1.25,-1.951) 24(1.75,-1.951) 25(2.25,-1.951) 26(2.751,-1.951) 27(3.251,-1.951) 28(3.752,-1.951) 29(4.252,-1.951) 30(4.75,-1.951) 31(5.25,-1.951) 32(5.751,-1.951) 33(6.248,-1.951) 34(6.749,-1.951) 35(7.252,-1.951) 36(7.752,-1.951) 37(8.25,-1.951) 38(8.75,-1.951) 39(9.251,-1.951) 40(9.751,-1.951)
  rect 1.194x2.692 smd: G1(-12.151,0) G5(12.151,0)
  rect 2.311x1.295 smd: G2(-8.9,1.951) G3(0,1.951) G4(8.9,1.951)
XTAL_320X250X080_4_220
  rect 1.397x1.194 smd: 1(-1.1,-0.851) 2(1.1,-0.851) 3(1.1,0.851) 4(-1.1,0.851)
XTAL_320X250X090_4-2
  rect 1.397x1.194 smd: 1(-1.1,-0.9) 2(1.1,-0.9) 3(1.1,0.9) 4(-1.1,0.9)
XTAL_320X250X090_4_220-2
  rect 1.397x1.194 smd: 1(-1.1,-0.851) 2(1.1,-0.851) 3(1.1,0.851) 4(-1.1,0.851)
XTAL_670X140X140_4_630
  rect 1.194x0.61 smd: 1(-3.15,-0.45) 2(3.15,-0.45) 3(3.15,0.45) 4(-3.15,0.45)

## Nets
1V0S_DGPU_PG: U67600.4
1V05A_PG: R7006.2(B) U60900.9(PG)
1V8_AON_PG: R55601.2(B) R55602.2(B) U53520.1
1V8_MAIN_EN_AND_LEVEL: R53520.1(A) R53550.1(A) R53573.1(A) R53574.2(B) R53584.1(A) U53520.4 U53550.2
1V8_MAIN_EN_LEVEL: C53510.1(A) Q53510.6 R53510.2(B) R53515.2(B) TP53510.1 U53520.2
1V8_MAIN_EN_OR: C53552.2(B) D53552.3(A1) R53552.2(B) TP53551.1 U55300.3(ON)
1V8_MAIN_EN_OR_LEVEL: D53552.1(A2) U53550.4
1V8_MAIN_R_EN: Q53510.5 R53512.2(B)
1V8_MAIN_R_EN#: Q53510.2 Q53510.3 R53511.2(B)
1V8S_DGPU_PG: R55601.1(A) U67400.9(PG)
2V5_PG: R7042.1(A) U60400.5
3V3DS_PG: R7021.2(B) U1.18(RI1#/GPD0<3>) U60100.3
3V_LP#: TP60102.1 U60100.12
5V0_PG: U60250.9(PG)
5V_PG: U60200.9
19V_CURRENT_MONITOR_N: R52011.1(A) R67099.4
19V_CURRENT_MONITOR_P: R52012.1(A) R52014.1(A) R67099.3
AGND_AUDIO: C501.2(B) C502.1(A) C504.2(B) C505.2(B) C512.1(A) C513.2(B) C523.1(A) C524.1(A) C525.1(A) C531.2(B) CN603.1 CN603.4 PAD500.2 PAD501.2 PAD502.2 R501.2(B) R531.2(B) U500.25(AVSS1) U500.38(AVSS2)
AVDDH: C407.1(A) C416.1(A) C417.1(A) U400.9 U400.22
AVDDL: C406.2(B) C408.2(B) C420.1(A) C424.1(A) C425.1(A) L401.2(INB) L402.2(INB) U400.6 U400.13 U400.19 U400.31
AVDDVCO: C404.1(A) C409.1(A) C410.1(A) L402.1(INA) U400.34
