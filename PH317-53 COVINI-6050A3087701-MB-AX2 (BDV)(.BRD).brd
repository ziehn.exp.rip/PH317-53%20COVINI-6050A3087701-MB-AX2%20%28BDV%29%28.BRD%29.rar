# Allegro board PH317-53 COVINI-6050A3087701-MB-AX2 (BDV)(.BRD).brd (continued)
## Library data of the parts (continued)
R407 = RSC_0402: part number: RSC_0402-2.37K_1%_2,6013A008810H,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-2.37K-1%-1/16W-0402-TAP; signal model: R2_6013A008810H_2_37K_1%_2; room: Sheet124
R408 = RSC_0402: part number: RSC_0402-200K_5%_2,60130B20400Y,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-200K-5%-1/16W-0402-TAP; signal model: R2_60130B20400Y_200K_5%_2; room: Sheet124
R409 = RSC_0402: part number: RSC_0402-20K_5%_2,6013A0050701,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-20K-5%-1/16W-0402-TAP; signal model: R2_6013A0050701_20K_5%_2; room: Sheet124
R411 = RSC_0402: part number: RSC_0402-1M_5%_2_DY,60130B10500Y_DY,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-1M-5%-1/16W-0402-TAP; signal model: R2_60130B10500Y_DY_1M_5%_2_DY; room: Sheet124
R412-R415 = RSC_0603: part number: RSC_0603-75_5%_3,60130B75000Z,RSC_160X080X080_2,0.95MM,RSC_0603,0603,RES-CHIP-75-5%-1/10W-0603-TAP; signal model: R2_60130B75000Z_75_5%_3; room: Sheet125
R416 = RSC_0402: part number: RSC_0402-4.7K_5%_2,60130B4720ZT,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-4.7K-5%-1/16W-0402-TAP; signal model: R2_60130B4720ZT_4_7K_5%_2; room: Sheet124
R417-R419 = RSC_0402: part number: RSC_0402-220_5%_2,60130B2210ZT,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-220-5%-1/16W-0402-TAP; signal model: R2_60130B2210ZT_220_5%_2; room: Sheet124
R500 R508-R511 R513 R514 = RSC_SHORT: part number: RSC_SHORT-SHORT_0603_25,SHORT_0603_25,RSC_160X080X080_2_25_SHORT,0.127MM,RSC_SHORT,SHORT_0603_25; signal model: R2_short_0603_25_short_0603_25; room: Sheet54
R501 = RSC_0402: part number: RSC_0402-20K_1%_2_DY,6013A0015301_DY,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-20K-1%-1/16W-0402-TAP; signal model: R2_6013A0015301_DY_20K_1%_2_DY; room: Sheet54
R502 = RSC_0402: part number: RSC_0402-200K_5%_2,60130B20400Y,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-200K-5%-1/16W-0402-TAP; signal model: R2_60130B20400Y_200K_5%_2; room: Sheet54
R503 = RSC_0402: part number: RSC_0402-4.7K_5%_2,60130B4720ZT,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-4.7K-5%-1/16W-0402-TAP; signal model: R2_60130B4720ZT_4_7K_5%_2; room: Sheet54
R504 R525 R531 = RSC_0402: part number: RSC_0402-100K_5%_2,60130B1040ZT,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-100K-5%-1/16W-0402-TAP; signal model: R2_60130B1040ZT_100K_5%_2; room: Sheet54
R505 R521 = RSC_0402: part number: RSC_0402-22K_5%_2,60130B22300Y,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-22K-5%-1/16W-0402-TAP; signal model: R2_60130B22300Y_22K_5%_2; room: Sheet54
R506 R515 = RSC_SHORT: part number: RSC_SHORT-SHORT_0402_5,SHORT_0402_5,RSC_100X050X040_2_SHORT,0.127MM,RSC_SHORT,SHORT_0402_5; signal model: R2_short_0402_5_short_0402_5; room: Sheet54
R507 = RSC_0402: part number: RSC_0402-75_5%_2,60130B7500ZT,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-75OHM-5%-1/16W-0402-TAP; signal model: R2_60130B7500ZT_75_5%_2; room: Sheet54
R512 = RSC_0402: part number: RSC_0402-100_5%_2,60130B1010ZT,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-100-5%-1/16W-0402-TAP; signal model: R2_60130B1010ZT_100_5%_2; room: Sheet54
R600 R601 = RSC_0402: part number: RSC_0402-2.2K_5%_2,6013A0049601,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-2.2K-5%-1/16W-0402-TAP; signal model: R2_6013A0049601_2_2K_5%_2; room: Sheet126
R604 R605 = RSC_0402: part number: RSC_0402-61.9_1%_2,6013A0087605,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RESISTOR-CHIP,61.9OHM,1%,1/16W,0402,TAPMM; signal model: R2_6013A0087605_61_9_1%_2; room: Sheet55
R606 R607 = RSC_0402: part number: RSC_0402-4.7K_5%_2,60130B4720ZT,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-4.7K-5%-1/16W-0402-TAP; signal model: R2_60130B4720ZT_4_7K_5%_2; room: Sheet55
R610 = RSC_0402: part number: RSC_0402-0_5%_2_DY,60130B0000ZT_DY,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-0OHM-5%-1/16W-0402-TAP; signal model: R2_60130B0000ZT_DY_0_5%_2_DY; room: Sheet126
R700 R701 = RSC_0402: part number: RSC_0402-2.2K_5%_2,6013A0049601,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-2.2K-5%-1/16W-0402-TAP; signal model: R2_6013A0049601_2_2K_5%_2; room: Sheet118
R702 R703 R705 = RSC_0402: part number: RSC_0402-100K_5%_2,60130B1040ZT,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-100K-5%-1/16W-0402-TAP; signal model: R2_60130B1040ZT_100K_5%_2; room: Sheet118
R704 = RSC_0402: part number: RSC_0402-390_1%_2,6013B0119601,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RESISTOR-CHIP,390OHM,1%,1/16W,0402,TR; signal model: R2_6013B0119601_390_1%_2; room: Sheet118
R1300 R1301 R1350 R1351 = RSC_0402: part number: RSC_0402-100K_5%_2,60130B1040ZT,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-100K-5%-1/16W-0402-TAP; signal model: R2_60130B1040ZT_100K_5%_2; room: Sheet57
R1320 R1321 R1324 R1328-R1331 R1337 R1338 R1345-R1347 R1352-R1356 R1358 R1361-R1368 = RSC_0402: part number: RSC_0402-0_5%_2,60130B0000ZT,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-0OHM-5%-1/16W-0402-TAP; signal model: R2_60130B0000ZT_0_5%_2; room: Sheet57
R1325 = RSC_0805: part number: RSC_0805-0_5%_5_DY,60130BA0003T_DY,RSC_200X125X130_2,1.45MM,RSC_0805,0805,RES-CHIP-0-5%-1/8W-0805-TAP; signal model: R2_60130BA0003T_0_5%_5_DY; room: Sheet57
R1334 = RSC_0402: part number: RSC_0402-71.5K_1%_2,6013A008860K,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-71.5K_1%-1/16W-0402-TAP; signal model: R2_6013A008860K_71_5K_1%_2; room: Sheet57
R1335 = RSC_0402: part number: RSC_0402-75K_1%_2_DY,6013A008860M_DY,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-75K-1%-1/16W-0402-TAP; signal model: R2_6013A008860M_DY_75K_1%_2_DY; room: Sheet57
R1342 R1357 R1359 = RSC_0402: part number: RSC_0402-10K_5%_2,60130B1030ZT,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP,10K,5%,1/16W,0402,TR; signal model: R2_60130B1030ZT_10K_5%_2; room: Sheet57
R1360 = RSC_0402: part number: RSC_0402-4.7K_5%_2,60130B4720ZT,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-4.7K-5%-1/16W-0402-TAP; signal model: R2_60130B4720ZT_4_7K_5%_2; room: Sheet57
R1700 R1718 = RSC_0402: part number: RSC_0402-4.7K_5%_2,60130B4720ZT,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-4.7K-5%-1/16W-0402-TAP; signal model: R2_60130B4720ZT_4_7K_5%_2; room: Sheet65
R1701 = RSC_0402: part number: RSC_0402-4.7K_5%_2_DY,60130B4720ZT_DY,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-4.7K-5%-1/16W-0402-TAP; signal model: R2_60130B4720ZT_DY_4_7K_5%_2_DY; room: Sheet65
R1702-R1717 = RSC_0402: part number: RSC_0402-1K_5%_2_DY,60130B1020ZT_DY,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-1K-5%-1/16W-0402-TAP; signal model: R2_60130B1020ZT_DY_1K_5%_2_DY; room: Sheet65
R1900 R1901 = RSC_0402: part number: RSC_0402-0_5%_2,60130B0000ZT,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-0OHM-5%-1/16W-0402-TAP; signal model: R2_60130B0000ZT_0_5%_2; room: Sheet58
R1902 = RSC_0402: part number: RSC_0402-0_5%_2,60130B0000ZT,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-0OHM-5%-1/16W-0402-TAP; signal model: R2_60130B0000ZT_0_5%_2; room: Sheet59
R1903 = RSC_0402: part number: RSC_0402-10K_5%_2,60130B1030ZT,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP,10K,5%,1/16W,0402,TR; signal model: R2_60130B1030ZT_10K_5%_2; room: Sheet59
R1904 R1905 = RSC_0402: part number: RSC_0402-10K_5%_2,60130B1030ZT,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP,10K,5%,1/16W,0402,TR; signal model: R2_60130B1030ZT_10K_5%_2; room: Sheet58
R1906 = RSC_0402: part number: RSC_0402-0_5%_2_DY,60130B0000ZT_DY,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-0OHM-5%-1/16W-0402-TAP; signal model: R2_60130B0000ZT_DY_0_5%_2_DY; room: Sheet58
R2400 R2401 = RSC_0402: part number: RSC_0402-10K_5%_2_DY,60130B1030ZT_DY,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP,10K,5%,1/16W,0402,TR; signal model: R2_60130B1030ZT_DY_10K_5%_2_DY; room: Sheet60
R2402 R2411 = RSC_0402: part number: RSC_0402-10K_5%_2,60130B1030ZT,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP,10K,5%,1/16W,0402,TR; signal model: R2_60130B1030ZT_10K_5%_2; room: Sheet60
R2403 = RSC_0402: part number: RSC_0402-4.7K_5%_2_DY,60130B4720ZT_DY,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-4.7K-5%-1/16W-0402-TAP; signal model: R2_60130B4720ZT_DY_4_7K_5%_2_DY; room: Sheet60
R2404 R2405 R2421-R2424 R2426-R2428 = RSC_0402: part number: RSC_0402-4.7K_5%_2_DY,60130B4720ZT_DY,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-4.7K-5%-1/16W-0402-TAP; signal model: R2_60130B4720ZT_DY_4_7K_5%_2_DY; room: Sheet122
R2406-R2409 R2412 R2413 R2416-R2418 = RSC_0402: part number: RSC_0402-4.7K_5%_2_DY,60130B4720ZT_DY,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-4.7K-5%-1/16W-0402-TAP; signal model: R2_60130B4720ZT_DY_4_7K_5%_2_DY; room: Sheet121
R2410 = RSC_0402: part number: RSC_0402-120K_1%_2,6013B0027202,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP,120K,1%,1/16W,0402,TR,-55/+125PPM/DEGREEC; signal model: R2_6013B0027202_120K_1%_2; room: Sheet60
R2414 = RSC_0402: part number: RSC_0402-4.99K_1%_2,6013A0015201,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-4.99K-1%-1/16W-0402-TAP; signal model: R2_6013A0015201_4_99K_1%_2; room: Sheet121
R2415 = RSC_0402: part number: RSC_0402-10K_5%_2_DY,60130B1030ZT_DY,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP,10K,5%,1/16W,0402,TR; signal model: R2_60130B1030ZT_DY_10K_5%_2_DY; room: Sheet121
R2419 = RSC_0402: part number: RSC_0402-4.99K_1%_2,6013A0015201,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-4.99K-1%-1/16W-0402-TAP; signal model: R2_6013A0015201_4_99K_1%_2; room: Sheet122
R2420 = RSC_0402: part number: RSC_0402-10K_5%_2_DY,60130B1030ZT_DY,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP,10K,5%,1/16W,0402,TR; signal model: R2_60130B1030ZT_DY_10K_5%_2_DY; room: Sheet122
R2500 R2501 R2557 = RSC_0402: part number: RSC_0402-10K_5%_2_DY,60130B1030ZT_DY,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP,10K,5%,1/16W,0402,TR; signal model: R2_60130B1030ZT_DY_10K_5%_2_DY; room: Sheet61
R2502-R2505 R2512-R2515 = RSC_0603: part number: RSC_0603-0_5%_3,60130B00000Z,RSC_160X080X055_2,0.7MM,RSC_0603,0603,RES-CHIP-0-5%-1/10W-TAP; signal model: R2_60130B00000Z_0_5%_3; room: Sheet60
R2506-R2509 = RSC_0402: part number: RSC_0402-220K_5%_2,6013A0076001,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-220K-5%-1/16W-0402-TAP; signal model: R2_6013A0076001_220K_5%_2; room: Sheet60
R2510 R2511 = RSC_0402: part number: RSC_0402-0_5%_2_DY,60130B0000ZT_DY,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-0OHM-5%-1/16W-0402-TAP; signal model: R2_60130B0000ZT_DY_0_5%_2_DY; room: Sheet60
R2523 R2524 = RSC_0402: part number: RSC_0402-0_5%_2_DY,60130B0000ZT_DY,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-0OHM-5%-1/16W-0402-TAP; signal model: R2_60130B0000ZT_DY_0_5%_2_DY; room: Sheet61
R2529-R2532 = RSC_0603: part number: RSC_0603-0_5%_3,60130B00000Z,RSC_160X080X055_2,0.7MM,RSC_0603,0603,RES-CHIP-0-5%-1/10W-TAP; signal model: R2_60130B00000Z_0_5%_3; room: Sheet61
R2551 = RSC_0402: part number: RSC_0402-19.6K_1%_2,6013A008840M,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-19.6K-1%-1/16W-0402-TAP; signal model: R2_6013A008840M_19_6K_1%_2; room: Sheet61
R2552 = RSC_0402: part number: RSC_0402-33K_1%_2,6013A0049501,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-33K-1%-1/16W-0402-TAP; signal model: R2_6013A0049501_33K_1%_2; room: Sheet61
R2553-R2555 R2558 = RSC_0402: part number: RSC_0402-0_5%_2,60130B0000ZT,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-0OHM-5%-1/16W-0402-TAP; signal model: R2_60130B0000ZT_0_5%_2; room: Sheet61
R2559 = RSC_0402: part number: RSC_0402-10K_5%_2,60130B1030ZT,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP,10K,5%,1/16W,0402,TR; signal model: R2_60130B1030ZT_10K_5%_2; room: Sheet61
R2649 = RSC_0402: part number: RSC_0402-8.45K_1%_2,6013A0068101,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-8.45K-1%-1/16W-0402-TAP; signal model: R2_6013A0068101_8_45K_1%_2; room: Sheet60
R2680 R2681 = RSC_0402: part number: RSC_0402-21K_1%_2,6013A008840R,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-21K-1%-1/16W-0402-TAP; signal model: R2_6013A008840R_21K_1%_2; room: Sheet60
R3000 R3004 R3005 = RSC_0402: part number: RSC_0402-100_5%_2,60130B1010ZT,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-100-5%-1/16W-0402-TAP; signal model: R2_60130B1010ZT_100_5%_2; room: Sheet62
R3001 = RSC_SHORT: part number: RSC_SHORT-SHORT_0402_5,SHORT_0402_5,RSC_100X050X040_2_SHORT,0.127MM,RSC_SHORT,SHORT_0402_5; signal model: R2_short_0402_5_short_0402_5; room: Sheet62
R3002 R3008 = RSC_0402: part number: RSC_0402-100K_5%_2,60130B1040ZT,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-100K-5%-1/16W-0402-TAP; signal model: R2_60130B1040ZT_100K_5%_2; room: Sheet62
R3006 = RSC_0402: part number: RSC_0402-100K_5%_2_DY,60130B1040ZT_DY,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-100K-5%-1/16W-0402-TAP; signal model: R2_60130B1040ZT_DY_100K_5%_2_DY; room: Sheet62
R3013 = RSC_0402: part number: RSC_0402-2.2K_5%_2_DY,6013A0049601_DY,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-2.2K-5%-1/16W-0402-TAP; signal model: R2_6013A0049601_DY_2_2K_5%_2_DY; room: Sheet62
R3500-R3502 = RSC_0402: part number: RSC_0402-10K_5%_2,60130B1030ZT,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP,10K,5%,1/16W,0402,TR; signal model: R2_60130B1030ZT_10K_5%_2; room: Sheet63
R3503 R3505 R3506 = RSC_0402: part number: RSC_0402-33_5%_2,60130B3300ZT,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-33-5%-1/16W-0402-TAP; signal model: R2_60130B3300ZT_33_5%_2; room: Sheet63
R3504 = RSC_SHORT: part number: RSC_SHORT-SHORT_0402_5,SHORT_0402_5,RSC_100X050X040_2_SHORT,0.127MM,RSC_SHORT,SHORT_0402_5; signal model: R2_short_0402_5_short_0402_5; room: Sheet63
R4119 R4216 R4220 = RSC_0402: part number: RSC_0402-0_5%_2,60130B0000ZT,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-0OHM-5%-1/16W-0402-TAP; signal model: R2_60130B0000ZT_0_5%_2; room: Sheet48
R4144 R4145 R4150 R4152 = RSC_0402: part number: RSC_0402-1K_1%_2,60130B10019Z,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-1K-1%-1/16W-0402-TAP; signal model: R2_60130B10019Z_1K_1%_2; room: Sheet29
R4148 R4153 = RSC_0402: part number: RSC_0402-2_1%_2,6013B0172801,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP,2,1%,1/16W,0402,TR; signal model: R2_6013B0172801_2_1%_2; room: Sheet29
R4149 R4155 = RSC_0402: part number: RSC_0402-24.9_1%_2,6013A008740P,RSC_100X050X035_2,0.5MM,RSC_0402,0402,RES-CHIP-24.9-1%-1/16W-0402-TAP; signal model: R2_6013A008740P_24_9_1%_2; room: Sheet29
R4200 = RSC_0402: part number: RSC_0402-240_1%_2,6013B0072701,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP,240,1%,1/16W,0402,TR; signal model: R2_6013B0072701_240_1%_2; room: Sheet48
R4201 = RSC_0402: part number: RSC_0402-240_1%_2,6013B0072701,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP,240,1%,1/16W,0402,TR; signal model: R2_6013B0072701_240_1%_2; room: Sheet47
R4210 R4212 R4214 = RSC_0402: part number: RSC_0402-0_5%_2,60130B0000ZT,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-0OHM-5%-1/16W-0402-TAP; signal model: R2_60130B0000ZT_0_5%_2; room: Sheet47
R4217-R4219 = RSC_SHORT: part number: RSC_SHORT-SHORT_0402_15,SHORT_0402_15,RSC_100X050X040_2_15_SHORT,0.127MM,RSC_SHORT,SHORT_0402_15; signal model: R2_short_0402_15_short_0402_15; room: Sheet48
R4300-R4302 R4305 = RSC_0402: part number: RSC_0402-10K_5%_2,60130B1030ZT,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP,10K,5%,1/16W,0402,TR; signal model: R2_60130B1030ZT_10K_5%_2; room: Sheet24
R4452 R4453 = RSC_0402: part number: RSC_0402-10K_5%_2,60130B1030ZT,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP,10K,5%,1/16W,0402,TR; signal model: R2_60130B1030ZT_10K_5%_2; room: Sheet49
R4454 = RSC_SHORT: part number: RSC_SHORT-SHORT_0402_5_NSP,SHORT_0402_5_NSP,RSC_100X050X040_2_NSP_SHORT,0.127MM,RSC_SHORT,SHORT_0402_5_NSP; signal model: R2_short_0402_5_nsp_short_0402_5_nsp; room: Sheet49
R4455 = RSC_SHORT: part number: RSC_SHORT-SHORT_0402_15_NSP,SHORT_0402_15_NSP,RSC_100X050X040_2_15_NSP_SHORT,0.127MM,RSC_SHORT,SHORT_0402_15_NSP; signal model: R2_short_0402_15_nsp_short_0402_15_nsp; room: Sheet49
R4501 = RSC_0402: part number: RSC_0402-24.9_1%_2,6013A008740P,RSC_100X050X035_2,0.5MM,RSC_0402,0402,RES-CHIP-24.9-1%-1/16W-0402-TAP; signal model: R2_6013A008740P_24_9_1%_2; room: Sheet26
R4505 = RSC_0402: part number: RSC_0402-499_1%_2,6013A0076801,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-499-1%-1/16W-0402-TAP; signal model: R2_6013A0076801_499_1%_2; room: Sheet30
R4507 R4523 R4736 R4739 = RSC_0402: part number: RSC_0402-1K_5%_2,60130B1020ZT,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-1K-5%-1/16W-0402-TAP; signal model: R2_60130B1020ZT_1K_5%_2; room: Sheet30
R4508 R4510 R4515 = RSC_0402: part number: RSC_0402-51_5%_2,60130B5100ZT,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-51-5%-1/16W-0402-TAP; signal model: R2_60130B5100ZT_51_5%_2; room: Sheet30
R4509 R4516 = RSC_0402: part number: RSC_0402-100_5%_2,60130B1010ZT,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-100-5%-1/16W-0402-TAP; signal model: R2_60130B1010ZT_100_5%_2; room: Sheet30
R4511 = RSC_0402: part number: RSC_0402-220_5%_2,60130B2210ZT,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-220-5%-1/16W-0402-TAP; signal model: R2_60130B2210ZT_220_5%_2; room: Sheet30
R4513 = RSC_0402: part number: RSC_0402-20_5%_2,6013A0003301,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-20-5%-1/8W-0402-TAP; signal model: R2_6013A0003301_20_5%_2; room: Sheet30
R4514 = RSC_0402: part number: RSC_0402-12.1_1%_2,6013A008730M,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-12.1-1%-1/16W-0402-TAP; signal model: R2_6013A008730M_12_1_1%_2; room: Sheet30
R4517 R4521 R4522 R4524 = RSC_0402: part number: RSC_0402-100_1%_2,6013A0016701,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-100OHM-1%-1/16W-0402-TAP; signal model: R2_6013A0016701_100_1%_2; room: Sheet32
R4518 = RSC_0402: part number: RSC_0402-121_1%_2,6013A0087705,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-121-1%-1/16W-0402-TAP; signal model: R2_6013A0087705_121_1%_2; room: Sheet29
R4519 R4533 = RSC_0402: part number: RSC_0402-49.9_1%_2,6013A0076901,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-49.9-1%-1/16W-0402-TAP; signal model: R2_6013A0076901_49_9_1%_2; room: Sheet30
R4520 = RSC_0402: part number: RSC_0402-0_5%_2,60130B0000ZT,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-0OHM-5%-1/16W-0402-TAP; signal model: R2_60130B0000ZT_0_5%_2; room: Sheet30
R4525 R4527 = RSC_0402: part number: RSC_0402-100_1%_2,6013A0016701,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-100OHM-1%-1/16W-0402-TAP; signal model: R2_6013A0016701_100_1%_2; room: Sheet35
R4526 R4528-R4530 = RSC_0402: part number: RSC_0402-1K_5%_2_DY,60130B1020ZT_DY,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-1K-5%-1/16W-0402-TAP; signal model: R2_60130B1020ZT_DY_1K_5%_2_DY; room: Sheet30
R4532 R4770 = RSC_SHORT: part number: RSC_SHORT-SHORT_0402_5,SHORT_0402_5,RSC_100X050X040_2_SHORT,0.127MM,RSC_SHORT,SHORT_0402_5; signal model: R2_short_0402_5_short_0402_5; room: Sheet39
R4534 = RSC_0402: part number: RSC_0402-1K_1%_2,60130B10019Z,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-1K-1%-1/16W-0402-TAP; signal model: R2_60130B10019Z_1K_1%_2; room: Sheet30
R4535 = RSC_0402: part number: RSC_0402-2.2K_5%_2,6013A0049601,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-2.2K-5%-1/16W-0402-TAP; signal model: R2_6013A0049601_2_2K_5%_2; room: Sheet30
R4538 = RSC_0402: part number: RSC_0402-56.2_1%_2,6013A0087601,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-56.2-1%-1/16W-0402-TAP; signal model: R2_6013A0087601_56_2_1%_2; room: Sheet30
R4540 = RSC_0402: part number: RSC_0402-100_1%_2,6013A0016701,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-100OHM-1%-1/16W-0402-TAP; signal model: R2_6013A0016701_100_1%_2; room: Sheet29
R4541 = RSC_0402: part number: RSC_0402-75_1%_2,6013A0050301,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-75-1%-1/16W-0402-TAP; signal model: R2_6013A0050301_75_1%_2; room: Sheet29
R4544 = RSC_0402: part number: RSC_0402-24.9_1%_2,6013A008740P,RSC_100X050X035_2,0.5MM,RSC_0402,0402,RES-CHIP-24.9-1%-1/16W-0402-TAP; signal model: R2_6013A008740P_24_9_1%_2; room: Sheet27
R4570 = RSC_SHORT: part number: RSC_SHORT-SHORT_0402_15_NSP,SHORT_0402_15_NSP,RSC_100X050X040_2_15_NSP_SHORT,0.127MM,RSC_SHORT,SHORT_0402_15_NSP; signal model: R2_short_0402_15_nsp_short_0402_15_nsp; room: Sheet22
R4600 = RSC_0402: part number: RSC_0402-150_1%_2,60130B15009Y,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-150-1%-1/16W-0402-TAP; signal model: R2_60130B15009Y_150_1%_2; room: Sheet46
R4601 R4603 R4604 = RSC_0402: part number: RSC_0402-10K_5%_2_DY,60130B1030ZT_DY,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP,10K,5%,1/16W,0402,TR; signal model: R2_60130B1030ZT_DY_10K_5%_2_DY; room: Sheet46
R4602 = RSC_0402: part number: RSC_0402-100K_5%_2,60130B1040ZT,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-100K-5%-1/16W-0402-TAP; signal model: R2_60130B1040ZT_100K_5%_2; room: Sheet46
R4605-R4607 = RSC_0402: part number: RSC_0402-200_1%_2,6013A0023701,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-200-1%-1/16W-0402-TAP; signal model: R2_6013A0023701_200_1%_2; room: Sheet46
R4608 = RSC_0402: part number: RSC_0402-100_1%_2,6013A0016701,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-100OHM-1%-1/16W-0402-TAP; signal model: R2_6013A0016701_100_1%_2; room: Sheet46
R4699 R4897 = RSC_0402: part number: RSC_0402-100K_5%_2_DY,60130B1040ZT_DY,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-100K-5%-1/16W-0402-TAP; signal model: R2_60130B1040ZT_DY_100K_5%_2_DY; room: Sheet40
R4702 = RSC_0402: part number: RSC_0402-4.7K_5%_2_DY,60130B4720ZT_DY,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-4.7K-5%-1/16W-0402-TAP; signal model: R2_60130B4720ZT_DY_4_7K_5%_2_DY; room: Sheet39
R4703 R4718 = RSC_0402: part number: RSC_0402-100K_5%_2,60130B1040ZT,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-100K-5%-1/16W-0402-TAP; signal model: R2_60130B1040ZT_100K_5%_2; room: Sheet39
R4705 R4775 R4828 R4891 R4913 = RSC_0402: part number: RSC_0402-2.2K_5%_2,6013A0049601,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-2.2K-5%-1/16W-0402-TAP; signal model: R2_6013A0049601_2_2K_5%_2; room: Sheet39
R4706 R4710 R4750 = RSC_0402: part number: RSC_0402-0_5%_2,60130B0000ZT,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-0OHM-5%-1/16W-0402-TAP; signal model: R2_60130B0000ZT_0_5%_2; room: Sheet39
R4707 R4749 = RSC_0402: part number: RSC_0402-10K_5%_2,60130B1030ZT,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP,10K,5%,1/16W,0402,TR; signal model: R2_60130B1030ZT_10K_5%_2; room: Sheet38
R4708 R4834 = RSC_0201: part number: RSC_0201-10K_5%_1,6013B0110476,RSC_060X030X030_2,0.45MM,RSC_0201,RES-CHIP,10K,5%,1/20W,0201,TR; signal model: R2_6013B0110476_10K_5%_1; room: Sheet36
R4711 = RSC_0201: part number: RSC_0201-100K_5%_1,6013B0110475,RSC_060X030X030_2,0.45MM,RSC_0201,RES-CHIP,100K,5%,1/20W,0201,TR; signal model: R2_6013B0110475_100K_5%_1; room: Sheet36
R4714 R4715 R4754 R4755 R4757 R4761 R4763 R4765 R4766 R4768 R4773 = RSC_0402: part number: RSC_0402-10K_1%_2_DY,60130B10029Z_DY,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-10K-1%-1/16W-0402-TAP; signal model: R2_60130B10029Z_DY_10K_1%_2_DY; room: Sheet45
R4716 R4719 = RSC_0402: part number: RSC_0402-33_5%_2,60130B3300ZT,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-33-5%-1/16W-0402-TAP; signal model: R2_60130B3300ZT_33_5%_2; room: Sheet45
R4717 R4747 R4861 R4890 = RSC_0402: part number: RSC_0402-1K_5%_2,60130B1020ZT,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-1K-5%-1/16W-0402-TAP; signal model: R2_60130B1020ZT_1K_5%_2; room: Sheet39
R4720 R4726-R4728 R4760 R4767 R4774 R4783 = RSC_0402: part number: RSC_0402-10K_5%_2,60130B1030ZT,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP,10K,5%,1/16W,0402,TR; signal model: R2_60130B1030ZT_10K_5%_2; room: Sheet37
R4722 = RSC_0402: part number: RSC_0402-60.4_1%_2,6013A0077001,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-60.4-1%-1/16W-0402-TAP; signal model: R2_6013A0077001_60_4_1%_2; room: Sheet30
R4723 R4813 R4873 = RSC_0402: part number: RSC_0402-10K_5%_2,60130B1030ZT,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP,10K,5%,1/16W,0402,TR; signal model: R2_60130B1030ZT_10K_5%_2; room: Sheet40
R4724 = RSC_0402: part number: RSC_0402-10K_5%_2,60130B1030ZT,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP,10K,5%,1/16W,0402,TR; signal model: R2_60130B1030ZT_10K_5%_2; room: Sheet46
R4725 R4731 R4732 = RSC_0402: part number: RSC_0402-20K_5%_2,6013A0050701,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-20K-5%-1/16W-0402-TAP; signal model: R2_6013A0050701_20K_5%_2; room: Sheet46
R4729 R4911 = RSC_0402: part number: RSC_0402-100K_5%_2,60130B1040ZT,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-100K-5%-1/16W-0402-TAP; signal model: R2_60130B1040ZT_100K_5%_2; room: Sheet36
R4733 R4909 R4912 = RSC_0402: part number: RSC_0402-10K_5%_2_DY,60130B1030ZT_DY,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP,10K,5%,1/16W,0402,TR; signal model: R2_60130B1030ZT_DY_10K_5%_2_DY; room: Sheet39
R4742 = RSC_0402: part number: RSC_0402-100K_5%_2,60130B1040ZT,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-100K-5%-1/16W-0402-TAP; signal model: R2_60130B1040ZT_100K_5%_2; room: Sheet30
R4743 = RSC_0402: part number: RSC_0402-200_5%_2,6013A0051201,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-200-5%-1/16W-0402-TAP; signal model: R2_6013A0051201_200_5%_2; room: Sheet30
R4748 = RSC_0402: part number: RSC_0402-75K_1%_2,6013A008860M,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-75K-1%-1/16W-0402-TAP; signal model: R2_6013A008860M_75K_1%_2; room: Sheet46
R4751 R4832 = RSC_0402: part number: RSC_0402-0_5%_2,60130B0000ZT,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-0OHM-5%-1/16W-0402-TAP; signal model: R2_60130B0000ZT_0_5%_2; room: Sheet42
R4752 = RSC_0402: part number: RSC_0402-47K_5%_2,60130B4730ZT,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-47K-5%-1/16W-0402-TAP; signal model: R2_60130B4730ZT_47K_5%_2; room: Sheet42
R4753 R4869 R4901 R4903 R4972 = RSC_0402: part number: RSC_0402-33_5%_2,60130B3300ZT,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-33-5%-1/16W-0402-TAP; signal model: R2_60130B3300ZT_33_5%_2; room: Sheet39
R4756 = RSC_0402: part number: RSC_0402-113_1%_2,6013A0075301,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-113-1%-1/16W-0402-TAP; signal model: R2_6013A0075301_113_1%_2; room: Sheet37
R4758 R4759 = RSC_0402: part number: RSC_0402-1K_5%_2,60130B1020ZT,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-1K-5%-1/16W-0402-TAP; signal model: R2_60130B1020ZT_1K_5%_2; room: Sheet37
R4762 R4764 = RSC_0402: part number: RSC_0402-27K_1%_2,6013B0112601,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP,27K,1%,1/16W,0402,TR; signal model: R2_6013B0112601_27K_1%_2; room: Sheet42
R4769 = RSC_0402: part number: RSC_0402-1K_5%_2,60130B1020ZT,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-1K-5%-1/16W-0402-TAP; signal model: R2_60130B1020ZT_1K_5%_2; room: Sheet42
R4771 = RSC_0402: part number: RSC_0402-470_5%_2,60130B4710ZT,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-470-5%-1/16W-0402-TAP; signal model: R2_60130B4710ZT_470_5%_2; room: Sheet39
R4772 R4777 = RSC_SHORT: part number: RSC_SHORT-SHORT_0402_5,SHORT_0402_5,RSC_100X050X040_2_SHORT,0.127MM,RSC_SHORT,SHORT_0402_5; signal model: R2_short_0402_5_short_0402_5; room: Sheet46
R4776 = RSC_0402: part number: RSC_0402-0_5%_2,60130B0000ZT,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-0OHM-5%-1/16W-0402-TAP; signal model: R2_60130B0000ZT_0_5%_2; room: Sheet36
R4778 = RSC_0402: part number: RSC_0402-30_5%_2,6013B0094201,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP,30,5%,1/16W,0402,TAP; signal model: R2_6013B0094201_30_5%_2; room: Sheet38
R4779-R4782 R4784 = RSC_0402: part number: RSC_0402-100K_5%_2_DY,60130B1040ZT_DY,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-100K-5%-1/16W-0402-TAP; signal model: R2_60130B1040ZT_DY_100K_5%_2_DY; room: Sheet38
R4785 = RSC_0402: part number: RSC_0402-620_5%,6013A008970C,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-620-5%-1/16-0402-TAP; signal model: R2_6013A008970C_620_5%; room: Sheet38
R4786 = RSC_0402: part number: RSC_0402-1K_5%_2,60130B1020ZT,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-1K-5%-1/16W-0402-TAP; signal model: R2_60130B1020ZT_1K_5%_2; room: Sheet38
R4787-R4791 = RSC_0402: part number: RSC_0402-100K_5%_2,60130B1040ZT,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-100K-5%-1/16W-0402-TAP; signal model: R2_60130B1040ZT_100K_5%_2; room: Sheet38
R4792 = RSC_0402: part number: RSC_0402-30_5%_2,6013B0094201,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP,30,5%,1/16W,0402,TAP; signal model: R2_6013B0094201_30_5%_2; room: Sheet40
R4793 = RSC_0402: part number: RSC_0402-100K_5%_2,60130B1040ZT,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-100K-5%-1/16W-0402-TAP; signal model: R2_60130B1040ZT_100K_5%_2; room: Sheet37
R4794 R4796-R4799 R4801 R4902 R4908 = RSC_0402: part number: RSC_0402-0_5%_2,60130B0000ZT,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-0OHM-5%-1/16W-0402-TAP; signal model: R2_60130B0000ZT_0_5%_2; room: Sheet40
R4795 = RSC_0603: part number: RSC_0603-0_5%_3,60130B00000Z,RSC_160X080X055_2,0.7MM,RSC_0603,0603,RES-CHIP-0-5%-1/10W-TAP; signal model: R2_60130B00000Z_0_5%_3; room: Sheet42
R4800 = RSC_0402: part number: RSC_0402-22_5%_2,60130B2200ZT,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-22-5%-1/16W-0402-TAP; signal model: R2_60130B2200ZT_22_5%_2; room: Sheet40
R4802 R4803 R4815 = RSC_0402: part number: RSC_0402-10K_5%_2_DY,60130B1030ZT_DY,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP,10K,5%,1/16W,0402,TR; signal model: R2_60130B1030ZT_DY_10K_5%_2_DY; room: Sheet44
R4806-R4809 R4919 R4935 = RSC_0402: part number: RSC_0402-2.2K_5%_2_DY,6013A0049601_DY,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-2.2K-5%-1/16W-0402-TAP; signal model: R2_6013A0049601_DY_2_2K_5%_2_DY; room: Sheet44
R4810 R4812 R4825 R4827 = RSC_0402: part number: RSC_0402-2.2K_5%_2,6013A0049601,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-2.2K-5%-1/16W-0402-TAP; signal model: R2_6013A0049601_2_2K_5%_2; room: Sheet44
R4811 R4818-R4820 R4822 R4824 R4882 = RSC_0402: part number: RSC_0402-10K_5%_2,60130B1030ZT,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP,10K,5%,1/16W,0402,TR; signal model: R2_60130B1030ZT_10K_5%_2; room: Sheet44
R4823 R4921 R4922 = RSC_0402: part number: RSC_0402-0_5%_2,60130B0000ZT,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-0OHM-5%-1/16W-0402-TAP; signal model: R2_60130B0000ZT_0_5%_2; room: Sheet44
R4826 = RSC_0402: part number: RSC_0402-1K_5%_2_DY,60130B1020ZT_DY,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-1K-5%-1/16W-0402-TAP; signal model: R2_60130B1020ZT_DY_1K_5%_2_DY; room: Sheet44
R4831 R4837 R4839 R4842 = RSC_0402: part number: RSC_0402-100K_5%_2_DY,60130B1040ZT_DY,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-100K-5%-1/16W-0402-TAP; signal model: R2_60130B1040ZT_DY_100K_5%_2_DY; room: Sheet44
R4833 = RSC_0402: part number: RSC_0402-1M_5%_2,60130B10500Y,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-1M-5%-1/16W-0402-TAP; signal model: R2_60130B10500Y_1M_5%_2; room: Sheet36
R4835 = RSC_0402: part number: RSC_0402-20K_5%_2,6013A0050701,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-20K-5%-1/16W-0402-TAP; signal model: R2_6013A0050701_20K_5%_2; room: Sheet36
R4840 = RSC_0402: part number: RSC_0402-30_5%_2,6013B0094201,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP,30,5%,1/16W,0402,TAP; signal model: R2_6013B0094201_30_5%_2; room: Sheet32
R4846-R4849 = RSC_0402: part number: RSC_0402-15_5%_2,6013B0027201,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP,15,5%,1/16W,0402,TR,-55/+125PPM/DEGREEC; signal model: R2_6013B0027201_15_5%_2; room: Sheet40
R4850 R4852 = RSC_0402: part number: RSC_0402-33_5%_2,60130B3300ZT,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-33-5%-1/16W-0402-TAP; signal model: R2_60130B3300ZT_33_5%_2; room: Sheet40
R4851 R4864 = RSC_SHORT: part number: RSC_SHORT-SHORT_0603_25,SHORT_0603_25,RSC_160X080X080_2_25_SHORT,0.127MM,RSC_SHORT,SHORT_0603_25; signal model: R2_short_0603_25_short_0603_25; room: Sheet41
R4862 = RSC_0402: part number: RSC_0402-10M_5%_2,60130B10600Y,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-10M-5%-1/16W-0402-TAP; signal model: R2_60130B10600Y_10M_5%_2; room: Sheet45
R4870 R4872 = RSC_0402: part number: RSC_0402-100_5%_2,60130B1010ZT,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-100-5%-1/16W-0402-TAP; signal model: R2_60130B1010ZT_100_5%_2; room: Sheet41
R4874 R4875 R4915 = RSC_SHORT: part number: RSC_SHORT-SHORT_0402_15,SHORT_0402_15,RSC_100X050X040_2_15_SHORT,0.127MM,RSC_SHORT,SHORT_0402_15; signal model: R2_short_0402_15_short_0402_15; room: Sheet41
R4876 = RSC_0402: part number: RSC_0402-100_5%_2_DY,60130B1010ZT_DY,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-100-5%-1/16W-0402-TAP; signal model: R2_60130B1010ZT_DY_100_5%_2_DY; room: Sheet39
R4879-R4881 = RSC_0402: part number: RSC_0402-51_5%_2,60130B5100ZT,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-51-5%-1/16W-0402-TAP; signal model: R2_60130B5100ZT_51_5%_2; room: Sheet39
R4892 = RSC_0402: part number: RSC_0402-60.4_1%_2,6013A0077001,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-60.4-1%-1/16W-0402-TAP; signal model: R2_6013A0077001_60_4_1%_2; room: Sheet45
R4898 = RSC_0402: part number: RSC_0402-1M_5%_2,60130B10500Y,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-1M-5%-1/16W-0402-TAP; signal model: R2_60130B10500Y_1M_5%_2; room: Sheet45
R4900 R4906 R4916 R4918 R4920 R4924 = RSC_0402: part number: RSC_0402-0_5%_2,60130B0000ZT,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-0OHM-5%-1/16W-0402-TAP; signal model: R2_60130B0000ZT_0_5%_2; room: Sheet41
R4904 = RSC_0402: part number: RSC_0402-0_5%_2_DY,60130B0000ZT_DY,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-0OHM-5%-1/16W-0402-TAP; signal model: R2_60130B0000ZT_DY_0_5%_2_DY; room: Sheet40
R4927 R4930 = RSC_0402: part number: RSC_0402-30_5%_2,6013B0094201,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP,30,5%,1/16W,0402,TAP; signal model: R2_6013B0094201_30_5%_2; room: Sheet39
R4928 = RSC_0402: part number: RSC_0402-20_5%_2,6013A0003301,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-20-5%-1/8W-0402-TAP; signal model: R2_6013A0003301_20_5%_2; room: Sheet27
R5000 = RSC_0402: part number: RSC_0402-100K_5%_2,60130B1040ZT,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-100K-5%-1/16W-0402-TAP; signal model: R2_60130B1040ZT_100K_5%_2; room: Sheet109
R5001 = RSC_0402: part number: RSC_0402-0_5%_2,60130B0000ZT,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-0OHM-5%-1/16W-0402-TAP; signal model: R2_60130B0000ZT_0_5%_2; room: Sheet109
R6050 R6051 R7602 = RSC_0402: part number: RSC_0402-100_5%_2,60130B1010ZT,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-100-5%-1/16W-0402-TAP; signal model: R2_60130B1010ZT_100_5%_2; room: Sheet9
R6098 = RSC_0603: part number: RSC_0603-4.7K_5%_3,60130B47200Z,RSC_160X080X080_2,0.95MM,RSC_0603,0603,RES-CHIP-4.7K-5%-1/10W-0603-TAP; signal model: R2_60130B47200Z_4_7K_5%_3; room: Sheet9
R6900 R7006 R7008 R7010 R7015-R7017 R7037 R7041 = RSC_0402: part number: RSC_0402-10K_5%_2,60130B1030ZT,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP,10K,5%,1/16W,0402,TR; signal model: R2_60130B1030ZT_10K_5%_2; room: Sheet23
R6980 R6987 R7042 = RSC_SHORT: part number: RSC_SHORT-SHORT_0402_5,SHORT_0402_5,RSC_100X050X040_2_SHORT,0.127MM,RSC_SHORT,SHORT_0402_5; signal model: R2_short_0402_5_short_0402_5; room: Sheet23
R7003 R7054 = RSC_0402: part number: RSC_0402-47K_5%_2,60130B4730ZT,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-47K-5%-1/16W-0402-TAP; signal model: R2_60130B4730ZT_47K_5%_2; room: Sheet23
R7007 R7014 R7040 R7043 R7044 = RSC_0402: part number: RSC_0402-100K_5%_2,60130B1040ZT,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-100K-5%-1/16W-0402-TAP; signal model: R2_60130B1040ZT_100K_5%_2; room: Sheet23
R7012 = RSC_0402: part number: RSC_0402-1K_5%_2,60130B1020ZT,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-1K-5%-1/16W-0402-TAP; signal model: R2_60130B1020ZT_1K_5%_2; room: Sheet23
R7013 = RSC_0402: part number: RSC_0402-200K_5%_2,60130B20400Y,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-200K-5%-1/16W-0402-TAP; signal model: R2_60130B20400Y_200K_5%_2; room: Sheet23
R7024 = RSC_0402: part number: RSC_0402-1K_5%_2,60130B1020ZT,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-1K-5%-1/16W-0402-TAP; signal model: R2_60130B1020ZT_1K_5%_2; room: Sheet22
R7027 = RSC_0402: part number: RSC_0402-100_5%_2,60130B1010ZT,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-100-5%-1/16W-0402-TAP; signal model: R2_60130B1010ZT_100_5%_2; room: Sheet23
R7030 = RSC_0402: part number: RSC_0402-200K_5%_2_DY,60130B20400Y_DY,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-200K-5%-1/16W-0402-TAP; signal model: R2_60130B20400Y_DY_200K_5%_2_DY; room: Sheet22
R7031 R7032 = RSC_0402: part number: RSC_0402-100K_5%_2,60130B1040ZT,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-100K-5%-1/16W-0402-TAP; signal model: R2_60130B1040ZT_100K_5%_2; room: Sheet42
R7034 R7035 = RSC_0603: part number: RSC_0603-150_5%_3,60130B15100T,RSC_160X080X080_2,0.95MM,RSC_0603,0603,RES-CHIP-150-5%-1/10W-0603-TAP; signal model: R2_60130B15100T_150_5%_3; room: Sheet22
R7038 R7039 R7065 R7066 = RSC_0402: part number: RSC_0402-100K_5%_2,60130B1040ZT,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-100K-5%-1/16W-0402-TAP; signal model: R2_60130B1040ZT_100K_5%_2; room: Sheet22
R7063 = RSC_SHORT: part number: RSC_SHORT-SHORT_0402_5,SHORT_0402_5,RSC_100X050X040_2_SHORT,0.127MM,RSC_SHORT,SHORT_0402_5; signal model: R2_short_0402_5_short_0402_5; room: Sheet22
R7068-R7070 = RSC_0402: part number: RSC_0402-0_5%_2,60130B0000ZT,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-0OHM-5%-1/16W-0402-TAP; signal model: R2_60130B0000ZT_0_5%_2; room: Sheet22
R7501 = RSC_0603: part number: RSC_0603-0_5%_3,60130B00000Z,RSC_160X080X055_2,0.7MM,RSC_0603,0603,RES-CHIP-0-5%-1/10W-TAP; signal model: R2_60130B00000Z_0_5%_3; room: Sheet9
R7601 = RSC_0402: part number: RSC_0402-10K_5%_2,60130B1030ZT,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP,10K,5%,1/16W,0402,TR; signal model: R2_60130B1030ZT_10K_5%_2; room: Sheet9
R7603 R60023 R60024 = RSC_0402: part number: RSC_0402-100K_5%_2,60130B1040ZT,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-100K-5%-1/16W-0402-TAP; signal model: R2_60130B1040ZT_100K_5%_2; room: Sheet9
R7604 = RSC_0402: part number: RSC_0402-10K_5%_2_DY,60130B1030ZT_DY,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP,10K,5%,1/16W,0402,TR; signal model: R2_60130B1030ZT_DY_10K_5%_2_DY; room: Sheet9
R50010-R50012 = RSC_0402: part number: RSC_0402-10K_1%_2,60130B10029Z,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-10K-1%-1/16W-0402-TAP; signal model: R2_60130B10029Z_10K_1%_2; room: Sheet74
R50020 R50021 = RSC_0402: part number: RSC_0402-100K_1%_2,6013A0014701,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-100K-1%-1/16W-0402-TAP; signal model: R2_6013A0014701_100K_1%_2; room: Sheet74
R50022 = RSC_0402: part number: RSC_0402-100K_1%_2_DY,6013A0014701_DY,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-100K-1%-1/16W-0402-TAP; signal model: R2_6013A0014701_DY_100K_1%_2_DY; room: Sheet74
R50090 = RSC_0603: part number: RSC_0603-0_5%_3,60130B00000Z,RSC_160X080X055_2,0.7MM,RSC_0603,0603,RES-CHIP-0-5%-1/10W-TAP; signal model: R2_60130B00000Z_0_5%_3; room: Sheet74
R50091 = RSC_0402: part number: RSC_0402-2.49K_1%_2,6013A008810K,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-2.49K-1%-1/16W-0402-TAP; signal model: R2_6013A008810K_2_49K_1%_2; room: Sheet74
R50120 R50121 = RSC_0402: part number: RSC_0402-60.4K_1%_2_DY,6013A0073401_DY,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-60.4K-1%-1/16W-0402-TAP; signal model: R2_6013A0073401_DY_60.4K_1%_2_DY; room: Sheet75
R50220 R50221 = RSC_0402: part number: RSC_0402-60.4K_1%_2_DY,6013A0073401_DY,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-60.4K-1%-1/16W-0402-TAP; signal model: R2_6013A0073401_DY_60.4K_1%_2_DY; room: Sheet76
R50320 R50321 = RSC_0402: part number: RSC_0402-60.4K_1%_2_DY,6013A0073401_DY,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-60.4K-1%-1/16W-0402-TAP; signal model: R2_6013A0073401_DY_60.4K_1%_2_DY; room: Sheet77
R50420 R50421 = RSC_0402: part number: RSC_0402-60.4K_1%_2_DY,6013A0073401_DY,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-60.4K-1%-1/16W-0402-TAP; signal model: R2_6013A0073401_DY_60.4K_1%_2_DY; room: Sheet78
R50500 R50501 = RSC_0402: part number: RSC_0402-121_1%_2,6013A0087705,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-121-1%-1/16W-0402-TAP; signal model: R2_6013A0087705_121_1%_2; room: Sheet79
R50505 R50506 = RSC_0402: part number: RSC_0402-10K_1%_2,60130B10029Z,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-10K-1%-1/16W-0402-TAP; signal model: R2_60130B10029Z_10K_1%_2; room: Sheet79
R50510 = RSC_0402: part number: RSC_0402-1K_1%_2,60130B10019Z,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-1K-1%-1/16W-0402-TAP; signal model: R2_60130B10019Z_1K_1%_2; room: Sheet79
R50600 R50601 = RSC_0402: part number: RSC_0402-121_1%_2,6013A0087705,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-121-1%-1/16W-0402-TAP; signal model: R2_6013A0087705_121_1%_2; room: Sheet80
R50605 R50606 = RSC_0402: part number: RSC_0402-10K_1%_2,60130B10029Z,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-10K-1%-1/16W-0402-TAP; signal model: R2_60130B10029Z_10K_1%_2; room: Sheet80
R50610 = RSC_0402: part number: RSC_0402-1K_1%_2,60130B10019Z,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-1K-1%-1/16W-0402-TAP; signal model: R2_60130B10019Z_1K_1%_2; room: Sheet80
R50700 R50701 = RSC_0402: part number: RSC_0402-121_1%_2,6013A0087705,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-121-1%-1/16W-0402-TAP; signal model: R2_6013A0087705_121_1%_2; room: Sheet81
R50705 R50706 = RSC_0402: part number: RSC_0402-10K_1%_2,60130B10029Z,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-10K-1%-1/16W-0402-TAP; signal model: R2_60130B10029Z_10K_1%_2; room: Sheet81
R50710 = RSC_0402: part number: RSC_0402-1K_1%_2,60130B10019Z,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-1K-1%-1/16W-0402-TAP; signal model: R2_60130B10019Z_1K_1%_2; room: Sheet81
R50800 R50801 = RSC_0402: part number: RSC_0402-121_1%_2,6013A0087705,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-121-1%-1/16W-0402-TAP; signal model: R2_6013A0087705_121_1%_2; room: Sheet82
R50805 R50806 = RSC_0402: part number: RSC_0402-10K_1%_2,60130B10029Z,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-10K-1%-1/16W-0402-TAP; signal model: R2_60130B10029Z_10K_1%_2; room: Sheet82
R50810 = RSC_0402: part number: RSC_0402-1K_1%_2,60130B10019Z,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-1K-1%-1/16W-0402-TAP; signal model: R2_60130B10019Z_1K_1%_2; room: Sheet82
R50900 R50901 = RSC_0402: part number: RSC_0402-121_1%_2,6013A0087705,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-121-1%-1/16W-0402-TAP; signal model: R2_6013A0087705_121_1%_2; room: Sheet83
R50905 R50906 = RSC_0402: part number: RSC_0402-10K_1%_2,60130B10029Z,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-10K-1%-1/16W-0402-TAP; signal model: R2_60130B10029Z_10K_1%_2; room: Sheet83
R50910 = RSC_0402: part number: RSC_0402-1K_1%_2,60130B10019Z,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-1K-1%-1/16W-0402-TAP; signal model: R2_60130B10019Z_1K_1%_2; room: Sheet83
R51000 R51001 = RSC_0402: part number: RSC_0402-121_1%_2,6013A0087705,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-121-1%-1/16W-0402-TAP; signal model: R2_6013A0087705_121_1%_2; room: Sheet84
R51005 R51006 = RSC_0402: part number: RSC_0402-10K_1%_2,60130B10029Z,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-10K-1%-1/16W-0402-TAP; signal model: R2_60130B10029Z_10K_1%_2; room: Sheet84
R51010 = RSC_0402: part number: RSC_0402-1K_1%_2,60130B10019Z,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-1K-1%-1/16W-0402-TAP; signal model: R2_60130B10019Z_1K_1%_2; room: Sheet84
R51100 R51101 = RSC_0402: part number: RSC_0402-121_1%_2,6013A0087705,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-121-1%-1/16W-0402-TAP; signal model: R2_6013A0087705_121_1%_2; room: Sheet85
R51105 R51106 = RSC_0402: part number: RSC_0402-10K_1%_2,60130B10029Z,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-10K-1%-1/16W-0402-TAP; signal model: R2_60130B10029Z_10K_1%_2; room: Sheet85
R51110 = RSC_0402: part number: RSC_0402-1K_1%_2,60130B10019Z,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-1K-1%-1/16W-0402-TAP; signal model: R2_60130B10019Z_1K_1%_2; room: Sheet85
R51200 R51201 = RSC_0402: part number: RSC_0402-121_1%_2,6013A0087705,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-121-1%-1/16W-0402-TAP; signal model: R2_6013A0087705_121_1%_2; room: Sheet86
R51205 R51206 = RSC_0402: part number: RSC_0402-10K_1%_2,60130B10029Z,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-10K-1%-1/16W-0402-TAP; signal model: R2_60130B10029Z_10K_1%_2; room: Sheet86
R51210 = RSC_0402: part number: RSC_0402-1K_1%_2,60130B10019Z,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-1K-1%-1/16W-0402-TAP; signal model: R2_60130B10019Z_1K_1%_2; room: Sheet86
R51316 = RSC_0402: part number: RSC_0402-10K_1%_2,60130B10029Z,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-10K-1%-1/16W-0402-TAP; signal model: R2_60130B10029Z_10K_1%_2; room: Sheet87
R51321 = RSC_0402: part number: RSC_0402-100K_1%_2,6013A0014701,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-100K-1%-1/16W-0402-TAP; signal model: R2_6013A0014701_100K_1%_2; room: Sheet87
R51400 R51422 = RSC_0402: part number: RSC_0402-10K_1%_2,60130B10029Z,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-10K-1%-1/16W-0402-TAP; signal model: R2_60130B10029Z_10K_1%_2; room: Sheet88
R51401-R51403 = RSC_0402: part number: RSC_0402-33_1%_2,6013A0050101,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-33-1%-1/16W-0402-TAP; signal model: R2_6013A0050101_33_1%_2; room: Sheet88
R51421 R51423 R51431 R51433 R51435 R51436 R51439 R51441 = RSC_0402: part number: RSC_0402-100K_1%_2,6013A0014701,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-100K-1%-1/16W-0402-TAP; signal model: R2_6013A0014701_100K_1%_2; room: Sheet88
R51424 = RSC_0402: part number: RSC_0402-10K_1%_2_DY,60130B10029Z_DY,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-10K-1%-1/16W-0402-TAP; signal model: R2_60130B10029Z_DY_10K_1%_2_DY; room: Sheet88
R51430 R51432 R51434 R51437 R51438 R51440 = RSC_0402: part number: RSC_0402-100K_1%_2_DY,6013A0014701_DY,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-100K-1%-1/16W-0402-TAP; signal model: R2_6013A0014701_DY_100K_1%_2_DY; room: Sheet88
R51500 R51501 = RSC_0402: part number: RSC_0402-2K_1%_2,6013A0018401,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-2K-1%-1/16W-0402-TAP; signal model: R2_6013A0018401_2K_1%_2; room: Sheet89
R51507 R51508 R51510-R51512 R51540 R51545 R51550 R51560-R51567 R51569 R51570 R51573 R51574 R51577 R51583 R51586 R51592 R51595 = RSC_0402: part number: RSC_0402-10K_1%_2,60130B10029Z,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-10K-1%-1/16W-0402-TAP; signal model: R2_60130B10029Z_10K_1%_2; room: Sheet89
R51521 R51522 R51531 R51532 = RSC_0402: part number: RSC_0402-33_1%_2,6013A0050101,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-33-1%-1/16W-0402-TAP; signal model: R2_6013A0050101_33_1%_2; room: Sheet89
R51523 R51524 R51533 R51534 R51568 = RSC_0402: part number: RSC_0402-2.2K_5%_2,6013A0049601,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-2.2K-5%-1/16W-0402-TAP; signal model: R2_6013A0049601_2_2K_5%_2; room: Sheet89
R51525 R51579 R51580 R51582 R51584 = RSC_0402: part number: RSC_0402-0_5%_2,60130B0000ZT,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-0OHM-5%-1/16W-0402-TAP; signal model: R2_60130B0000ZT_0_5%_2; room: Sheet89
R51526 = RSC_0402: part number: RSC_0402-0_5%_2_DY,60130B0000ZT_DY,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-0OHM-5%-1/16W-0402-TAP; signal model: R2_60130B0000ZT_DY_0_5%_2_DY; room: Sheet89
R51571 R51575 R51576 R51593 R51596 = RSC_0402: part number: RSC_0402-100K_1%_2,6013A0014701,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-100K-1%-1/16W-0402-TAP; signal model: R2_6013A0014701_100K_1%_2; room: Sheet89
R51572 = RSC_0402: part number: RSC_0402-1K_1%_2,60130B10019Z,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-1K-1%-1/16W-0402-TAP; signal model: R2_60130B10019Z_1K_1%_2; room: Sheet89
R51585 R51587 = RSC_0402: part number: RSC_0402-10K_1%_2_DY,60130B10029Z_DY,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-10K-1%-1/16W-0402-TAP; signal model: R2_60130B10029Z_DY_10K_1%_2_DY; room: Sheet89
R51615 = RSC_0402: part number: RSC_0402-1K_1%_2,60130B10019Z,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-1K-1%-1/16W-0402-TAP; signal model: R2_60130B10019Z_1K_1%_2; room: Sheet91
R51616 = RSC_0603: part number: RSC_0603-0_5%_3,60130B00000Z,RSC_160X080X055_2,0.7MM,RSC_0603,0603,RES-CHIP-0-5%-1/10W-TAP; signal model: R2_60130B00000Z_0_5%_3; room: Sheet91
R51630 R51640 R51650 R51660 = RSC_0402: part number: RSC_0402-100K_1%_2,6013A0014701,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-100K-1%-1/16W-0402-TAP; signal model: R2_6013A0014701_100K_1%_2; room: Sheet91
R51670-R51672 R51680-R51682 = RSC_0402: part number: RSC_0402-10K_1%_2,60130B10029Z,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-10K-1%-1/16W-0402-TAP; signal model: R2_60130B10029Z_10K_1%_2; room: Sheet91
R51711 R51712 R51752 = RSC_0402: part number: RSC_0402-0_5%_2,60130B0000ZT,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-0OHM-5%-1/16W-0402-TAP; signal model: R2_60130B0000ZT_0_5%_2; room: Sheet94
R51720 = RSC_0603: part number: RSC_0603-0_5%_3,60130B00000Z,RSC_160X080X055_2,0.7MM,RSC_0603,0603,RES-CHIP-0-5%-1/10W-TAP; signal model: R2_60130B00000Z_0_5%_3; room: Sheet94
R51721 = RSC_0402: part number: RSC_0402-1K_1%_2,60130B10019Z,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-1K-1%-1/16W-0402-TAP; signal model: R2_60130B10019Z_1K_1%_2; room: Sheet94
R51750 R51751 R51753 = RSC_0402: part number: RSC_0402-10K_1%_2,60130B10029Z,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-10K-1%-1/16W-0402-TAP; signal model: R2_60130B10029Z_10K_1%_2; room: Sheet94
R51900 R51902 R51903 = RSC_0402: part number: RSC_0402-10K_1%_2,60130B10029Z,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-10K-1%-1/16W-0402-TAP; signal model: R2_60130B10029Z_10K_1%_2; room: Sheet97
R52000 R52001 R52003 R52008 R52009 R52011 R52021 R52080 R52081 = RSC_0402: part number: RSC_0402-0_5%_2,60130B0000ZT,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-0OHM-5%-1/16W-0402-TAP; signal model: R2_60130B0000ZT_0_5%_2; room: Sheet98
