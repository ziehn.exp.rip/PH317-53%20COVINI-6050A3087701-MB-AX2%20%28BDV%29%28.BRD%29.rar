# Allegro board PH317-53 COVINI-6050A3087701-MB-AX2 (BDV)(.BRD).brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
VCCAMPHYPLL: length 0.8
  BOTTOM w0.381: C4857.1 234.37,38.15 ; 238,38.25 C4856.1
VCCDPHY_1P243: length 4.9
  BOTTOM w0.089: U4710.BG5 260.92,63.89 261.61,63.89 262.51,64.79
  BOTTOM w0.102: C6.1 264.12,65.23 v2(263.19,65.23) 262.95,65.23 262.51,64.79
VCCDSW_1P5: length 7.6
  TOP w0.102: v1(260.64,42.96) 260.64,42.02 263.67,38.99 v1(264.18,38.99)
  BOTTOM w0.102: C4859.1 264.28,38.89 v1(264.18,38.99)
  BOTTOM w0.254: U4710.BG46 260.41,42.73 v1(260.64,42.96) 260.37,43.23 U4710.BG45
VCCHDA: length 4.2
  TOP w0.254: C4827.1 R4915.1 258.49,58.83 v1(258.42,58.75) 257.76,58.75 257.25,59.26 R4916.1
  BOTTOM w0.254: v1(258.42,58.75) 258.3,58.64 258.09,58.64 258.07,58.65 257.81,58.65 U4710.BB14
VCCIO_PG: length 3.7
  BOTTOM w0.102: R7016.2 67.03,101.88 R7018.1 67.54,102.26 v2(67.54,102.8) 67.59,102.85 67.59,103.79 67.75,103.95 U60500.13
VCCIO_VCCSENSE: length 74
  TOP w0.254: R4524.1 122.32,126.6 v1(122.59,126.34)
  L10 w0.254: v1(122.59,126.34) 121.9,127.03 102.72,127.03 101.72,128.03 101.4,128.03 99.24,128.03 98.55,127.34 92.38,127.34 91.63,128.09 90.21,128.09 89.09,126.98 85.93,126.98 85.84,127.07 85.07,127.07 84.4,126.4 83.82,126.4 79,121.58 79,120.29 76.8,118.09 74.62,118.09 67.63,111.09 67.63,104.03 v3(68.07,103.58)
  BOTTOM w0.076: U4555.H14 v1(122.59,126.34)
  BOTTOM w0.254: U60500.12 68.25,103.76 v3(68.07,103.58)
VCCIO_VSSSENSE: length 74.7
  TOP w0.254: v1(121.72,126.21) 121.51,126.43 R4522.1
  L10 w0.254: v1(121.72,126.21) 121.28,126.65 102.56,126.65 101.56,127.65 99.56,127.65 98.86,126.96 93.32,126.96 93.32,126.95 92.23,126.95 91.47,127.71 90.37,127.71 89.25,126.6 85.78,126.6 85.68,126.69 85.23,126.69 84.56,126.02 83.98,126.02 79.38,121.42 79.38,120.13 76.96,117.71 74.78,117.71 68.01,110.94 68.01,104.41 68.64,103.78 68.64,103.57 v1(68.75,103.46)
  BOTTOM w0.076: v1(121.72,126.21) 121.72,126.6 121.6,126.73 U4555.J14
  BOTTOM w0.254: R60526.1 68.38,102.31 C60509.2 68.38,102.85 68.75,103.22 v1(68.75,103.46) U60500.11
VCCMPHY_SENSE_L: length 8.6
  BOTTOM w0.089: U4710.K47 242.29,42.37 242.29,41.9 242.34,41.84 242.34,41.41 242.74,41.01 242.74,39.2 242.85,39.1 242.85,39.09
  BOTTOM w0.254: R4874.1 241.5,35.76 241.33,35.93 241.33,36.05 R4872.2 241.3,36.48 241.73,36.91 v2(242.16,36.91) 242.16,37.34 242.85,38.02 242.85,39.09
VCCPLL_OC: length 86.6
  TOP w0.254: v1(91.69,125.2) 91.61,125.2 91.29,125.51 C4726.1 C4786.1
  L10 w0.203: 92.08,121.53 92.08,122.4 92.14,122.45 92.14,124.75 v1(91.69,125.2)
  L10 w0.254: v1(122.58,123.95) 122.56,123.93 122.53,123.93 121.99,123.4 121.99,122.28 122.23,122.04 122.23,122.04 122.32,121.95 122.32,121.59
  L10 w0.305: v1(91.69,125.2) 88.38,125.2 88,124.81 87.96,124.81 87.92,124.77 ; 92.08,121.53 92.3,121.31 107.41,121.31 107.91,121.81 108.34,121.81 108.43,121.72 108.44,121.72 108.87,121.29 122.02,121.29 122.32,121.59
  L10 w0.381: v1(75.41,94.5) 75.41,96.5 77.85,98.94 77.85,117.61 82.54,122.3 82.9,122.3 83.69,123.09 84.75,123.09 84.96,123.29 84.96,123.5 85.28,123.82 85.54,123.82 86.05,124.34 87.49,124.34 87.92,124.77
  BOTTOM w0.203: U4555.BH13 91.24,125.42 91.49,125.19 v1(91.69,125.2)
  BOTTOM w0.254: U4555.BJ13 91.05,125.5 U4555.BH13
  BOTTOM w0.305: v1(122.58,123.95) 122.6,123.97 122.6,123.99 U4555.G11
  BOTTOM w0.381: v2(74.27,95.51) 74.16,95.41 C7042.2 73.47,95.26 73.16,94.94 Q7007.S 73.18,94.38 R7035.2 74.56,94.5 v1(75.41,94.5)
VCCPLL_OC_DIS: length 1.3
  BOTTOM w0.102: Q10.3 74.61,93.01 R7035.1
VCCPLL_OC_DISCHARGE_EN: length 3.3
  BOTTOM w0.102: v2(74.67,88.19) 74.68,88.2 R144.2 R143.1 73.93,89.03 73.96,89.06 Q10.5 Q10.6
VCCPLL_OC_EN: length 21.3
  BOTTOM w0.102: 73.96,90.73 Q10.2 ; 73.96,90.73 75.41,90.73 75.94,91.27 75.94,95.08 74.16,96.86 v2(72.2,96.86) 71.96,97.11 69.06,97.11 68.48,96.52 Q7006.5 68.48,94.64 68.25,94.42 C7039.1 ; 73.96,90.73 73.01,90.73 R7069.2
VCCPRIM_1P2: length 3.1
  TOP w0.381: 250.72,54.72 C8.1 ; C9.1 252.33,55.65
  BOTTOM w0.254: U4710.AK22 v1(251.58,54.37) U4710.AK23 ; U4710.AJ22 v1(250.77,54.37) U4710.AJ23
  vias: v2(251.46,56.26)
VCCSA_VCCSENSE: length 41.1
  TOP w0.254: v1(94.08,159.21) 93.98,159.31 R66680.1 ; R4517.1 119.99,144.32 v1(119.49,144.82)
  L3 w0.076: 119.94,145.27 119.94,145.32
  L3 w0.254: v1(94.08,159.21) 94.18,159.11 95.5,159.11 97.08,157.53 117.34,157.53 119.94,154.94 119.94,145.32 ; v1(119.49,144.82) 119.94,145.27
  BOTTOM w0.076: U4555.M38 v1(119.49,144.82)
VCCSA_VSSSENSE: length 41.9
  TOP w0.254: R66681.1 93.92,158.42 v1(94.08,158.58) ; R4521.1 119.1,144.45 118.92,144.63 118.92,145.01 119.36,145.46 v1(119.45,145.46)
  L3 w0.254: v1(119.45,145.46) 119.4,145.5 119.4,154.72 117.12,157 96.93,157 95.23,158.7 94.21,158.7 v1(94.08,158.58)
  BOTTOM w0.076: U4555.M37 119.49,143.9 119.19,144.19 119.19,144.55 119.09,144.65 119.09,144.92 119.1,144.93 119.1,145.11 119.32,145.33
  BOTTOM w0.254: 119.32,145.33 v1(119.45,145.46)
VCCSENSE: length 36.8
  TOP w0.254: v1(93.14,160.48) R66180.1 ; R21.1 108.23,144.06 107.91,144.06 v1(107.29,144.68)
  L3 w0.254: v1(107.29,144.68) 107.39,144.58 108.23,144.58 110.31,146.66 110.31,153.21 108.14,155.38 95.42,155.38 93.09,157.7 93.09,160.4 93.14,160.45 v1(93.14,160.48)
  BOTTOM w0.102: U4555.AG37 108,143.99 108,144.53 107.85,144.68 v1(107.29,144.68)
VCCSFR: length 0.5
  TOP w0.381: R4570.1 231.09,54.56
  vias: v2(230.4,55.33)
VCCST_PWRGD: length 5.6
  BOTTOM w0.102: R4739.2 67.01,69.32 67.01,69.32 R4722.1 66.24,69.9 66.05,69.71 Q4751.6 65.65,70.75 65.2,71.19 C4702.1 v2(63.57,71.19)
VCCST_PWRGD_CPU: length 103.5
  L8 w0.102: v3(68.09,70.62) 67.15,71.56 67.15,79.2 68.95,81 69.28,81 69.79,81.51 69.79,82.81 70.43,83.45 70.43,83.98 70.43,87.28 72.64,89.49 72.64,93.53 76.09,96.98 78.59,96.98 81.56,99.95 81.56,104.07 82.11,104.62 82.11,106.99 84.27,109.15 119.63,109.15 123.97,113.49 123.97,119.82 122.18,121.6 122.18,122.98 122.13,123.03 122.13,123.36 122.18,123.41 122.18,123.87 122.19,123.87 122.19,124.11 122.59,124.51 v1(122.59,125.55)
  BOTTOM w0.076: U4555.H13 v1(122.59,125.55)
  BOTTOM w0.102: v3(68.09,70.62) 67.86,70.38 R4722.2
VDDQ_PG: length 13.5
  L5 w0.102: v1(63.34,72.93) 63.34,75.31 66.06,78.03 66.06,79.61 68.32,81.87 v1(68.92,81.87)
  BOTTOM w0.102: v1(68.92,81.87) 69.02,81.77 69.71,81.77 U60300.12 ; v1(63.34,72.93) 63.55,72.93 R7008.2
VSS: length 2.3
  TOP w0.102: TP4713.1 251.89,48.47 v1(251.69,48.67)
  BOTTOM w0.102: U4710.AL37 251.69,47.96 v1(251.69,48.67)
VSSMPHY_SENSE_L: length 9.3
  BOTTOM w0.089: 242.47,39.09 242.47,39.4 242.57,39.51 242.57,40.9 242.17,41.3 242.17,41.77 242.11,41.82 242.11,42.12 241.83,42.4 241.83,42.73 U4710.K46
  BOTTOM w0.254: 242.47,39.09 242.47,38.18 241.17,36.88 v2(240.89,36.88) 240.89,36.61 240.53,36.24 R4870.1 240.53,35.28 R4875.1
VSSSENSE: length 36.4
  TOP w0.254: R66181.1 93.3,161.37 v1(93.44,161.22) ; R4531.1 107.82,143.46 v1(107.29,144)
  L3 w0.254: v1(93.44,161.22) 93.7,160.96 93.7,159.92 93.47,159.69 93.47,158.04 95.63,155.88 108.35,155.88 110.69,153.55 110.69,146.49 108.4,144.2 107.49,144.2 v1(107.29,144)
  BOTTOM w0.076: v1(107.29,144) 107.6,144.31 U4555.AG38
A20GATE: length 2.7
  BOTTOM w0.102: R317.2 216.44,26.67 v2(215.74,27.36) 215.57,27.53 U1.126
AC_LED: length 188.1
  L3 w0.102: v1(34.97,42.35) 39.47,42.35 41.33,40.49 50.04,40.49 60.15,30.38 87.5,30.38 87.73,30.15 123.6,30.15 126.93,26.83 174.85,26.83 175.2,27.18 176.12,27.18 178.28,29.34 179.02,30.08 185.11,30.08 186.23,28.96 194.89,28.96 195.04,29.11 200.99,29.11 v1(201.39,29.52)
  BOTTOM w0.102: v1(201.39,29.52) 201.39,28.83 201.57,28.65 201.57,26.83 201.44,26.7 201.44,25.99 201.49,25.95 U1.29 201.49,24.43 201.24,24.18 199.97,24.18 199.84,24.31 199.84,25.45 199.44,25.86 v2(198.65,25.86) 198.35,25.86 197.35,26.86 R341.1 ; CN603.14 v1(34.97,42.35)
ACDRV: length 14
  L10 w0.508: v3(50.77,46.3) 50.77,46.08 50.26,45.57 44.73,45.57 v1(44.55,45.75) 42.54,45.75 41.47,46.82 v1(39.18,46.82)
  BOTTOM w0.381: 37.66,47.06 R60026.1 ; C60002.2 39.02,47.47
  BOTTOM w0.432: R60004.2 v3(50.77,46.3)
ACPRES: length 183.9
  L8 w0.102: v1(35.98,49.46) 36.7,49.46 38.1,48.06 51.91,48.06 v1(52.9,47.07) 52.93,47.07 53.36,47.5 58.04,47.5 59.38,46.16 59.38,44.05 70.84,32.59 121.85,32.59 126.67,27.77 155.53,27.77 156.14,28.38 156.48,28.38 156.88,27.97 186.81,27.97 187.54,28.71 193.42,28.71 193.97,29.26 197.99,29.26 199.29,30.56 v3(199.87,30.56)
  BOTTOM w0.102: Q60002.2 36.03,49.41 v1(35.98,49.46) ; v3(199.87,30.56) 200.25,30.18 200.25,28.29 199.49,27.53 U1.35 ; R60007.1 52.76,47.21 v1(52.9,47.07) 52.99,47.07 53.95,46.11 U60000.5
ACPRESENT: length 7.4
  BOTTOM w0.089: 261.7,44.68 260.38,44.68 U4710.BG42
  BOTTOM w0.102: 261.7,44.68 262,44.38 262,44.26 262.75,43.51 264.03,43.51 264.4,43.89 R4805.2 264.43,43.97 v2(265.2,43.97) 265.55,43.97 D4801.1
ADC_IN_N: length 71.7
  L8 w0.097: v1(143.25,56.26) 143.46,56.47 143.46,58.41 145.23,60.19 145.23,73.54 145.67,73.97 145.67,81.95 144.65,82.97 144.65,95.92 145.29,96.55 145.29,98.97 144.67,99.59 144.67,111.86 151.29,118.48 152.04,118.48 152.85,119.29 v4(153.28,119.5)
  BOTTOM w0.102: v4(153.28,119.5) U50000.BJ11
  BOTTOM w0.122: C52009.1 143.46,56.63 143.46,56.47 v1(143.25,56.26) 143.44,56.08 143.44,55.8 R52008.2
ADC_IN_P: length 71.7
  L8 w0.097: v4(153.29,118.7) 153.29,118.92 153.19,119.02 152.9,119.02 152.14,118.26 151.39,118.26 144.9,111.77 144.9,99.68 145.51,99.07 145.51,96.46 144.88,95.83 144.88,83.06 145.89,82.05 145.89,73.88 145.46,73.44 145.46,60.09 143.68,58.32 143.68,56.47 143.89,56.26 v1(143.91,56.26)
  BOTTOM w0.102: U50000.BJ9 153.6,118.48 153.38,118.7 v4(153.29,118.7)
  BOTTOM w0.122: R52009.2 143.9,55.49 143.66,55.73 143.66,56.09 143.84,56.26 v1(143.91,56.26) 143.91,56.32 143.68,56.55 143.68,56.77 C52008.1
ADC_IN_R_N: length 2.8
  BOTTOM w0.122: U52000.19 144.46,53.07 143.51,54.01 143.51,54.33 143.2,54.64 R52008.1
ADC_IN_R_P: length 2.8
  BOTTOM w0.122: R52009.1 143.74,54.36 143.74,54.11 144.86,52.99 U52000.20
ADC_MUX_R_SEL: length 2.7
  BOTTOM w0.102: U52000.29 147.94,50.37 v2(148.19,50.62) 148.83,50.62 R52003.1
ALERT_PCH#: length 17.1
  TOP w0.102: v3(271.32,57.72) 270.86,58.18 R4820.2
  L8 w0.102: v1(257.63,53.11) 258.04,53.52 260.27,53.52 262.51,55.76 269.36,55.76 v3(271.32,57.72)
  BOTTOM w0.089: v1(257.63,53.11) 257.73,53.01 U4710.BB26
ALL_PG_REQ: length 3.1
  BOTTOM w0.102: R50010.1 143.23,126.24 v2(142.57,125.58) 142.24,125.25 142.24,124.46 Q50010.G
ALL_POWER_GOOD: length 99.1
  L5 w0.102: v1(118.97,45.75) 120.29,44.43 134.64,44.43 135.42,43.65 141.64,43.65 142.13,43.16 146.51,43.16 146.78,43.42 149.97,43.42 149.98,43.44 150.04,43.44 152.3,45.7 167.26,45.7 168.25,44.71 189.35,44.71 192.07,41.99 194.48,41.99 195.42,42.93 204.16,42.93 204.51,42.57 206.35,42.57 v1(206.98,43.21)
  BOTTOM w0.102: v1(118.97,45.75) 118.28,45.75 117.28,46.76 R53540.2 116.86,47.5 116.81,47.45 TP53540.1 116.11,47.67 U53540.4 ; v1(206.98,43.21) 206.93,43.26 206.93,44.17 R345.1
ALL_PWGD_IN: length 166.8
  L8 w0.102: v1(60.8,34.8) 63.47,32.13 122.02,32.13 126.59,27.56 167.68,27.56 167.69,27.58 194.62,27.58 194.87,27.33 197.53,27.33 199.07,28.87 199.59,28.87 199.61,28.9 199.95,28.9 199.97,28.87 206.91,28.87 208.22,30.18 213,30.18 214.4,28.78 215.81,28.78 216.55,28.05 v1(216.56,28.05)
  BOTTOM w0.102: U1.124 215.16,28.33 215.17,28.34 215.54,28.34 215.66,28.46 216.14,28.46 v1(216.56,28.05) 216.56,28.04 216.56,28.03 C300.1 ; D7002.3 60.37,35.23 v1(60.8,34.8) 60.8,34.32 R7004.1
ALL_PWGD_INTO_EC: length 201.3
  L5 w0.102: v1(188.39,40.54) 188.07,40.22 175.19,40.22 174.77,39.81 172.51,39.81 171.19,41.13 168.22,41.13 168.01,40.92 166.42,40.92 165.8,41.54 159.71,41.54 158.61,40.44 153.92,40.44 153.79,40.57 139.55,40.57 138.28,41.84 131.9,41.84 131.24,41.18 105.44,41.18 104.85,41.76 82.08,41.76 75.02,48.82 72.09,48.82 66.24,54.68 66.24,55.88 64.92,57.2 64.92,60.15 58.95,66.12 58.95,74.12 60.2,75.37 61.92,75.37 64.03,77.47 64.03,79.75 64.69,80.41 64.81,80.41 68.2,83.8 68.2,85.07 68.65,85.53 68.65,85.72 68.65,89.89 68.81,90.05 68.81,91.69 68.53,91.97 68.53,99.22 v1(67.46,100.28)
  BOTTOM w0.102: v1(188.39,40.54) 188.34,40.49 188.34,36.88 191,34.22 193.95,34.22 v2(195.14,33.02) 195.43,32.73 U1.48 ; v1(67.46,100.28) 67.92,100.74 R7018.2
ALWAYS_PW_EN: length 4.3
  TOP w0.102: v3(216.43,30.53) 216.88,30.99 R7015.1 217.57,30.99 217.57,30.98 R7012.2
  BOTTOM w0.102: v3(216.43,30.53) 216.15,30.25 215.54,30.25 215.22,29.93 U1.120
AMP_EN: length 214.5
  TOP w0.102: U500.47 22.81,58.32 22.93,58.45 22.93,59.34 22.65,59.62 v1(22.65,59.85) 22.65,60.31 R525.2
  L8 w0.102: v1(22.65,59.85) 22.65,58.87 29.13,52.39 29.13,50.45 30.65,48.92 36.15,48.92 45.58,39.5 55.53,39.5 61.35,33.68 61.46,33.68 63.22,31.93 107.79,31.93 108.62,31.09 122.5,31.09 126.23,27.36 189.53,27.36 189.55,27.38 194.54,27.38 194.78,27.13 197.95,27.13 198.89,28.07 202.19,28.07 204.03,26.23 v1(211.98,26.23)
  BOTTOM w0.102: R334.1 213.99,23.4 v2(213.97,23.42) 212.04,23.42 211.71,23.75 211.71,24.25 211.79,24.33 211.79,24.42 211.89,24.52 U1.3 211.89,26.02 211.98,26.11 v1(211.98,26.23)
AUD_CPU_SCLK: length 198.6
  TOP w0.109: R4930.1 255.39,71.02 254.97,71.02 v2(254.78,71.2) 254.6,71.02 250.45,71.02 249.87,70.44 244.32,70.44 243.05,71.71 240.49,71.71 240.49,71.71 240.15,71.71 240.15,71.71 237.72,71.71 236.56,70.55 235.42,70.55 230.89,66.02 221.92,66.02 214.89,73.06 164.07,73.06 162.33,71.32 156.46,71.32 152.27,75.51 152.27,79.16 148.82,82.61 148.55,82.61 137.29,93.88 137.29,118.09 138.96,119.76 138.96,121.85 v1(138.53,122.28)
  L3 w0.076: v1(123.23,137.36) 123.6,137.73 124.81,137.73 125.14,137.39 130.25,137.39 131.52,138.66 133.96,138.66 138.53,134.09 v1(138.53,122.28)
  BOTTOM w0.076: v1(123.23,137.36) 123.23,137.36 122.91,137.03 U4555.G27
  BOTTOM w0.109: v1(138.53,122.28) 138.2,122.61 137.19,122.61 C4594.1
AUD_CPU_SCLK_R: length 7.5
  TOP w0.109: R4930.2 v2(255.62,69.14) 255.06,68.58 v1(255.06,68.08)
  BOTTOM w0.089: 254.35,67.53 253.95,67.53 253.56,67.15 253.56,66.46 253.64,66.39 253.64,66.23 253.64,65.84 253.74,65.74 253.74,65.05 253.29,64.59 253.29,64.49 253.17,64.38 253.17,64.22 U4710.AM3
  BOTTOM w0.109: v1(255.06,68.08) 254.52,67.53 254.35,67.53
AUD_CPU_SDI: length 195.7
  TOP w0.109: R4927.1 253.93,70.25 v2(253.72,70.46) 253.65,70.53 250.66,70.53 250.08,69.94 235.51,69.94 231.09,65.53 221.72,65.53 214.68,72.57 164.27,72.57 162.53,70.83 156.25,70.83 151.78,75.3 151.78,78.96 148.62,82.12 147.48,82.12 136.8,92.8 136.8,118.29 138.02,119.52 v1(138.02,120.65)
  L3 w0.076: v1(122.59,134.99) 122.96,134.62 125.35,134.62 125.35,134.62 125.99,135.26 125.99,136.2 126.21,136.42 126.21,136.81 126.48,137.07 132.85,137.07 132.91,137.01 134.9,137.01 138.02,133.89 v1(138.02,120.65)
  BOTTOM w0.076: v1(122.59,134.99) 122.91,135.32 U4555.G25
AUD_CPU_SDOP: length 33.9
  L3 w0.076: v1(123.88,138.92) 124.48,139.53 125.12,139.53 125.99,138.65 127.24,138.65 128.19,137.7 129.91,137.7 131.33,139.12 134.18,139.12 138.99,134.32 138.99,122.09 138.72,121.82 138.63,121.82 138.53,121.72 v1(138.53,121.62)
  BOTTOM w0.076: U4555.G29 122.91,138.61 123.22,138.92 123.87,138.92 123.87,138.92 v1(123.88,138.92)
  BOTTOM w0.109: v1(138.53,121.62) 138.5,121.62 137.99,122.12 R4928.1
AUD_PCH_SDI: length 168.1
  TOP w0.109: v1(137.13,120.55) 136.67,120.09 136.67,119.1 136.32,118.75 136.32,92.6 147.28,81.65 148.42,81.65 151.31,78.76 151.31,75.11 156.06,70.36 162.72,70.36 164.47,72.1 214.49,72.1 216.66,69.93 220.98,65.61 221.05,65.54 221.53,65.06 231.29,65.06 235.7,69.47 250.54,69.47 251.08,68.94 252.02,68.94 v2(253.5,67.45) v1(254,66.96)
  BOTTOM w0.089: U4710.AN3 253.42,64.32 253.59,64.49 253.59,64.63 253.92,64.96 253.92,66.51
  BOTTOM w0.109: 253.92,66.51 253.92,66.88 v1(254,66.96) ; R4928.2 137.61,121.14 137.13,120.65 v1(137.13,120.55)
AUD_PCH_SDO: length 6.1
  TOP w0.109: v1(254.4,68.1) v2(254.4,68.76) 254.78,69.13 R4927.2
  BOTTOM w0.089: 253.44,65.97 253.44,65.79 253.54,65.69 253.54,65.11 U4710.AM2
  BOTTOM w0.109: v1(254.4,68.1) 254.25,68.1 253.36,67.21 253.36,66.4 253.45,66.31 253.45,65.98 253.44,65.97
B/I: length 2
  TOP w0.102: R7601.2 22.32,31.41 22.37,31.35 v3(22.37,31.34)
  BOTTOM w0.102: v3(22.37,31.34) 22.37,31.35 22.36,31.36 CN6050.6
BATPRES#: length 42.8
  TOP w0.102: R7501.1 28.7,28.81 v3(31.21,31.32)
  L5 w0.102: v3(31.21,31.32) 31.21,31.4 31.85,32.03 38.48,32.03 48.87,42.42 50.34,42.42 55.31,47.39 56.96,47.39 v1(58.49,48.92)
  BOTTOM w0.102: U60000.15 58.48,48.91 v1(58.49,48.92) R60022.2
BATT_CLK: length 5
  TOP w0.109: v3(27.1,33) 27.07,32.97 C7602.1 27.06,32 D7602.2 27.84,30.1 R6050.2
  BOTTOM w0.109: v3(27.1,33) 26.54,33 26.36,32.82 CN6050.4
BATT_IN#: length 205.4
  TOP w0.102: R7602.1 R7501.2 v3(25.58,26.06)
  L3 w0.102: v1(70.71,45.27) 69.85,44.4 69.85,41.09 70.93,40.01 85.73,40.01 87.23,38.51 100.66,38.51 101.99,37.19 133.35,37.19 134.67,35.87 146.91,35.87 147.7,36.66 159.05,36.66 160.83,34.88 167.08,34.88 167.44,35.24 167.52,35.24 168.94,36.67 173.34,36.67 175,38.33 186.48,38.33 187.11,38.97 196.47,38.97 197.26,39.75 202.46,39.75 v1(202.71,39.5)
  L5 w0.102: v1(70.71,45.27) 70.31,45.27 59.89,34.84 59.89,30.69 56.28,27.08 54.45,27.08 50.86,23.48 38.29,23.48 36.45,25.33 26.32,25.33 v3(25.58,26.06)
  BOTTOM w0.102: v1(202.71,39.5) 202.69,39.53 U1.71
BRD_ID0: length 15.6
  TOP w0.102: R4843.2 270.23,52.15 v1(269.67,52.71) 270,53.04 R4842.2
  L8 w0.102: v3(260.02,48.72) 260.63,48.11 266.34,48.11 267.97,49.74 267.97,51.56 269.12,52.71 v1(269.67,52.71)
  BOTTOM w0.089: U4710.BE34 259.13,48.62 259.23,48.72 v3(260.02,48.72)
BRD_ID1: length 20.4
  TOP w0.102: R4839.2 268.75,51.71 v3(269.11,52.07) 269.47,52.07 270.28,51.26 R4841.2
  L8 w0.102: v3(269.11,52.07) 268.3,51.26 268.3,49.78 265.74,47.22 261.62,47.22 261.1,46.71 258.93,46.71 257.98,47.66 257.4,47.66 256.49,48.58 v1(256.49,49.23)
  BOTTOM w0.089: v1(256.49,49.23) 256.6,49.34 U4710.BA33
BRD_ID2: length 15.6
  TOP w0.102: v1(267.67,53.06) R4838.2 268.25,53.67 v2(267.99,53.93) 267.88,54.04 R4837.2
  L8 w0.102: v1(256.54,50.56) 261.48,50.56 262.07,51.16 265.33,51.16 267.23,53.06 v1(267.67,53.06)
  BOTTOM w0.089: v1(256.54,50.56) 256.54,49.96 U4710.AW32
BRD_ID3: length 20.9
  TOP w0.102: 269.6,50.9 269.07,50.37 R4831.2 ; 269.6,50.9 270.13,50.37 R4836.2 ; 269.6,50.9 v3(269.59,50.9)
  L8 w0.102: v1(255.9,49.23) 255.9,47.82 257.22,46.5 261.25,46.5 261.77,47.02 266.33,47.02 268.75,49.44 268.75,50.07 269.59,50.9 v3(269.59,50.9)
  BOTTOM w0.089: U4710.AV34 255.58,48.9 v1(255.9,49.23)
BUF_PLT_RST#: length 349.1
  TOP w0.102: v1(271.95,57.14) 271.7,56.88 R4729.1 R4776.1 ; CN301.6 211.32,30.9 211.18,31.05 211.18,31.08 210.99,31.27 207.59,31.27 206.88,30.56 205.53,30.56 204.97,30 v1(204.97,29.54)
  L3 w0.102: v1(204.97,29.54) 205.56,28.96 209.85,28.96 210.69,28.12 210.69,26.8 211.91,25.58 214.35,25.58 v1(215.93,23.99) 217.21,25.27 221.63,25.27 224.64,22.25 229.33,22.25 v1(229.87,22.79) ; v1(284.36,25.94) 284.54,26.12 284.54,28.54 284.2,28.88 284.2,29.33 283.82,29.71 283.82,33.61 281.94,35.49 280.31,35.49 272.59,43.21 272.59,53.31 271.68,54.22 271.68,56.86 v1(271.95,57.14)
  L8 w0.102: v1(215.93,23.99) 215.39,24.54 214.47,24.54 212.68,22.75 211.54,22.75 210.66,21.87 210.66,20.48 210.05,19.87 207.41,19.87 206.73,20.55 206.04,20.55 v1(205.23,21.36) ; v1(67.44,41.36) 74.6,34.19 106.52,34.19 107.72,33 122.02,33 126.01,29.01 157.32,29.01 158.15,28.17 167.71,28.17 167.94,28.4 v1(174.7,28.4)
  L10 w0.102: v1(67.44,41.36) 55.01,41.36 53.82,42.55 39.36,42.55 38.03,43.88 35.51,43.88 35.04,44.35 v1(32.82,44.35) ; v1(174.7,28.4) 175.57,27.52 185.24,27.52 185.72,28 186.6,28.88 186.76,28.88 186.76,28.88 192.48,28.88 192.61,28.76 195.4,28.76 195.68,29.04 195.85,29.04 199.46,29.04 199.53,29.1 200.03,29.1 200.1,29.04 204.47,29.04 v1(204.97,29.54) ; v1(229.87,22.79) 229.97,22.89 231.16,22.89 232.83,24.55 237.31,24.55 238.24,25.48 242.52,25.48 243.25,26.22 247.52,26.22 248.41,27.11 255.39,27.11 255.58,27.29 268,27.29 270.46,29.75 279.17,29.75 281.59,27.32 283.75,27.32 284.54,26.53 284.54,26.15 284.36,25.98 v1(284.36,25.94)
  BOTTOM w0.102: U3500.17 230.2,25.39 229.66,24.85 229.66,23.96 v2(229.77,23.85) 229.87,23.75 v1(229.87,22.79) ; U4700.4 v1(271.95,57.14) ; v1(174.7,28.4) 174.8,28.4 175.2,28.8 CN1900.50 ; R347.1 204.85,22.41 204.85,22.13 205.23,21.75 v1(205.23,21.36) ; v1(67.44,41.36) 67.44,46.97 67.77,47.3 CN1901.50 ; CN603.18 v1(32.82,44.35) ; v1(284.36,25.94) 284.7,26.28 CN1300.52
CATERR_N: length 25.4
  TOP w0.109: R4533.2 81.48,156 v1(81.23,156.26)
  L3 w0.076: v1(81.23,156.26) 81.23,155.32 82.2,154.34 82.2,150.1 84.06,148.24 84.28,148.24 84.28,148.24 85.67,148.24 86.64,147.27 86.64,142.68 86.33,142.37 86.33,139.98 v1(85.32,138.97)
  BOTTOM w0.076: U4555.BM30 88.47,138.78 85.51,138.78 v1(85.32,138.97)
CFG<0>: length 1.5
  TOP w0.109: R4535.1 88.83,134.92 88.46,135.29 v1(88.46,135.55)
  BOTTOM w0.109: v1(88.46,135.55) 88.14,135.23 U4555.BN25
CFG<1>: length 1.5
  TOP w0.109: v1(88.46,137.13) 89.09,136.5 TP4512.1
  BOTTOM w0.076: v1(88.46,137.13) 88.14,136.8 U4555.BN27
CFG<2>: length 1.3
  TOP w0.109: R4529.1 87.45,135.2 v1(87.81,135.55)
  BOTTOM w0.109: U4555.BN26 88.14,135.88 v1(87.81,135.55)
CFG<3>: length 1.2
  TOP w0.109: v1(87.81,137.13) 87.82,137.12 TP4513.1
  BOTTOM w0.076: v1(87.81,137.13) 88.14,137.45 U4555.BN28
CFG<4>: length 3.3
  TOP w0.109: v1(84.62,132.39) 84.57,132.34 R4523.1
  BOTTOM w0.076: U4555.BR20 86.54,131.52 86.06,131.52 86.05,131.5 85.52,131.5
  BOTTOM w0.102: v1(84.62,132.39) 84.63,132.39 85.52,131.5
CFG<5>: length 1.5
  TOP w0.109: R4528.1 88.85,130.44 v1(88.46,130.83)
  BOTTOM w0.109: v1(88.46,130.83) 88.46,130.9 U4555.BM20
CFG<6>: length 4.9
  TOP w0.109: v1(82.42,130.46) 82.29,130.32 R4526.1
  BOTTOM w0.076: U4555.BT20 86.05,131.09 83.05,131.09
  BOTTOM w0.102: 83.05,131.09 v1(82.42,130.46)
CFG<7>: length 3.4
  TOP w0.109: R4530.1 85.21,131.87 v1(85.21,132.42)
  BOTTOM w0.076: U4555.BP20 87.31,131.22 86.85,131.68 85.97,131.68
  BOTTOM w0.102: 85.97,131.68 85.95,131.68 v1(85.21,132.42)
CFG<8>: length 3.4
  TOP w0.109: v1(84.58,133.97) 84.34,133.72 TP4503.1
  BOTTOM w0.076: U4555.BR23 86.67,133.42 86.43,133.42 86.31,133.29 85.26,133.29 v1(84.58,133.97)
CFG<9>: length 4.7
  TOP w0.109: R4534.1 83.43,133.9 v1(83.36,133.97)
  BOTTOM w0.076: v1(83.36,133.97) 84.21,133.12 86.51,133.12 U4555.BR22
CFG<10>: length 1.4
  TOP w0.109: TP4504.1 85.61,133.8 v1(85.78,133.97)
  BOTTOM w0.109: v1(85.78,133.97) 85.8,133.97 U4555.BT23
CFG<11>: length 5.2
  TOP w0.109: TP4505.1 82.19,134.53 v1(82.19,133.97)
  BOTTOM w0.076: v1(82.19,133.97) 83.24,132.92 86.06,132.92 U4555.BT22
CFG<12>: length 1.5
  TOP w0.109: TP4506.1 89.72,130.22 v1(89.11,130.83)
  BOTTOM w0.076: U4555.BM19 v1(89.11,130.83)
CFG<13>: length 4.2
  TOP w0.109: TP4507.1 83.68,130.66 83.68,130.65 v1(83.68,130.44)
  BOTTOM w0.076: U4555.BR19 86.43,130.03 85.43,130.03 84.09,130.03 v1(83.68,130.44)
CFG<14>: length 4.2
  TOP w0.109: v1(84.32,130.44) 84.32,129.8 84.31,129.8 TP4508.1
  BOTTOM w0.076: U4555.BP19 87.19,130.73 85.85,130.73 85.75,130.83 84.71,130.83 v1(84.32,130.44)
CFG<15>: length 1.3
  TOP w0.109: v1(85.59,130.41) 85.59,130.41 TP4509.1
  BOTTOM w0.076: U4555.BT19 86.16,130.41 85.59,130.41 v1(85.59,130.41)
CFG<16>: length 1.3
  TOP w0.109: TP4511.1 86.88,133.7 v1(87.16,133.98)
  BOTTOM w0.076: U4555.BP23 87.49,133.65 v1(87.16,133.98)
CFG<17>: length 2.5
  TOP w0.109: TP4510.1 89.01,133.56 88.23,133.56 v1(87.81,133.98)
  BOTTOM w0.076: v1(87.81,133.98) 88.14,133.65 U4555.BN23
CFG<18>: length 1.2
  TOP w0.109: TP4502.1 87.81,132.69 v1(87.81,132.4)
  BOTTOM w0.076: U4555.BN22 v1(87.81,132.4)
CFG<19>: length 1.2
  TOP w0.109: TP4501.1 87.16,132.09 v1(87.16,132.4)
  BOTTOM w0.076: U4555.BP22 v1(87.16,132.4)
CFG_RCOMP: length 1.1
  TOP w0.254: R4519.1 85.13,135.16 v1(85.69,135.16)
  BOTTOM w0.254: U4555.BT25 v1(85.69,135.16)
CHARGE_USBPWR_EN: length 92.4
  TOP w0.102: v1(278.91,28.47) 279.17,28.73 279.58,29.14 279.58,29.14 279.6,29.16 279.6,29.44 v2(280.29,30.13) 280.93,30.13 R2555.1
  L8 w0.102: v1(207.37,39.35) 208.7,40.67 228.04,40.67 231.52,37.19 237.92,37.19 238.6,36.5 239.87,36.5 240.53,37.16 245.82,37.16 246.39,36.59 248.27,36.59 248.87,36 253.02,36 255.76,33.25 256.08,33.25 256.69,32.64 256.69,30.99 257.73,29.95 271.19,29.95 277.81,23.33 279.4,23.33 280.07,24 280.07,25.03 279.7,25.4 279.7,27.69 v1(278.91,28.47)
  BOTTOM w0.102: v1(207.37,39.35) 207.69,39.35 208.29,39.94 U1.85
CHG_LED: length 188.6
  L3 w0.102: v1(35.48,42.85) 39.26,42.85 41.41,40.69 50.13,40.69 60.24,30.59 87.59,30.59 87.82,30.36 123.69,30.36 127.01,27.03 174.76,27.03 175.12,27.38 176.04,27.38 178.19,29.54 179.01,30.36 192,30.36 192.4,30.76 198.04,30.76 198.68,30.13 201.55,30.13 201.84,30.42 203.43,30.42 v3(204.31,29.54)
  BOTTOM w0.102: CN603.15 v1(35.48,42.85) ; R342.1 207.51,23.14 206.69,23.97 U1.16 206.69,28.55 206.1,29.14 204.72,29.14 v3(204.31,29.54)
CL_CLK1: length 59.3
  TOP w0.109: v1(282.19,28.86) 282.19,28.68 R1347.2
  L3 w0.076: v1(282.19,28.86) 282.19,29.56 279,32.75 279,35.63 270.96,43.66 270.96,53.85 268.47,56.34 268.2,56.34 267.92,56.34 265.48,56.34 265.08,55.93 263.52,55.93 261.44,58.02 259.76,58.02 258.62,59.16 257.37,59.16 256.6,59.93 256.6,60.09 255.75,60.95 255.75,64.98 256.26,65.48 256.26,66.53 255.97,66.81 255.97,66.86 v3(255.88,66.96)
  BOTTOM w0.089: v3(255.88,66.96) 255.84,66.99 254.92,66.99 254.28,66.35 254.28,64.69 254.44,64.52 U4710.AR2
CL_DATA1: length 61.4
  TOP w0.109: v3(281.5,28.86) 281.3,28.65 R1346.2
  L3 w0.076: v3(281.5,28.86) 281.16,28.52 280.2,28.52 278.02,30.69 278.02,35.67 270.3,43.39 270.3,53.57 268.2,55.68 265.76,55.68 265.35,55.27 263.8,55.27 263.25,55.27 262.03,56.49 259.62,56.49 257.74,58.37 256.51,58.37 254.26,60.62 254.26,66.06 254.8,66.6 v1(255.14,66.6)
  BOTTOM w0.089: 254.86,66.48 254.45,66.07 254.45,64.79 254.7,64.55 254.7,63.2 254.76,63.13 254.76,63.13 U4710.AT5
  BOTTOM w0.109: v1(255.14,66.6) 255.01,66.48 254.86,66.48
CL_RST#1: length 59.7
  TOP w0.109: v1(280.82,28.91) 280.82,28.47 R1345.2
  L3 w0.076: v1(255.67,66.32) 255.52,66.17 254.84,66.17 254.59,65.93 254.59,60.99 256.75,58.83 257.75,58.83 259.76,56.82 262.17,56.82 263.39,55.6 263.66,55.6 265.21,55.6 265.62,56.01 268.06,56.01 268.33,56.01 270.63,53.71 270.63,43.53 278.36,35.81 278.36,30.86 280.31,28.91 v1(280.82,28.91)
  BOTTOM w0.089: v1(255.67,66.32) 255.5,66.15 254.83,66.15 254.63,65.94 254.63,64.95 254.71,64.88 254.71,64.87 254.87,64.7 254.87,63.69 U4710.AU4
CLINKCLK: length 2.2
  TOP w0.109: v3(282.11,26.34) 282.19,26.42 R1347.1
  BOTTOM w0.109: CN1300.42 282.2,26.43 v3(282.11,26.34)
CLINKDAT: length 2.3
  TOP w0.109: R1346.1 281.3,26.51 v1(281.43,26.38)
  BOTTOM w0.109: v1(281.43,26.38) 281.7,26.64 CN1300.40
CLINKRST#: length 2.4
  TOP w0.109: R1345.1 280.41,26.68 v3(280.72,26.37)
  BOTTOM w0.109: CN1300.38 281.2,26.85 v3(280.72,26.37)
CLK_CPU_DN: length 177.2
  L3 w0.084: v3(128.78,139.53) 128.53,139.28 128.53,139.16 128.61,139.08 129.91,139.08 130.82,139.99 134.28,139.99 140.71,133.56 140.71,125.17 148.87,117.01 148.87,110.3 150.85,108.32 150.85,97.58 158.44,89.99 158.44,87.47 164.58,81.33 213.74,81.33 214.71,82.3 232.55,82.3 233,81.85 233.51,81.85 234.15,81.21 234.57,81.21 235.41,80.38 235.41,74.32 232.76,71.68 232.76,63.02 233.4,62.39 233.84,62.39 233.91,62.31 v1(234.13,62.31)
  BOTTOM w0.076: v3(128.78,139.53) 128.53,139.78 128.53,139.98 128.3,140.21 127.03,140.21 126.81,140.42 U4555.A32
  BOTTOM w0.089: 236.83,61.94 236.85,61.94 236.87,61.93 238.13,61.93 U4710.C8
  BOTTOM w0.107: v1(234.13,62.31) 234.5,61.94 236.83,61.94
CLK_CPU_DP: length 177.2
  L3 w0.084: v1(128.12,139.53) 128.32,139.34 128.32,139.07 128.52,138.87 129.99,138.87 130.91,139.78 134.19,139.78 140.5,133.47 140.5,125.09 148.66,116.93 148.66,110.21 150.64,108.23 150.64,97.49 158.23,89.9 158.23,87.39 164.49,81.12 213.83,81.12 214.8,82.09 232.46,82.09 232.91,81.64 233.08,81.64 233.42,81.64 234.06,81 234.48,81 235.2,80.29 235.2,74.41 232.55,71.76 232.55,62.93 233.52,61.96 v3(233.57,61.96)
  BOTTOM w0.076: U4555.B31 126.24,140.19 126.82,140.19 126.96,140.05 128.23,140.05 128.37,139.91 128.37,139.78 v1(128.12,139.53)
  BOTTOM w0.089: 236.83,61.74 236.92,61.74 236.93,61.75 237.94,61.75 U4710.B8
  BOTTOM w0.107: 236.83,61.74 234.41,61.74 234.24,61.91 233.97,61.91 233.92,61.96 v3(233.57,61.96)
CLK_CPU_PCIBCLK_DN: length 177.2
  L3 w0.076: 125.72,141.41 125.02,142.11 125.02,142.35 125.1,142.43 125.37,142.43 v1(125.49,142.31)
  L3 w0.084: v3(235.35,63.89) 235.1,64.15 235.1,64.67 234.11,65.66 234.11,71.26 236.61,73.75 236.61,80.87 235.07,82.41 234.64,82.41 234,83.05 233.49,83.05 233.04,83.5 214.21,83.5 213.25,82.53 166.36,82.53 166.09,82.8 166.09,82.8 162.38,86.51 162.38,86.9 162.39,89.86 161.59,90.66 160.94,90.66 158.17,93.44 158.17,95.72 152.06,101.83 152.06,108.8 150.07,110.79 150.07,119.82 142,127.9 142,133.98 134.57,141.41 125.72,141.41
  BOTTOM w0.076: v1(125.49,142.31) 125.43,142.37 U4555.C36
  BOTTOM w0.089: 237.28,62.84 237.78,62.84 U4710.B6
  BOTTOM w0.107: 237.28,62.84 237.15,62.97 236.14,62.97 235.35,63.76 v3(235.35,63.89)
CLK_CPU_PCIBCLK_DP: length 177.2
  L3 w0.076: 125.72,141.2 125.63,141.2 125.51,141.33 125.51,141.39 124.86,142.04 124.86,142.64 v3(124.72,142.78)
  L3 w0.084: 125.72,141.2 134.48,141.2 141.79,133.9 141.79,127.81 149.86,119.74 149.86,110.71 151.85,108.72 151.85,101.74 157.96,95.63 157.96,93.35 160.86,90.45 161.5,90.45 162.17,89.78 162.17,86.98 162.17,86.6 162.17,86.43 165.88,82.72 166.28,82.32 213.34,82.32 214.3,83.29 232.96,83.29 233.41,82.84 233.92,82.84 234.55,82.2 234.98,82.2 236.39,80.79 236.39,73.84 233.9,71.34 233.9,65.58 234.89,64.58 234.89,64.13 v1(234.67,63.91)
  BOTTOM w0.076: v3(124.72,142.78) 124.72,142.57 U4555.D35
  BOTTOM w0.089: U4710.A6 237.46,62.67 237.37,62.67 237.36,62.66 237.2,62.66 237.17,62.69 237.14,62.69 237.13,62.7
  BOTTOM w0.107: v1(234.67,63.91) 235.1,63.48 235.34,63.48 236.05,62.76 237.07,62.76 237.13,62.7
CLK_CPUNSSC_DN: length 178.9
  L3 w0.084: v3(124.53,140.52) 124.43,140.52 124.28,140.36 124.28,140.19 124.39,140.07 125.14,140.07 125.72,140.65 134.48,140.65 141.4,133.74 141.4,127.65 149.47,119.58 149.47,110.55 149.7,110.32 151.46,108.56 151.46,98.69 161.19,88.96 161.19,86.68 165.94,81.94 213.5,81.94 214.46,82.9 232.8,82.9 233.25,82.45 233.75,82.45 234.11,82.1 234.39,81.81 234.82,81.81 236.01,80.63 236.01,74.07 233.51,71.58 233.51,63.85 234.44,62.92 234.93,62.92 235,62.84 235.3,62.84 v1(235.35,62.89)
  BOTTOM w0.076: v3(124.53,140.52) 124.53,140.21 124.63,140.11 U4555.D31
  BOTTOM w0.089: U4710.C6 238.5,62.36 238.43,62.44 238.3,62.44 238.15,62.28 237.16,62.28 237,62.44 235.35,62.44 235.2,62.59 235.2,62.74 v1(235.35,62.89)
CLK_CPUNSSC_DP: length 178.9
  L3 w0.084: v3(234.76,62.52) 234.57,62.71 234.35,62.71 233.3,63.76 233.3,71.66 235.8,74.16 235.8,80.54 234.73,81.6 234.31,81.6 233.89,82.01 233.67,82.24 233.16,82.24 232.71,82.69 214.55,82.69 213.58,81.72 165.86,81.72 160.98,86.6 160.98,88.88 151.25,98.61 151.25,108.47 149.61,110.11 149.26,110.46 149.26,119.49 141.19,127.56 141.19,133.65 134.39,140.44 125.8,140.44 125.22,139.86 124.31,139.86 124.07,140.1 124.07,140.31 v1(123.87,140.51)
  BOTTOM w0.076: U4555.E31 v1(123.87,140.51)
  BOTTOM w0.089: v3(234.76,62.52) 234.77,62.53 235.01,62.53 235.28,62.26 236.93,62.26 237.08,62.11 238.28,62.11 238.41,61.98 238.55,61.98 U4710.D7
CLK_LAN_DN: length 241
  L10 w0.084: v1(246.94,65.54) 247.01,65.54 247.24,65.31 247.24,64.26 245.86,62.88 245.09,62.88 244.62,62.41 244.62,58.67 239.84,53.88 238.7,53.88 237.66,52.85 237.66,51.64 236.66,50.63 235.19,50.63 232.46,47.91 229.41,47.91 227.97,46.47 221.24,46.47 220.13,47.58 145.21,47.58 143.81,46.18 141.75,46.18 137.85,42.28 111.44,42.28 102.58,51.13 78.31,51.13 76.13,48.96 71.31,48.96 70.49,48.14 60.7,48.14 59.27,49.57 52.49,49.57 51.98,49.06 36.58,49.06 36.39,48.87 32.13,48.87 31.63,48.36 31.63,47.05 31.77,46.9 v3(31.77,46.51)
  BOTTOM w0.107: v1(246.94,65.54) 247.23,65.24 247.23,65.05 U4710.AA1 ; CN603.20 32.99,45.35 31.83,46.51 v3(31.77,46.51)
CLK_LAN_DP: length 241
  L10 w0.084: v1(32.46,46.51) 31.84,47.13 31.84,48.28 32.22,48.66 36.47,48.66 36.66,48.85 52.07,48.85 52.58,49.36 59.18,49.36 60.62,47.92 70.57,47.92 71.4,48.75 76.22,48.75 78.4,50.92 102.49,50.92 111.35,42.07 137.94,42.07 141.84,45.97 143.9,45.97 145.29,47.36 220.05,47.36 221.15,46.26 228.06,46.26 229.5,47.7 232.55,47.7 235.28,50.42 236.75,50.42 237.88,51.55 237.88,52.76 238.79,53.67 239.93,53.67 244.83,58.58 244.83,62.32 245.18,62.67 245.95,62.67 247.45,64.18 247.45,65.39 v3(247.6,65.54)
  BOTTOM w0.107: v3(247.6,65.54) 247.44,65.38 247.44,64.74 U4710.Y2 ; CN603.21 32.79,45.85 32.46,46.18 v1(32.46,46.51)
CLK_LPC_DEBUG_R: length 66.9
  TOP w0.109: R4852.2 268.18,32.33 267.38,31.53 v2(267.26,31.53) 266.45,31.53 v1(262.99,28.07) ; v1(216.43,25.87) 216.43,26.52 215.36,27.59 215.36,29.26 214.73,29.9 212.95,29.9 212.82,30.03 CN301.9
  L3 w0.076: v1(216.43,25.87) 217.12,26.56 222.14,26.56 225.55,23.15 229.57,23.15 229.76,23.35 230.43,23.35 230.99,23.35 231.52,23.88 238.71,23.88 241.69,26.86 247.06,26.86 248.37,28.17 256.62,28.17 258.48,26.31 261.2,26.31 262.97,28.07 v1(262.99,28.07)
CLK_LPC_EC: length 68.9
  TOP w0.109: R4850.2 270.05,32.78 269.86,32.58 269.13,32.58 266.87,30.33 v2(266.72,30.33) 266.24,30.33 263.98,28.07 v1(263.9,28.07)
  L3 w0.076: v1(226.03,20.6) 226.74,21.31 230.32,21.31 231.97,22.97 239.09,22.97 239.11,22.99 239.12,22.99 241.16,25.02 246.64,25.02 248.34,26.73 255.72,26.73 257.25,25.2 262.71,25.2 263.9,26.39 v1(263.9,28.07)
  BOTTOM w0.109: v1(226.03,20.6) 224.3,20.6 223.78,20.08 211.24,20.08 210.18,21.14 R331.1
CLK_PCIE_DGPU_100MHZ_N: length 172.5
  L10 w0.084: v1(250.35,61.29) 250.54,61.48 250.54,62.11 250.26,62.39 250.26,64.89 248.49,66.65 244.8,66.65 244.67,66.78 243.83,67.62 236.34,67.62 234.37,65.65 221.16,65.65 219.39,67.43 219.39,70.33 218.61,71.11 216.43,71.11 216.02,71.51 215.04,72.49 166.89,72.49 165.34,74.04 158,74.04 154.48,77.56 154.48,87.44 151.33,90.59 151.33,93.1 142.02,102.41 142.02,112.02 143.79,113.79 143.79,121.38 145.45,123.05 145.45,123.67 149.3,127.51 149.3,128.96 v1(149.07,129.19)
  BOTTOM w0.105: U50000.BM27 151.5,130.75 151.23,130.49 149.91,130.49 149.4,129.97 149.4,129.51 v1(149.07,129.19)
  BOTTOM w0.107: v1(250.35,61.29) 250.7,60.94 250.9,60.94 U4710.AH9
CLK_PCIE_DGPU_100MHZ_P: length 172.5
  L10 w0.084: v3(250.34,60.63) 250.75,61.04 250.75,61.12 250.75,62.2 250.47,62.48 250.47,64.98 250.34,65.1 248.58,66.87 244.88,66.87 243.92,67.83 236.25,67.83 234.29,65.87 221.25,65.87 219.6,67.52 219.6,70.42 218.7,71.32 216.51,71.32 216.23,71.6 215.13,72.7 166.97,72.7 165.43,74.25 158.09,74.25 154.69,77.64 154.69,87.52 151.54,90.67 151.54,93.19 142.23,102.5 142.23,111.94 144,113.7 144,121.3 145.67,122.96 145.67,123.58 149.51,127.42 149.51,128.97 v1(149.73,129.19)
  BOTTOM w0.105: v1(149.73,129.19) 149.6,129.32 149.6,129.89 150,130.28 U50000.BM26
  BOTTOM w0.107: U4710.AH10 250.87,60.62 250.75,60.73 250.44,60.73 v3(250.34,60.63)
CLK_PCIE_SSD1_DN: length 195.1
  L10 w0.084: v3(80.84,47.86) 81.07,48.08 82.06,48.08 83.68,49.7 101.96,49.7 111.96,39.7 155.64,39.7 158.79,36.55 166.59,36.55 170.34,40.31 175.1,40.31 180.86,46.07 219.54,46.07 220.62,44.99 236.41,44.99 236.9,44.99 239.13,47.21 239.13,50.95 240.25,52.07 241.99,52.07 245.59,55.66 245.59,55.99 246.4,56.8 247.55,56.8 248.18,57.43 249.17,57.43 249.53,57.79 249.53,58.44 249.29,58.69 249.13,58.69 v1(248.94,58.88)
  BOTTOM w0.107: v3(80.84,47.86) 80.65,48.06 80.34,48.06 80.27,47.98 80.27,47.58 79.89,47.2 77.97,47.2 77.59,47.58 77.59,48.08 77.49,48.19 77.24,48.19 77.1,48.05 CN1901.53 ; v1(248.94,58.88) 248.94,58.86 249.05,58.75 U4710.AE14
CLK_PCIE_SSD1_DP: length 195.1
  L10 w0.084: v3(248.75,58.25) 248.98,58.47 249.2,58.47 249.32,58.36 249.32,57.88 249.08,57.64 248.09,57.64 247.97,57.52 247.97,57.52 247.46,57.01 246.31,57.01 245.38,56.08 245.38,55.75 241.91,52.28 240.16,52.28 238.92,51.03 238.92,47.3 236.81,45.2 236.49,45.2 220.71,45.2 219.62,46.28 180.78,46.28 175.01,40.52 170.25,40.52 166.5,36.76 158.88,36.76 155.73,39.91 112.05,39.91 102.05,49.91 83.59,49.91 81.98,48.3 81.07,48.3 v1(80.84,48.52)
  BOTTOM w0.107: U4710.AE15 249.44,58.21 249.27,58.37 248.88,58.37 v3(248.75,58.25) ; CN1901.55 77.1,48.55 77.25,48.4 77.57,48.4 77.8,48.17 77.8,47.66 78.06,47.41 79.8,47.41 80.06,47.66 80.06,48.07 80.26,48.26 80.59,48.26 v1(80.84,48.52)
CLK_PCIE_SSD2_DN: length 123.8
  L10 w0.084: v3(249.82,62.17) 249.75,62.17 249.51,61.94 249.51,61.61 248.53,60.63 248.35,60.63 247.72,60.63 246.94,59.85 246.94,58.92 243.19,55.17 242.51,55.17 238.48,51.15 238.48,47.42 236.65,45.59 220.87,45.59 219.77,46.69 174.34,46.69 169.08,41.43 161.76,41.43 159.51,39.18 159.51,38.51 v1(159.73,38.28)
  BOTTOM w0.107: v3(249.82,62.17) 249.59,62.17 249.44,62.32 U4710.AE6 ; v1(159.73,38.28) 159.51,38.06 159.51,29.59 161.2,27.9 167.32,27.9 167.46,28.05 CN1900.53
CLK_PCIE_SSD2_DP: length 123.9
  L10 w0.084: v1(249.07,62.13) 249.3,61.9 249.3,61.69 248.44,60.84 247.63,60.84 246.73,59.94 246.73,59.01 243.1,55.38 242.42,55.38 238.27,51.24 238.27,47.5 236.57,45.8 220.96,45.8 219.85,46.9 174.25,46.9 169,41.64 161.68,41.64 159.3,39.27 159.3,38.51 v1(159.07,38.28)
  BOTTOM w0.107: v1(249.07,62.13) 249.1,62.13 U4710.AE7 ; CN1900.55 167.46,27.55 167.32,27.7 161.11,27.7 159.3,29.51 159.3,38.06 v1(159.07,38.28)
CLK_WLAN_DN: length 100
  L3 w0.084: v1(283.89,21.39) 283.87,21.39 283.66,21.18 283.66,20.93 284.67,19.92 293.2,19.92 293.74,20.46 293.74,20.79 295.52,22.57 295.52,26.13 294.38,27.27 294.38,29.08 293.21,30.24 293.21,34.28 277.49,50 277.49,58.24 277.49,58.62 269.16,66.95 262.28,66.95 260.6,68.63 258.94,68.63 258.7,68.88 253.68,68.88 252.21,67.41 250.78,67.41 249.38,66 249.38,65.26 248.6,64.48 245.75,64.48 245.25,64.98 245.25,65.39 245.12,65.52 v1(244.98,65.52)
  BOTTOM w0.089: U4710.T2 244.85,64.56 244.85,64.75 244.67,64.93 244.67,65.31 244.89,65.52 v1(244.98,65.52)
  BOTTOM w0.107: CN1300.49 283.95,20.6 283.82,20.72 283.82,21.32 v1(283.89,21.39)
CLK_WLAN_DP: length 100.1
  L3 w0.084: v1(283.31,21.39) 283.31,21.39 283.45,21.25 283.45,20.84 284.58,19.71 293.29,19.71 293.95,20.37 293.95,20.7 295.73,22.48 295.73,26.22 294.59,27.36 294.59,29.16 293.42,30.33 293.42,34.37 277.7,50.09 277.7,58.15 277.7,58.71 269.24,67.16 262.37,67.16 260.69,68.85 259.03,68.85 258.78,69.09 253.59,69.09 252.12,67.62 250.7,67.62 249.17,66.09 249.17,65.35 248.51,64.69 245.84,64.69 245.46,65.07 245.46,65.33 v3(245.64,65.51)
  BOTTOM w0.089: U4710.T1 v3(245.64,65.51)
  BOTTOM w0.107: CN1300.47 283.45,20.59 283.54,20.68 283.54,21.16 v1(283.31,21.39)
CLKIN_XTAL: length 72.3
  TOP w0.089: R1342.2 244.1,62.05 v3(244.19,61.95)
  TOP w0.109: v1(288.29,28.81) 288.29,28.4 288.38,28.3 R1352.1
  L3 w0.076: v3(244.19,61.95) 244.19,61.7 248.33,57.56 250.01,57.56 253.1,54.47 253.1,54.23 253.33,54 254.26,54 254.61,53.65 258.24,53.65 259.86,52.02 259.86,51.51 260.41,50.97 261.58,50.97 261.78,51.17 265.78,51.17 266.09,50.85 266.98,50.85 268.65,49.18 268.65,43.16 277.26,34.55 277.26,28.3 278.18,27.38 278.84,27.38 279.36,26.86 280.63,25.59 281.78,25.59 282.12,25.25 284.73,25.25 285.67,26.19 285.67,26.88 286.56,27.77 287.24,27.77 v1(288.29,28.81)
  BOTTOM w0.109: U4710.R6 244.39,62.23 244.3,62.23 244.19,62.12 v3(244.19,61.95)
CLKREQ0#: length 6.5
  BOTTOM w0.102: U4710.BF31 259.48,50.47 261.77,50.47 262.1,50.8 264.82,50.8 v2(264.87,50.85) 265.1,51.08 R4755.2
CLKREQ4#: length 4.1
  TOP w0.089: v2(258.82,52.86) 259.34,52.35 R4714.2 258.64,52.12 v1(258.54,52.02)
  BOTTOM w0.089: U4710.BA30 257.01,51.17 257.29,51.44 257.69,51.44 258.11,51.87 258.39,51.87 v1(258.54,52.02)
CLKREQ5#: length 2.3
  TOP w0.102: R4715.2 254.46,50.75 v3(254.45,50.75)
  BOTTOM w0.102: v3(254.45,50.75) 253.87,50.75 253.45,51.17 U4710.AN29
CLKREQ6#: length 7
  BOTTOM w0.089: 246.83,39.09 247.14,39.41 247.28,39.41 249.1,41.24 249.1,42.28 249.45,42.63 U4710.AE47
  BOTTOM w0.102: R4754.2 246.88,38.7 v2(246.66,38.93) 246.83,39.09
CLKREQ7#: length 6.4
  BOTTOM w0.102: R4757.2 v2(246,37.82) 246,39.02 246.6,39.62 247.19,39.62 248.02,40.45 248.02,41.53 248.33,41.84 U4710.AC48
CLKREQ8#: length 6.3
  TOP w0.102: v1(248.84,45.06) 247.89,46.02 v2(247.89,46.24) 246.85,46.24 245.54,47.55 245.28,47.55 244.79,48.04 R4763.2
  BOTTOM w0.089: U4710.AE41 249.17,45.06 v1(248.84,45.06)
CLKREQ9#: length 6.3
  BOTTOM w0.102: R4761.2 248.55,37.04 248.55,38.39 v2(247.93,39.01) 249.78,40.86 249.78,41.73 U4710.AF48
CLKREQ10#: length 6.7
  TOP w0.102: R4765.2 242.8,47.78 v2(243.44,47.13) 243.79,46.78 245.69,46.78 247.23,45.23 v1(247.65,45.23)
  BOTTOM w0.089: v1(247.65,45.23) 248.18,45.23 U4710.AC41
CLKREQ11#: length 5.6
  TOP w0.102: R4766.2 244.34,47.26 v2(244.72,47.26) 245.53,47.26 247.01,45.77 v1(247.37,45.77)
  BOTTOM w0.089: v1(247.37,45.77) 247.95,45.77 U4710.AC39
CLKREQ12#: length 5.6
  TOP w0.102: R4768.2 246.5,47.05 v2(246.77,47.05) 246.99,47.27 247.59,47.27 248.51,46.35 248.51,45.93 248.79,45.65 v1(248.85,45.65)
  BOTTOM w0.089: v1(248.85,45.65) 248.99,45.65 U4710.AE39
CLKREQ13_LAN#: length 225.2
  L3 w0.102: v1(67.44,40.66) 73.59,34.51 75.74,34.51 75.99,34.27 98.6,34.27 99.03,34.7 105.2,34.7 105.62,35.12 132.93,35.12 133.83,34.22 147.6,34.22 148.13,34.75 158.41,34.75 160.59,32.57 164.55,32.57 165.08,33.1 168.59,33.1 168.87,32.82 174.58,32.82 174.79,32.82 176.85,34.88 189.06,34.88 190.43,36.25 196.34,36.25 196.75,36.66 204.82,36.66 205.29,37.12 221.85,37.12 222.83,38.1 228.37,38.1 229.39,37.09 236.08,37.09 238.86,39.87 246.59,39.87 v1(247.09,40.36)
  L10 w0.102: v1(35,43.31) 35.04,43.35 38.27,43.35 39.28,42.34 53.74,42.34 55.23,40.85 67.25,40.85 v1(67.44,40.66)
  BOTTOM w0.089: U4710.AB48 247.66,41.69 247.66,41.68 247.66,41.01 247.09,40.44 v1(247.09,40.36)
  BOTTOM w0.102: CN603.16 34.96,43.35 v1(35,43.31)
CLKREQ14_WLAN#: length 52.1
  TOP w0.102: R1358.2 283.77,23.09 v2(284.3,22.56) 284.91,21.95 v1(285.01,21.95)
  L3 w0.102: v1(248.77,43.81) 248.86,43.81 250.35,42.32 257.37,42.32 258.39,41.3 258.92,41.3 260.1,40.12 266.21,40.12 276.67,29.67 276.67,27.6 278.18,26.09 278.18,24.11 278.86,23.42 281.17,23.42 281.53,23.07 283.46,23.07 284.58,21.95 v1(285.01,21.95)
  BOTTOM w0.089: U4710.AC44 v1(248.77,43.81)
  BOTTOM w0.102: v1(285.01,21.95) 285.04,21.92 285.04,21.43 284.95,21.34 CN1300.53
CLKREQ15#: length 7.6
  TOP w0.102: v1(247.78,44.57) 247.6,44.57 245.97,46.21 v2(245.46,46.21) 245.1,46.57 243.28,46.57 242.99,46.87 242.6,46.87 R4773.2
  BOTTOM w0.089: v1(247.78,44.57) U4710.AC43
CLKREQ_SSD1#: length 190
  L10 w0.102: v3(253.62,49.58) 253.39,49.81 248.59,49.81 246.67,47.88 241.86,47.88 240.82,46.84 239.68,46.84 237.37,44.53 231.55,44.53 229.69,42.68 220.29,42.68 218.44,44.53 212.58,44.53 212.29,44.24 199.23,44.24 198.82,44.66 182.93,44.66 178.18,39.91 171.24,39.91 167.49,36.16 156.25,36.16 154.94,37.47 137.49,37.47 136.7,38.26 112.85,38.26 103.26,47.84 103.09,47.84 91.97,47.84 90.86,46.73 87.31,46.73 v1(86.23,47.81)
  BOTTOM w0.089: v3(253.62,49.58) 253.67,49.58 U4710.AR32
  BOTTOM w0.102: v1(86.23,47.81) 84.32,49.71 81.68,49.71 80.96,50.43 R1904.2 R1901.2
CLKREQ_SSD2#: length 101.3
  TOP w0.102: R1903.2 176.37,31 R1902.2 176.34,30.27 175.56,29.5 v2(175.21,29.5) v1(174.71,29)
  L3 w0.102: v1(257.45,51.06) 257.45,51.05 257.45,50.9 256.65,50.09 253.39,50.09 252.9,49.61 250.44,49.61 249.81,48.97 248.34,48.97 245.51,46.15 245.51,44.41 243.62,42.52 241.18,42.52 239.87,41.22 237.79,41.22 236.3,39.73 222.33,39.73 221.29,38.69 214.19,38.69 214.01,38.87 210.26,38.87 210,39.12 208.4,39.12 208.2,38.92 203.02,38.92 202.87,38.76 188.63,38.76 186.4,36.53 175.87,36.53 v1(174.06,34.73)
  BOTTOM w0.089: U4710.BB30 257.75,50.68 257.45,50.98 257.45,51.05 v1(257.45,51.06)
  BOTTOM w0.102: v1(174.71,29) 174.82,29.11 174.82,32.87 174.06,33.63 v1(174.06,34.73)
CN_MIC: length 15.4
  L3 w0.254: v1(301.38,154.93) 310.2,154.93 310.28,154.84 311.38,154.84 312.3,155.77 JACK600.4
  BOTTOM w0.254: L600.1 C23.1 R610.1 300.29,155.22 D7521.2 301.11,155.21 v1(301.38,154.93)
CNV_BRI_DT: length 14
  TOP w0.109: v1(260.5,69.4) 261.03,69.4 v2(261.16,69.52) 261.26,69.42 R1364.1
  BOTTOM w0.089: U4710.AV4 255.84,63.6 255.84,63.63 255.87,63.65 255.87,63.96 255.83,63.99 255.75,64.11 255.73,64.13 255.73,64.44 256.28,64.99 256.28,65.26 256.47,65.45 256.47,65.85
  BOTTOM w0.102: 256.47,65.85 257.17,66.55 257.17,67.06
  BOTTOM w0.109: 257.17,67.06 257.17,67.38 257.05,67.5 257.05,67.91 257.73,68.58 259.69,68.58 v1(260.5,69.4) 260.37,69.4 260.14,69.62 R4724.1 R4603.1
CNV_BRI_DT_R: length 53.7
  TOP w0.109: v3(279.13,30.67) 279.13,30.92 277.98,32.07 277.98,62.36 277.78,62.56 277.78,62.59 271.26,69.1 271.07,69.1 263.38,69.1 R1364.2
  BOTTOM w0.109: v3(279.13,30.67) 279.13,30.01 280.7,28.44 280.7,27.64 CN1300.36
CNV_BRI_RSP: length 62.9
  TOP w0.109: R1320.1 277.51,29.57 277.51,62.16 271.14,68.53 262.02,68.53 v2(261.72,68.23) 261.41,68.53 260.25,68.53 v1(259.79,68.08)
  BOTTOM w0.089: U4710.AY2 256.71,64.44 256.71,65.17 256.9,65.35 256.9,65.75 257.91,66.75 257.91,66.88
  BOTTOM w0.109: 257.91,66.88 259.1,68.08 v1(259.79,68.08) 259.79,68.1 261.24,69.55 261.24,70.38 R4725.1
CNV_BRI_RSP_R: length 3.6
  TOP w0.109: v3(278.66,27.86) 278.37,27.86 R1320.2
  BOTTOM w0.109: v3(278.66,27.86) 277.99,28.53 277.49,28.53 277.2,28.24 CN1300.22
CNV_CLKREQ: length 11.9
  TOP w0.089: v1(257.15,57.53) 257.55,57.53 258.11,58.09 v2(259,58.09) 261.72,58.09
  TOP w0.102: 261.72,58.09 263.88,60.25 265.68,60.25 v1(265.78,60.15)
  BOTTOM w0.089: U4710.BA17 257.15,57.18 v1(257.15,57.53)
  BOTTOM w0.102: R4772.1 266.78,59.16 v1(265.78,60.15)
CNV_PA_BLANKING: length 52.3
  TOP w0.102: R1361.1 283.08,28.73 v1(283,28.81)
  L3 w0.102: v1(283,28.81) 283,29.23 279.35,32.89 279.35,35.77 272.18,42.93 272.18,43.1 272.18,53.14 271.01,54.32 271.01,55.71 270.02,56.7 266.74,56.7 265.67,57.76 262.56,57.76 261.95,58.37 260.31,58.37 258.06,60.62 256.66,60.62 256.1,61.17 256.1,62.43 v1(256.51,62.83)
  BOTTOM w0.089: U4710.AV6 256.13,62.66 256.33,62.66 256.5,62.83 v1(256.51,62.83)
CNV_PA_BLANKING_R: length 3.1
  TOP w0.102: R1361.2 282.83,26.96 v1(282.83,25.94)
  BOTTOM w0.102: v1(282.83,25.94) 282.7,26.06 CN1300.44
CNV_RF_RESET#: length 9.1
  BOTTOM w0.089: U4710.BE16 259.54,57.75 259.77,57.97 260.28,57.97 260.3,57.95 260.96,57.95 261.16,57.75 262.51,57.75
  BOTTOM w0.102: R4777.1 R4748.1 266.22,57.23 v2(265.7,57.75) 262.51,57.75
CNV_RF_RESET#_R: length 35.7
  TOP w0.102: v1(268.77,57.82) 268.88,57.71 268.88,55.19 270.22,53.85 271.45,53.85 272.31,52.99 272.31,38.43 274.16,36.58 274.16,29.64 273.91,29.38 273.91,29.14 v1(273.61,28.83) 273.45,28.68 R1335.2
  BOTTOM w0.102: v1(268.77,57.82) 268.47,58.12 R4777.2 ; CN1300.10 274.2,28.38 273.75,28.83 v1(273.61,28.83)
CNV_RGI_DT: length 6.3
  TOP w0.089: R1321.1 259.94,66.6 v2(259.84,66.7) 259.58,66.96 R4604.1
  TOP w0.102: v1(257.81,63.45) 257.81,64.39 259.05,65.63 R4731.1 R4604.1
  BOTTOM w0.089: U4710.BA4 257.77,63.49 v1(257.81,63.45)
CNV_RGI_DT_R: length 56.8
  TOP w0.109: v1(278.32,26.64) 277.27,27.69 277.27,61.99 271.19,68.08 263.78,68.08 v2(262.3,66.6) R1321.2
  BOTTOM w0.109: v1(278.32,26.64) 278.66,26.98 279.59,26.98 279.7,27.09 CN1300.32
CNV_RGI_RSP: length 62.4
  TOP w0.109: v3(259.48,69.35) 259.97,68.86 271.17,68.86 277.54,62.49 277.54,62.47 277.75,62.26 277.75,31.42 R1365.1
  BOTTOM w0.089: 256.82,67.19 256.82,67.13 256.99,66.96 256.99,66.65 256.24,65.9 256.24,65.48 256.1,65.34 256.1,65.06 255.56,64.51 255.56,64.06 255.57,64.04 255.57,63.85 U4710.AV3
  BOTTOM w0.109: R4732.1 259.25,69.57 v3(259.48,69.35) 259.24,69.1 257.87,69.1 256.82,68.05 256.82,67.19
CNV_RGI_RSP_R: length 3.9
  TOP w0.109: R1365.2 278.08,29.87 v3(278.63,29.32)
  BOTTOM w0.109: CN1300.34 280.2,27.64 280.2,28.49 279.37,29.32 v3(278.63,29.32)
CNV_UART_RXD: length 63.6
  TOP w0.102: v1(284.71,29.11) 284.71,28.55 R1363.1
  L3 w0.102: v1(284.71,29.11) 284.02,29.8 284.02,33.69 282.02,35.69 280.4,35.69 272.79,43.29 272.79,53.39 271.88,54.31 271.88,55.63 272.44,56.19 272.44,57.33 271.31,58.46 266.84,58.46 265.1,60.2 260.68,60.2 260.4,59.92 259.58,59.92 259.2,60.3 259.2,60.99 258.77,61.42 258.31,61.42 257.2,62.54 257.2,63.96 258.11,64.88 v3(258.11,67.81)
  BOTTOM w0.089: U4710.AW2 256.46,64.77 256.46,65.18 256.69,65.41 256.69,65.8
  BOTTOM w0.102: 256.69,65.8 257.62,66.73 257.62,67.2 258.11,67.69 v3(258.11,67.81)
CNV_UART_RXD_R: length 4.1
  TOP w0.102: v1(283.79,25.84) 283.79,26.04 284.48,26.72 v2(284.71,26.72) 284.88,26.9 R1363.2
  BOTTOM w0.102: CN1300.48 283.7,26.82 283.79,26.72 v1(283.79,25.84)
CNV_UART_TXD: length 57.1
  TOP w0.102: R1362.1 283.97,28.55 v1(283.7,28.82) ; v1(256.51,62.24) 256.11,62.64 256.11,62.99 256.24,63.12 256.24,63.92 v2(256.66,64.34) 256.6,64.41 R4602.2 R4601.2
  L3 w0.102: v1(283.7,28.82) 279.55,32.97 279.55,35.85 272.39,43.01 272.39,53.23 271.22,54.39 271.22,55.79 270.11,56.9 266.82,56.9 265.76,57.97 262.64,57.97 262.03,58.58 260.39,58.58 258.14,60.83 257.97,60.83 256.74,60.83 256.41,61.16 256.41,62.14 v1(256.51,62.24)
  BOTTOM w0.089: U4710.AU9 255.38,61.1 256.16,61.88 256.16,61.89 v1(256.51,62.24)
CNV_UART_TXD_R: length 2.4
  TOP w0.102: R1362.2 283.97,26.95 v3(283.38,26.37)
  BOTTOM w0.102: v3(283.38,26.37) 283.2,26.55 CN1300.46
CNV_WR_CLKN_R: length 3.4
  TOP w0.107: R1338.2 277.39,22.85 277.39,21.94 v1(277.16,21.72)
  BOTTOM w0.107: v1(277.16,21.72) 277.25,21.63 277.25,21.25 276.95,20.95 CN1300.21
CNV_WR_CLKP_R: length 3.5
  TOP w0.107: v1(277.82,21.72) 277.59,21.95 277.59,22.77 R1337.2
  BOTTOM w0.107: CN1300.23 277.45,20.08 277.45,21.16 277.46,21.16 277.46,21.36 v1(277.82,21.72)
CNV_WR_D0N_R: length 3.5
  TOP w0.107: R1366.2 275.35,23.15 275.62,22.88 275.62,21.94 v1(275.37,21.69)
  BOTTOM w0.107: CN1300.15 275.45,20.08 275.45,21.05 275.6,21.19 275.6,21.46 v1(275.37,21.69)
CNV_WR_D0P_R: length 3.4
  TOP w0.107: R1324.2 275.83,22.81 275.83,21.89 v1(276.03,21.69)
  BOTTOM w0.107: CN1300.17 275.95,20.08 275.95,21.05 275.8,21.19 275.8,21.46 v1(276.03,21.69)
CNV_WR_D1N_R: length 3.6
  TOP w0.107: v1(273.87,21.74) 274.1,21.96 274.1,22.26 273.82,22.53 273.82,22.81 R1328.2
  BOTTOM w0.107: v1(273.87,21.74) 274.1,21.51 274.1,21.19 273.95,21.05 273.95,20.08 CN1300.9
CNV_WR_D1P_R: length 3.6
  TOP w0.107: R1329.2 274.03,22.81 274.03,22.62 274.3,22.34 274.3,21.96 v1(274.53,21.74)
  BOTTOM w0.107: CN1300.11 274.45,20.08 274.45,21.05 274.3,21.19 274.3,21.51 v1(274.53,21.74)
CNV_WT_CLKN_R: length 4.6
  TOP w0.107: R1354.2 290.66,20.47 289.87,20.47 289.53,20.81 289.53,21.63 v3(289.37,21.79)
  BOTTOM w0.107: v3(289.37,21.79) 289.55,21.61 289.55,21.15 289.55,21.15 289.45,21.05 CN1300.71
