# Allegro board PH317-53 COVINI-6050A3087701-MB-AX2 (BDV)(.BRD).brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
VRACPU_DIFFOUT: length 6.4
  TOP w0.254: C66170.2 91.03,162.33 v2(90.33,162.33) R66171.2 90.33,163.19 89.57,163.96 87.38,163.96 86.98,164.35 U66000.4
VRACPU_DRVON: length 112.7
  TOP w0.254: C66198.1 84.2,171.8 84.2,170.92 84.58,170.54 84.58,169.59 84.48,169.49 v1(84.48,169.42) 84.38,169.32 U66000.17
  L3 w0.254: v1(80.69,149.76) 80.69,151.39 78.48,153.6 78.48,166.04 81.4,168.96 83.44,168.96 83.89,169.42 v1(84.48,169.42) 84.58,169.42 85.16,170.01 90.07,170.01 92.2,172.14 v1(96.01,172.14) v1(106.35,172.14) 116.76,172.14 v1(116.76,172.14) 127.08,172.14 v1(127.13,172.19) 131.87,172.19 132.56,172.87 132.56,175.67 135.56,178.67 142.9,178.67 143.48,178.08 143.48,167.26 144.12,166.62 144.12,166.17 v1(144.14,166.15)
  BOTTOM w0.254: R66311.1 81.97,149.69 v2(81.48,149.69) 81.4,149.76 v1(80.69,149.76) ; U66610.3 v1(144.14,166.15) ; v1(127.13,172.19) 127.33,172.19 127.66,171.85 U66040.30 ; v1(106.35,172.14) 106.55,172.14 106.88,171.81 U66020.30 ; U66010.30 96.54,171.8 96.34,172 96.15,172 v1(96.01,172.14) ; v1(116.76,172.14) 116.97,172.14 117.3,171.8 U66030.30
VRACPU_FB: length 8.1
  TOP w0.254: U66000.5 87.19,164.75 87.61,164.34 89.84,164.34 90.13,164.04 C66172.2 91.28,164.04 ; 91.28,164.04 91.18,163.94 R66171.1 91.91,163.17 v2(91.97,163.22) 92.03,163.17 R66170.1 ; 91.28,164.04 C66171.2
VRACPU_FB1: length 1.7
  TOP w0.254: v2(93.65,162.32) R66170.2 92.74,162.25 C66170.1
VRACPU_ILIM: length 2.8
  TOP w0.254: R66005.2 88.04,165.3 v2(87.94,165.4) 87.79,165.55 U66000.7
VRACPU_IMON: length 3.3
  TOP w0.254: U66000.3 86.77,163.95 87.35,163.38 v2(87.42,163.38) 87.51,163.47 C66107.2 R66107.2
VRACPU_PH1: length 1
  TOP w0.254: v3(96.31,168.23) R66016.2
VRACPU_PH2: length 1
  TOP w0.254: R66026.2 106.81,168.23 v3(106.8,168.22)
VRACPU_PH3: length 1
  TOP w0.254: R66036.2 117.96,168.23 117.91,168.18 v3(117.24,168.18)
VRACPU_PH4: length 1
  TOP w0.254: R66046.2 127.7,168.28 v3(127.66,168.24)
VRACPU_PROCHOT#: length 3.5
  TOP w0.254: U66000.39 80.14,163.15 79.55,162.56 v2(79.55,161.88) R66105.1
VRACPU_PSYS: length 4.2
  TOP w0.254: U66000.24 81.58,169.07 80.9,169.75 80.9,170.45 C66197.1 R66197.1 81.05,172.25 R66195.2
VRACPU_PWM1: length 17.4
  TOP w0.254: U66000.18 83.98,169.84 84.09,169.95 v1(84.09,169.96)
  L3 w0.254: v1(84.09,169.96) 84.1,169.96 84.1,170.03 84.5,170.44 89.96,170.44 92.2,172.67 96.64,172.67 v1(96.92,172.95)
  BOTTOM w0.254: R66093.1 84.24,170.11 v1(84.09,169.96) ; U66010.1 v1(96.92,172.95)
VRACPU_PWM2: length 31.3
  TOP w0.254: v3(83.75,170.58) 83.74,170.58 83.58,170.43 U66000.19
  L3 w0.254: v3(83.75,170.58) 83.75,170.6 84.02,170.87 84.02,172.62 84.5,173.1 95.55,173.1 97.02,174.58 105.76,174.58 107.27,173.07 v1(107.27,172.96)
  BOTTOM w0.254: U66020.1 v1(107.27,172.96) ; v3(83.75,170.58) 84.2,171.04 R66092.1
VRACPU_PWM3: length 41.9
  TOP w0.254: U66000.20 83.18,169.36 83.19,169.37 83.19,170.82 83.21,170.84 v1(83.21,171)
  L3 w0.254: v1(117.19,172.95) 115.19,174.96 96.87,174.96 95.39,173.49 84.34,173.49 83.28,172.43 83.28,171.07 v1(83.21,171)
  BOTTOM w0.254: v1(83.21,171) 83.31,171.1 R66091.1 ; U66030.1 v1(117.19,172.95)
VRACPU_PWM4: length 53.4
  TOP w0.254: U66000.21 82.78,169.42 82.8,169.45 82.8,170.71 v1(82.53,170.98)
  L3 w0.254: v3(128.04,173) 125.71,175.34 96.71,175.34 95.24,173.87 83.9,173.87 82.55,172.51 82.55,171 v1(82.53,170.98)
  BOTTOM w0.254: U66040.1 v3(128.04,173) ; v1(82.53,170.98) 82.42,171.09 R66090.1
VRACPU_SNB1: length 1.7
  TOP w0.254: C66016.1 v2(99.44,168.23) R66016.1
VRACPU_SNB2: length 1.7
  TOP w0.254: C66026.1 v2(109.93,168.23) R66026.1
VRACPU_SNB3: length 1.7
  TOP w0.254: R66036.1 v2(120.37,168.23) C66036.1
VRACPU_SNB4: length 1.7
  TOP w0.254: R66046.1 v2(130.78,168.28) C66046.1
VRACPU_SVID_CLK: length 2.4
  TOP w0.109: U66000.42 81.58,161.64 v2(81.46,161.52) 81.46,160.49 R66102.1
VRACPU_SVID_DATA: length 2.8
  TOP w0.109: U66000.40 80.78,162.51 80.46,162.2 80.46,160.99 v2(80.36,160.89) 80.44,160.81 R66103.1
VRACPU_TSENSE: length 3.3
  TOP w0.254: U66000.14 85.67,168.53 85.67,168.83 86.79,169.95 C66160.1 87.25,170.59 R66161.1
VRACPU_TSENSE1: length 8.5
  TOP w0.254: R66161.2 87.38,171.54 87.75,171.17 v1(87.75,170.97)
  BOTTOM w0.254: R66160.1 R66162.1 92.04,169.05 91.16,169.93 88.95,169.93 87.91,170.97 v1(87.75,170.97)
VRACPU_VCC: length 4.3
  TOP w0.254: U66000.16 84.78,169.04 85.14,169.4 v2(85.14,169.75) C66109.1 85.08,170.6 84.58,171.1 84.58,172.05 R66109.2
VRACPU_VRMP: length 5.3
  TOP w0.254: R66199.2 86.51,172.36 v2(86.28,172.14) 86.56,171.87 86.56,170.79 86.1,170.34 C66199.1 86.03,169.75 85.18,168.9 U66000.15
VRACPU_VSN: length 4.6
  TOP w0.254: R66182.2 C66182.2 88.21,161.02 87.4,161.83 v2(87.4,162.11) 87.4,162.11 87.4,162.56 86.76,163.2 86.76,163.28 86.49,163.55 U66000.2
VRACPU_VSN1: length 3.9
  TOP w0.254: C66182.1 R66182.1 89.34,161.87 89.99,161.22 89.99,161.12 89.99,161.12 v2(89.99,161.11) 90.31,161.43 C66180.2 91.58,161.43 R66181.2
VRACPU_VSP: length 8
  TOP w0.254: R66180.2 90.93,160.48 C66180.1 90.83,160.44 v2(90.24,159.85) 90.24,160.01 89.74,160.51 87.99,160.51 86.74,161.76 86.74,162.61 86.2,163.15 U66000.1
VRAGPU_ADDR: length 4
  TOP w0.102: U67000.24 130.97,55.06 129.87,56.16 v2(129.87,56.24) 129.45,55.82 R67089.1 128.98,55.78 128.24,55.78 R67090.1
VRAGPU_CS1: length 33.7
  TOP w0.254: R67081.2 130.57,58.43 v3(130.91,58.09) 130.98,58.09 132.05,57.03 U67000.20
  L3 w0.254: v1(157.96,55.45) 156.44,55.45 154.23,57.66 139.93,57.66 138.5,56.24 133.63,56.24 132.58,57.28 131.85,57.28 131.19,57.94 131.06,57.94 v3(130.91,58.09)
  BOTTOM w0.254: U67010.18 159.37,55.44 158.78,55.44 158.67,55.33 158.08,55.33 v1(157.96,55.45)
VRAGPU_CS2: length 43.8
  TOP w0.254: R67082.2 131.46,58.61 v1(131.63,58.44) 131.63,58.21 132.45,57.39 U67000.19
  L3 w0.254: v3(167.62,55.46) 167.64,55.48 167.64,55.48 167.88,55.72 167.88,56.35 166.87,57.36 155.03,57.36 154.37,58.02 139.78,58.02 138.36,56.59 133.77,56.59 132.68,57.69 132.13,57.69 131.63,58.18 v1(131.63,58.44)
  BOTTOM w0.254: v3(167.62,55.46) 167.7,55.38 168.61,55.38 168.66,55.42 U67020.18
VRAGPU_CS3: length 52.6
  TOP w0.254: U67000.18 132.85,57.82 v3(132.35,58.32) R67083.2
  L3 w0.254: v1(177.84,55.48) 177.85,55.48 177.85,56.8 176.93,57.71 155.18,57.71 154.73,58.16 154.52,58.37 139.63,58.37 138.21,56.95 133.92,56.95 132.83,58.04 132.63,58.04 v3(132.35,58.32)
  BOTTOM w0.254: v1(177.84,55.48) 177.97,55.35 178.55,55.35 178.66,55.46 179.26,55.46 U67030.18
VRAGPU_CS4: length 61.7
  TOP w0.254: R67084.2 133.25,59.09 v1(133.25,58.4) U67000.17
  L3 w0.254: v3(187.68,55.58) 187.87,55.77 187.87,56.6 186.41,58.07 155.33,58.07 155.08,58.31 154.67,58.73 139.48,58.73 138.06,57.31 134.13,57.31 133.25,58.19 v1(133.25,58.4)
  BOTTOM w0.254: U67040.18 189.27,55.52 188.67,55.52 188.61,55.45 187.8,55.45 v3(187.68,55.58)
VRAGPU_CS5: length 71.4
  TOP w0.254: U67000.16 133.65,57.84 v3(134.13,58.32) 134.13,58.42 134.13,58.43 R67085.2
  L3 w0.254: v3(134.13,58.32) 134.79,57.66 137.91,57.66 139.34,59.08 154.82,59.08 155.48,58.42 196.14,58.42 197.89,56.67 v1(197.89,55.5)
  BOTTOM w0.254: U67050.18 199.3,55.49 198.71,55.49 198.6,55.38 198.01,55.38 v1(197.89,55.5) ; R67095.1 134.13,57.63 v3(134.13,58.32)
VRAGPU_CS6: length 81.4
  TOP w0.254: R67086.2 v1(135.02,58.37) 134.05,57.41 U67000.15
  L3 w0.254: v3(207.67,55.53) 207.9,55.76 207.9,57.13 206.24,58.78 155.62,58.78 154.96,59.44 139.19,59.44 137.77,58.02 135.37,58.02 v1(135.02,58.37)
  BOTTOM w0.254: R67096.1 135.05,58.34 v1(135.02,58.37) ; U67060.18 209.33,55.52 208.73,55.52 208.67,55.45 207.74,55.45 v3(207.67,55.53)
VRAGPU_CSSUM: length 9.2
  TOP w0.254: R67086.1 R67085.1 R67084.1 R67083.1 R67082.1 R67081.1 130.43,59.96 129.89,59.41 129.89,58.83 v2(129.77,58.7) 129.77,58.37 131.4,56.74 U67000.21
VRAGPU_IMON: length 3.9
  TOP w0.102: R67091.1 128.68,54.8 C67089.1 128.9,55.02 v2(130.27,55.02) 130.64,54.66 U67000.25
VRAGPU_IREF: length 3.2
  TOP w0.102: U67000.26 129.69,54.26 v2(129.47,54.04) 129.16,53.73 R67093.1
VRAGPU_PWM1: length 28.2
  TOP w0.254: U67000.11 137.29,56.91 139.72,59.34 150.92,59.34 154.3,55.96 154.3,54.64 155.27,53.67 v3(159.08,53.67)
  BOTTOM w0.254: v3(159.08,53.67) 159.39,53.99 U67010.15
VRAGPU_PWM2: length 42.8
  TOP w0.254: v3(168.98,53.67) 167.61,53.67 167.36,53.42 167.36,50 167.02,49.66 158.73,49.66 153.95,54.44 153.95,55.81 150.78,58.98 139.87,58.98 137.15,56.26 U67000.10
  BOTTOM w0.254: v3(168.98,53.67) 169.29,53.99 U67020.15
VRAGPU_PWM3: length 53.1
  TOP w0.254: v3(178.96,53.7) 177.75,53.7 177.29,53.24 177.29,49.56 177.03,49.3 158.58,49.3 153.59,54.29 153.59,55.67 150.63,58.63 140.02,58.63 137.25,55.86 U67000.9
  BOTTOM w0.254: U67030.15 179.27,54.01 v3(178.96,53.7)
VRAGPU_PWM4: length 63.2
  TOP w0.254: U67000.8 137.35,55.46 140.16,58.27 150.48,58.27 153.23,55.52 153.23,54.15 158.43,48.95 158.97,48.95 186.26,48.95 187.3,49.99 187.3,53.5 v2(187.46,53.66) 187.55,53.75 v1(188.97,53.75)
  BOTTOM w0.254: v1(188.97,53.75) 189.29,54.06 U67040.15
VRAGPU_PWM5: length 73.6
  TOP w0.254: v3(199.01,53.72) 197.81,53.72 197.25,53.17 197.25,49.25 196.59,48.59 159.12,48.59 159.12,48.59 158.82,48.59 158.28,48.59 152.88,54 152.88,55.37 150.33,57.92 140.31,57.92 137.45,55.06 U67000.7
  BOTTOM w0.254: U67050.15 199.32,54.04 v3(199.01,53.72)
VRAGPU_PWM6: length 82.9
  TOP w0.254: U67000.6 137.56,54.66 140.46,57.56 150.19,57.56 152.52,55.22 152.52,53.85 158.14,48.24 158.97,48.24 159.26,48.24 204.43,48.24 207.24,51.04 207.24,53.34 207.64,53.75 v3(209.03,53.75)
  BOTTOM w0.254: v3(209.03,53.75) 209.35,54.06 U67060.15
VRAGPU_SNB1: length 1.1
  BOTTOM w0.254: C67016.1 166,58.44 R67016.2
VRAGPU_SNB2: length 1.1
  BOTTOM w0.254: R67026.2 175.95,58.46 C67026.1
VRAGPU_SNB3: length 1.1
  BOTTOM w0.254: C67036.1 185.96,58.44 R67036.2
VRAGPU_SNB4: length 1.1
  BOTTOM w0.254: C67046.1 196,58.44 R67046.2
VRAGPU_SNB5: length 1.1
  BOTTOM w0.254: C67056.1 205.95,58.47 R67056.2
VRAGPU_SNB6: length 1.1
  BOTTOM w0.254: C67066.1 215.99,58.47 R67066.2
VRAGPU_SYNC1: length 1.4
  BOTTOM w0.254: U67010.16 158.96,54.62 158.96,54.62 158.6,54.62 R67017.2
VRAGPU_SYNC2: length 1.4
  BOTTOM w0.254: R67027.2 168.5,54.62 168.86,54.62 168.87,54.62 U67020.16
VRAGPU_SYNC3: length 1.4
  BOTTOM w0.254: R67037.2 178.48,54.64 178.84,54.64 178.85,54.65 U67030.16
VRAGPU_SYNC4: length 1.4
  BOTTOM w0.254: R67047.2 188.49,54.69 188.86,54.69 188.86,54.7 U67040.16
VRAGPU_SYNC5: length 1.4
  BOTTOM w0.254: R67057.2 198.52,54.67 198.89,54.67 198.89,54.67 U67050.16
VRAGPU_SYNC6: length 1.4
  BOTTOM w0.254: R67067.2 208.55,54.69 208.92,54.69 208.92,54.7 U67060.16
VRAGPU_VDD18: length 4.9
  TOP w0.102: U67000.23 130.95,55.46 130.48,55.93 130.48,56.39 129.42,57.45 v2(129.33,57.45) 129.02,57.14 R67089.2 128.24,56.67 C67088.1
VRAGPU_VDIFF: length 2.7
  TOP w0.102: U67000.28 130.87,53.46 130.48,53.06 130.33,53.06 130.32,53.07 v2(130.31,53.07) 130.18,53.07 R67094.1
VRAGPU_VINSEN: length 6.6
  TOP w0.102: U67000.22 130.98,55.86 130.81,56.04 130.81,56.67 129.37,58.1 129.3,58.1 128.95,58.45 R67088.1 C67087.1 127.94,58.38 v2(127.94,57.66) 127.46,57.66 127.15,57.97 R67087.1
VRAGPU_VORTN: length 5.2
  TOP w0.102: v2(130.81,49.58) 131.22,49.17 131.22,48.73 R67003.1 ; v2(130.81,49.58) 129.99,49.58 R67001.1 ; v2(130.81,49.58) 131.14,49.58 132.2,50.65 132.2,50.96 132.45,51.2 U67000.32
VRAGPU_VOSEN: length 3.3
  TOP w0.102: U67000.31 132.05,51.29 v2(131.67,50.91) 131.13,50.36 R67002.1 130.07,50.36 129.96,50.47 R67000.1
VRAGPU_VTEMP: length 97.8
  TOP w0.254: 198.93,57.38 207.95,57.38 208.71,56.62 208.71,55.43 208.21,54.93 207.94,54.93 207.93,54.92 v1(207.93,54.92) ; 198.93,57.38 198.93,55.86 197.97,54.9 v1(197.91,54.9) ; 198.93,57.38 188.59,57.38 ; 188.59,57.38 188.59,55.58 187.94,54.93 v1(187.88,54.93) ; 188.59,57.38 178.81,57.38 ; 168.68,57.38 168.68,55.59 167.94,54.85 v1(167.89,54.85) ; 168.68,57.38 178.81,57.38 ; 168.68,57.38 160.57,57.38 158.04,54.85 v1(157.98,54.85) ; 178.81,57.38 178.81,55.77 177.93,54.88 v1(177.87,54.88) ; R67012.1 v1(137.45,50.12)
  L3 w0.254: v1(137.45,50.12) 138.23,50.91 140.03,50.91 142.9,53.78 156.95,53.78 157.98,54.81 v1(157.98,54.85)
  BOTTOM w0.254: v1(157.98,54.85) 158.11,54.97 158.81,54.97 158.86,55.02 U67010.17 ; U67060.17 208.82,55.1 208.79,55.07 208.08,55.07 207.93,54.92 v1(207.93,54.92) ; U67020.17 168.76,55.02 168.72,54.97 168.01,54.97 v1(167.89,54.85) ; U67050.17 198.79,55.07 198.74,55.02 198.03,55.02 v1(197.91,54.9) ; v1(187.88,54.93) 188,55.05 188.71,55.05 188.76,55.1 U67040.17 ; U67030.17 178.74,55.05 178.7,55 177.99,55 v1(177.87,54.88)
VRAGT_BST1: length 2.2
  BOTTOM w0.254: U66310.1 80.49,148.6 80.24,148.85 80.24,149.2 v2(80.03,149.41) 79.36,148.73 R66315.1
VRAGT_BST11: length 1.9
  BOTTOM w0.381: C66315.2 77.72,147.25 v2(77.75,147.27) 78.35,147.87 R66315.2
VRAGT_COMP: length 4.8
  TOP w0.254: U66000.33 79.03,165.55 78.96,165.48 77.7,165.48 C66472.2 77.33,165.33 v2(76.6,165.33) 76.06,164.79 R66472.2
VRAGT_COMP1: length 1.8
  TOP w0.254: v2(74.34,164.7) 74.44,164.6 R66472.1 75.21,164.59 C66471.2
VRAGT_CSCOMP: length 53.5
  TOP w0.254: v1(73.79,165.49) R66451.1 75.28,165.49 75.28,165.48 v2(75.33,165.48) 75.43,165.48 C66451.1 C66450.1 77.34,166.27 77.89,166.82 R66305.2 78.9,166.82 79.37,166.35 U66000.31
  L5 w0.254: v1(73.79,165.49) 72.36,164.06 72.36,144.89 68.7,141.23 68.7,138.89 67.43,137.62 67.43,134.65 65.86,133.07 65.86,124.02 v1(66.46,123.41)
  BOTTOM w0.254: v1(66.46,123.41) 66.46,123.42 R66450.1
VRAGT_CSCOMP1: length 50
  TOP w0.254: R66452.1 74.58,166.27 74.52,166.34 R66451.2 73.67,166.34 v3(73.63,166.37)
  L5 w0.254: v3(73.63,166.37) 71.9,164.65 71.9,145.09 68.22,141.4 68.22,138.95 67.05,137.78 67.05,134.81 65.48,133.23 65.48,123.55 v1(66.46,122.56)
  BOTTOM w0.254: R66450.2 66.46,122.57 v1(66.46,122.56)
VRAGT_CSN1: length 50.1
  TOP w0.254: v1(76.71,168.18) R66413.2
  L8 w0.254: v1(66.64,125.2) 66.7,125.2 67.79,126.3 67.79,134.24 67.43,134.6 67.43,138.28 67.79,138.64 67.79,140.41 72.56,145.18 72.56,166.02 74.06,167.52 76.05,167.52 v1(76.71,168.18)
  BOTTOM w0.254: v1(66.64,125.2) 66.57,125.2 66.44,125.07 R66318.2
VRAGT_CSN11: length 6.4
  BOTTOM w0.254: L66310.4 70.08,123.24 69.11,124.21 R66318.1
VRAGT_CSP1: length 50.6
  TOP w0.254: R66412.2 75.09,168.58 v1(75.49,168.58) 75.49,169.56 R66414.2
  L8 w0.254: v1(66.6,125.78) 67.41,126.6 67.41,134.04 67.05,134.39 67.05,138.46 67.41,138.81 67.41,140.25 67.41,140.57 72.18,145.34 72.18,166.18 74.59,168.58 v1(75.49,168.58)
  BOTTOM w0.254: R66319.2 66.54,125.84 v1(66.6,125.78)
VRAGT_CSP1_R: length 6.3
  TOP w0.254: R66414.1 75.79,170.56 75.81,170.58 75.81,170.58 C66414.1 77.19,170.58 77.37,170.4 v2(77.38,170.4) 77.41,170.37 77.68,170.37 78.92,169.13 78.92,168.48 79.84,167.56 80.08,167.56 U66000.28
VRAGT_CSP2_R: length 6.2
  TOP w0.254: v2(77.03,171.68) 77.03,171.64 ; 77.03,171.64 76.73,171.33 R66424.1 ; 77.03,171.64 77.03,171.58 79.34,169.27 79.34,168.59 79.98,167.95 U66000.27
VRAGT_CSP11: length 7.5
  BOTTOM w0.254: L66310.3 70.08,127.44 69.33,126.69 R66319.1
VRAGT_CSREF: length 5.5
  TOP w0.254: C66414.2 76.83,169.73 77.55,169 R66413.1 77.48,168.75 v2(77.48,168) 77.6,167.87 C66413.1 78.97,167.87 79.69,167.16 80.08,167.16 80.09,167.15 U66000.29
VRAGT_CSSUM: length 7.1
  TOP w0.254: v2(75.56,167.92) 75.33,167.7 R66452.2 ; R66452.2 75.3,167.09 R66412.1 ; R66452.2 C66451.2 C66450.2 77.33,167.34 78.97,167.34 79.55,166.75 U66000.30
VRAGT_DIFFOUT: length 4.5
  TOP w0.254: C66470.1 R66471.1 77.77,163.43 v2(78.43,163.43) 78.43,164.15 78.72,164.44 79.09,164.44 79.4,164.75 U66000.35
VRAGT_FB: length 6
  TOP w0.254: R66470.2 76.06,162.82 C66471.1 76.64,163.71 R66471.2 76.81,163.74 C66472.1 77.54,164.47 77.92,164.47 v2(78.3,164.85) 78.36,164.91 79,164.91 79.24,165.15 U66000.34
VRAGT_FB1: length 2.3
  TOP w0.254: C66470.2 76.17,162 v2(75.87,162) 75.21,162.65 R66470.1
VRAGT_ILIM: length 2.4
  TOP w0.254: R66305.1 78.69,165.97 v2(78.82,166.11) 78.89,166.11 79.04,165.95 U66000.32
VRAGT_IMON: length 3.2
  TOP w0.254: v1(78.98,163.93) 79.14,163.93 79.54,164.33 79.57,164.33 79.58,164.35 U66000.36
  BOTTOM w0.254: R66407.1 79.58,164.46 79.76,164.28 C66407.1 v1(78.98,163.93)
VRAGT_PWM1: length 27.1
  TOP w0.254: v1(81.43,169.9) 81.43,169.77 81.98,169.23 U66000.23
  L3 w0.254: v1(80.72,149.05) 80.13,149.63 80.13,151.18 78.1,153.22 78.1,166.22 81.43,169.55 v1(81.43,169.9)
  BOTTOM w0.254: v1(81.43,169.9) R66393.1 ; U66310.2 80.84,147.98 81.1,148.23 81.1,148.67 v1(80.72,149.05)
VRAGT_PWM2: length 2.1
  TOP w0.254: U66000.22 82.38,169.67 v3(82.24,169.8)
  BOTTOM w0.254: R66690.1 82.32,169.73 v3(82.24,169.8)
VRAGT_SNB1: length 1
  BOTTOM w0.254: R66316.1 65.76,128.93 C66316.1
VRAGT_TSENSE: length 4.4
  TOP w0.254: U66000.25 81.18,168.91 80.45,169.64 v1(80.45,170.79)
  BOTTOM w0.254: v1(80.45,170.79) 80.42,170.76 C66460.1 78.79,170.76 78.79,170.76 R66461.1
VRAGT_TSENSE1: length 39.7
  L8 w0.254: v1(76.04,169.12) 74.44,169.12 71.8,166.48 71.8,145.77 67.03,141 67.03,139.98 v1(66.9,139.86)
  BOTTOM w0.254: v1(76.04,169.12) 76.22,168.94 78.03,168.94 78.74,169.65 R66461.2 ; v1(66.9,139.86) 67.1,139.65 R66462.1 R66460.1
VRAGT_VSN: length 5.5
  TOP w0.254: v2(76.63,160.94) 76.63,161.09 77.36,161.82 R66482.1 C66482.1 78.36,162.51 78.99,163.15 78.99,163.24 79.7,163.95 U66000.37
VRAGT_VSN1: length 3.5
  TOP w0.254: R66481.1 77.14,158.52 77.14,159.24 v2(77.21,159.31) 77.48,159.57 C66480.2 77.47,160.15 R66482.2 C66482.2
VRAGT_VSP: length 6.4
  TOP w0.254: R66480.1 78.03,158.52 78.03,158.86 v2(78.48,159.31) 78.48,159.34 78.33,159.49 C66480.1 78.4,160.15 78.91,160.66 78.91,162.46 79.4,162.94 79.4,163.1 79.85,163.55 U66000.38
VRAM_DGPU_BST1: length 1
  BOTTOM w0.254: C67215.1 235.66,80.42 R67215.2
VRAM_DGPU_BST2: length 1.1
  BOTTOM w0.254: C67225.1 235.13,74.68 R67225.2
VRAM_DGPU_EN: length 2.5
  BOTTOM w0.254: R67211.2 239.09,80.1 239.8,79.39 U67200.3
VRAM_DGPU_GND: length 16.7
  TOP w0.254: v1(240.99,73.77) 241.7,74.48 241.7,75.57 244.42,78.29 v1(245.36,78.29)
  BOTTOM w0.254: C67236.2 244.58,78.03 244.65,78.1 C67234.2 244.92,78.29 v1(245.36,78.29) 245.43,78.37 R67212.2 245.5,78.99 R67208.2 244.72,79.81 C67235.2 ; C67232.2 241.5,75.52 241.2,75.82 U67200.10 ; R67203.1 241.75,74.63 240.99,73.87 v1(240.99,73.77) 240.93,73.77 240.85,73.69 240.43,73.69 C67230.1 240.3,73.12 R67202.2
  BOTTOM w0.381: R67203.1 242.09,74.63 C67232.2
VRAM_DGPU_HG1: length 33.9
  L8 w0.508: v5(216.47,68.02) 216.47,71.9 222.44,77.87 231.07,77.87 232.74,76.2 234.59,76.2 234.95,76.56 234.95,78.57 235.81,79.43 v5(238.95,79.43)
  BOTTOM w0.254: v5(238.95,79.43) 238.95,79.43 239.38,79.01 239.38,78.59 U67200.2
  BOTTOM w0.508: Q67210.1 v5(216.47,68.02)
VRAM_DGPU_HG2: length 8
  BOTTOM w0.254: 238.46,74.74 238.73,75.01 239.05,75.01 239.4,75.35 U67200.14
  BOTTOM w0.508: 238.46,74.74 237.26,73.54 235.25,73.54 v2(234.53,72.81) 234.42,72.7 Q67220.1
VRAM_DGPU_LG1: length 25.3
  TOP w0.508: v5(222.89,68.89) 222.62,68.89 221.84,69.68 221.84,74.91 223.95,77.02 235.58,77.02 v2(236.08,77.52) 236.45,77.88 v5(237.56,77.88)
  BOTTOM w0.254: U67200.19 237.82,77.57 237.56,77.82 v5(237.56,77.88)
  BOTTOM w0.508: Q67210.8 v5(222.89,68.89)
VRAM_DGPU_LG2: length 14.4
  TOP w0.508: v5(226.46,72.75) 233.5,72.75 v2(236.56,75.81) 237.16,76.41 v5(237.54,76.41)
  BOTTOM w0.254: v5(237.54,76.41) 237.54,76.51 237.79,76.77 U67200.17
  BOTTOM w0.508: v5(226.46,72.75) 226.64,72.75 226.69,72.7 Q67220.8
VRAM_DGPU_OCSET: length 6.1
  BOTTOM w0.254: U67200.12 240.2,74.73 v2(240.18,74.7) 240.03,74.7 239.44,74.12 239.14,74.12 237.21,72.19 C67233.1 236.32,72.08 R67233.2
VRAM_DGPU_PG: length 161.8
  L5 w0.102: v1(118.41,51.51) 117.67,50.78 109.37,50.78 v3(109.22,50.63)
  L8 w0.102: v1(235.05,71.57) 235.4,71.22 235.4,69.17 231.42,65.18 222.87,65.18 219.15,61.46 219.15,59.06 217.24,57.15 217.24,51.16 216.26,50.18 187.66,50.18 187.66,50.18 180.55,50.18 175.38,45.01 168.53,45.01 166.52,43.01 159.76,43.01 157.2,40.44 153.69,40.44 153.18,40.95 143.74,40.95 142.54,42.14 128.3,42.14 126.11,44.34 126.11,44.83 120.03,50.91 119.02,50.91 v1(118.41,51.51)
  BOTTOM w0.102: U53500.2 109.33,49.32 109.04,49.61 109.04,50.45 v3(109.22,50.63) ; v1(118.41,51.51) 118.38,51.48 R53541.1 118.38,49.99 U53540.1
  BOTTOM w0.254: v1(235.05,71.57) 235.05,71.99 235.62,72.56 237.07,72.56 238.99,74.48 239.14,74.48 239.8,75.14 U67200.13
VRAM_DGPU_PH1: length 27.4
  L8 w0.508: v1(220.67,74.12) 220.67,74.7 222.55,76.58 230.68,76.58 232.03,75.24 235.1,75.24 236.32,76.46 236.32,78.11 236.85,78.64 v5(237.54,78.64)
  BOTTOM w0.254: U67200.20 238.4,78.39 238.14,78.64 v5(237.54,78.64) 237.54,78.85 236.95,79.43 C67215.2
  BOTTOM w0.508: R67216.1 218.81,76.72
VRAM_DGPU_PH2: length 9.3
  TOP w0.254: R67226.1 v1(232.2,74.2)
  BOTTOM w0.254: U67200.16 238.4,76.08 238.14,75.83 236.8,75.83 236.75,75.88 ; 236.75,75.88 236.36,75.49 C67225.2 ; 236.75,75.88 v2(236.75,75.88)
  BOTTOM w0.508: L67220.1 232.25,75.69 232.89,76.33 235.47,76.33 235.98,75.82 C67225.2
VRAM_DGPU_PSI: length 112
  TOP w0.102: v3(241.25,81.51) 241.78,82.05 243.43,82.05 R67231.1 243.71,81.76 R67230.2
  L8 w0.102: v1(161.85,107.06) 161.85,106.35 162.46,105.74 162.46,87.05 164.79,84.71 164.79,84.48 167.05,82.22 213.01,82.22 214.1,83.32 216.76,83.32 217.12,83.67 233.04,83.67 233.24,83.47 233.78,83.47 234.69,82.55 235.66,82.55 236.88,81.33 240,81.33 240.13,81.21 240.94,81.21 v3(241.25,81.51)
  BOTTOM w0.102: R51587.2 166.21,106.73 R51586.1 165.25,106.66 R51582.2 163.97,107.19 161.97,107.19 v1(161.85,107.06) ; R67219.1 240.81,81.08 v3(241.25,81.51)
VRAM_DGPU_PSI1: length 2.5
  BOTTOM w0.102: U67200.4 240.2,79.82 C67219.1 240.81,80.09 R67219.2
VRAM_DGPU_PVCC: length 3.1
  BOTTOM w0.254: U67200.18 237.25,77.17 237.17,77.24 C67209.1 R67209.1
VRAM_DGPU_PWMVID: length 93.7
  TOP w0.102: v3(161.38,94.38) 161.06,94.06 R51580.2
  L8 w0.102: v1(242.08,81.49) 241.35,80.75 239.98,80.75 239.67,81.05 236.65,81.05 235.4,82.3 234.49,82.3 233.52,83.26 217,83.26 216.74,83.01 214.32,83.01 213.2,81.89 166.6,81.89 162.15,86.34 162.15,90.33 161.79,90.68 161.79,93.32 161.38,93.74 v3(161.38,94.38)
  BOTTOM w0.102: v1(242.08,81.49) 242.08,81.33 R67220.1
VRAM_DGPU_REFADJ: length 3.6
  BOTTOM w0.254: R67207.1 242.47,80.19 242.47,79.71 v2(242.08,79.33) 241.65,78.9 241.65,78.24 241.39,77.97 U67200.6
VRAM_DGPU_REFADJ1: length 3.6
  BOTTOM w0.102: v2(244.93,81.39) 245.5,80.82 R67204.2 245.39,80.59 C67235.1 244.54,80.7 R67207.2 243.83,79.81 R67205.1
VRAM_DGPU_REFIN: length 3.9
  BOTTOM w0.254: R67205.2 242.98,78.92 R67206.1 242.98,78.11 C67236.1 243,77.98 v2(242.26,77.98) 241.85,77.57 U67200.7
VRAM_DGPU_SENSE: length 24.8
  L5 w0.254: v1(230.79,84.85) 230.79,84.58 234.54,80.83 240.08,80.83 241.91,79 241.91,75.81 v1(240.95,74.85)
  BOTTOM w0.254: C67231.1 238.7,72.69 R67201.2 238.99,73.1 C67230.2 239.45,73.61 239.62,73.78 239.62,73.79 239.77,73.94 239.78,73.94 239.99,74.15 240.46,74.15 240.95,74.64 v1(240.95,74.85) 240.95,75.12 240.6,75.47 U67200.11 ; R67200.2 231.09,83.94 231.09,84.53 230.79,84.83 v1(230.79,84.85)
VRAM_DGPU_SN1: length 2
  BOTTOM w0.432: C67216.1 214.5,78.66 v2(214.5,78.11) 214.69,77.92 R67216.2
VRAM_DGPU_SN2: length 1.8
  TOP w0.381: C67226.1 228.93,74.12 228.98,74.17 v2(229,74.17) 229.3,74.17 229.33,74.2 R67226.2
VRAM_DGPU_TON: length 2
  BOTTOM w0.254: R67217.2 242.96,76.48 v2(242.26,76.48) 241.98,76.77 U67200.9
VRAM_DGPU_TON1: length 3.2
  BOTTOM w0.102: v2(246.83,75.83) C67218.2 245.15,76.48 R67218.2 244.65,76.48 244.58,76.41 R67217.1
VRAM_DGPU_VCC_SENSE: length 131.8
  TOP w0.254: R52230.2 186.53,155.09 TP52230.1 186.68,155.29 186.68,155.54 v1(186.37,155.85)
  L5 w0.254: v1(239.1,71.26) 238.75,71.26 231.75,78.26 231.75,80.9 229.83,82.82 210.12,82.82 201.95,90.99 201.95,94.6 196.21,100.34 196.21,157.19 193.68,159.72 191.82,159.72 191.21,160.33 189.2,160.33 186.37,157.5 v1(186.37,155.85)
  BOTTOM w0.254: v1(239.1,71.26) 239.1,71.73 R67201.1
VRAM_DGPU_VID: length 2.1
  BOTTOM w0.254: R67220.2 241.37,79.77 241.37,79.18 240.77,78.57 U67200.5
VRAM_DGPU_VREF: length 8.4
  BOTTOM w0.254: U67200.8 244.04,77.17 244.12,77.25 C67234.1 244.81,77.25 245.34,77.78 245.81,77.78 v2(246.48,78.45) 246.83,78.8 246.83,80.22 R67204.1
VRAM_DGPU_VSS_SENSE: length 133.5
  TOP w0.254: R52231.2 185.62,155.06 TP52231.1 185.42,155.46 v1(185.79,155.83)
  L5 w0.254: v1(239.7,71.25) 239.7,71.35 239.3,71.74 238.96,71.74 232.46,78.25 232.46,80.96 230.22,83.2 210.29,83.2 204.75,88.75 204.75,92.35 196.59,100.5 196.59,157.35 193.84,160.1 191.98,160.1 191.37,160.71 189.05,160.71 185.79,157.45 185.79,155.83 v1(185.79,155.83)
  BOTTOM w0.254: R67202.1 239.7,71.66 v1(239.7,71.25)
VRAP1V0S_DGPU_FB: length 1.8
  BOTTOM w0.508: R67600.2 153.8,172.07 C67601.2 152.88,172.07 R67601.1
VRASA_BST1: length 1.1
  BOTTOM w0.254: R66615.1 146.07,166.94 U66610.1
VRASA_BST11: length 2.3
  BOTTOM w0.254: R66615.2 146.45,168.52 v2(146.45,169.47) 146.06,169.86 C66615.1
VRASA_COMP: length 5.3
  TOP w0.254: U66000.50 84.78,162.08 86.13,160.73 v2(86.13,160.4) 86.53,160 86.53,159.7 86.93,159.29 C66671.2 86.93,158.37 R66670.2
VRASA_COMP1: length 1.8
  TOP w0.254: C66670.2 87.04,157.41 R66670.1 87.25,157.21 v2(87.25,156.62)
VRASA_CSN1: length 65.8
  TOP w0.254: R66618.2 138.22,163.86 v1(138.15,163.94) ; R66651.2 85.33,158.32 C66651.1 C66650.1 85.91,156.86 86.4,156.86 86.69,156.57 v1(86.69,156.26)
  L5 w0.254: v1(138.15,163.94) 135.94,163.94 133.65,161.65 133.65,159.01 130.75,156.11 96.08,156.11 94.79,157.4 87.83,157.4 v1(86.69,156.26)
  BOTTOM w0.254: v1(138.15,163.94) 137.3,163.09 R66650.1
VRASA_CSN11: length 2.3
  TOP w0.254: v1(139.72,163.17) R66618.1
  BOTTOM w0.254: v1(139.72,163.17) 139.72,163.15 139.72,163.14 L66610.4
VRASA_CSP1: length 59.9
  TOP w0.254: R66653.2 85.61,156.26 v1(85.98,156.26) ; R66619.2 v3(137.99,164.75)
  L5 w0.254: v3(137.99,164.75) 136.01,164.75 133.17,161.9 133.17,159.19 130.63,156.65 96.44,156.65 95.2,157.89 87.42,157.89 85.98,156.44 v1(85.98,156.26)
VRASA_CSP1_R: length 7.6
  TOP w0.254: R66652.1 R66653.1 84.49,156.54 C66650.2 C66651.2 83.66,159.14 v2(83.66,159.39) 83.89,159.62 83.89,161.16 83.58,161.47 U66000.47
VRASA_CSP11: length 2.2
  TOP w0.254: R66619.1 139.72,164.75 v3(139.72,165.59)
  BOTTOM w0.254: v3(139.72,165.59) L66610.3
VRASA_ILIM: length 4.1
  TOP w0.254: v1(85.21,160.91) 85.21,161.04 84.38,161.87 U66000.49
  BOTTOM w0.254: v1(85.21,160.91) 85.52,161.22 C66605.2 R66605.2
VRASA_IMON: length 3.7
  TOP w0.254: v1(83.39,160.98) 83.18,161.19 U66000.46
  BOTTOM w0.254: R66607.1 C66607.1 83.72,161.31 v1(83.39,160.98)
VRASA_PWM1: length 98.6
  TOP w0.254: v3(82.41,160.58) 82.47,160.64 82.47,161.95 82.38,162.04 U66000.44
  L8 w0.254: v3(82.41,160.58) 82.39,160.59 82.39,161.55 82.04,161.9 81.3,161.9 79.73,163.48 79.73,169.7 79.72,169.71 79.72,170.11 79.73,170.11 79.73,171.55 82.05,173.87 97.81,173.87 101.8,177.85 136.09,177.85 137.13,178.9 142.95,178.9 143.48,178.36 143.48,167.47 144.32,166.63 144.34,166.63 144.63,166.35 144.63,166.32 144.8,166.15 144.8,165.79 v1(144.36,165.34)
  BOTTOM w0.254: U66610.2 144.64,165.63 v1(144.36,165.34) ; v3(82.41,160.58) 82.41,161.41 R66693.1
VRASA_SNB1: length 1.7
  TOP w0.254: R66616.2 v2(141.5,172.52) C66616.1
VRASA_VSN: length 7
  TOP w0.254: R66682.2 C66682.2 88.06,158.34 v2(87.87,158.54) 87.47,158.93 87.47,159.4 86.92,159.96 86.92,160.5 85.18,162.24 U66000.51
VRASA_VSN1: length 3.8
  TOP w0.254: R66681.2 91.98,158.17 v2(91.23,158.17) 90.35,158.17 C66680.1 90.17,158.34 C66682.1 R66682.1
VRASA_VSP: length 5.2
  TOP w0.254: R66683.2 C66683.2 87.65,160.01 v2(87.56,160.11) 87.55,160.11 87.55,160.41 85.58,162.38 U66000.52
VRASA_VSP1: length 4
  TOP w0.254: R66680.2 91.59,159.31 v2(91.46,159.43) 91.46,159.43 91.08,159.05 C66680.2 90.21,159.16 R66683.1 C66683.1
VRAVCCIO_BST: length 2.5
  BOTTOM w0.254: R60515.1 69.9,103.54 69.9,105.08 69.63,105.35 U60500.9
VRAVCCIO_BST1: length 1
  BOTTOM w0.254: C60515.1 70.41,101.83 R60515.2
VRAVCCIO_MODE: length 3.2
  BOTTOM w0.254: U60500.7 69.64,106.35 69.92,106.63 69.92,107.9 70.31,108.29 R60529.2
VRAVCCIO_SNB: length 1
  BOTTOM w0.254: R60516.2 74.79,101.73 74.89,101.83 C60516.1
VRAVDDQ_BST: length 2.2
  BOTTOM w0.254: U60300.10 70.72,81.11 70.47,80.85 69.44,80.85 68.97,80.39 R60315.1
VRAVDDQ_BST1: length 1.8
  BOTTOM w0.254: C60315.1 67.48,80.16 R60315.2
VRAVDDQ_FB: length 6.2
  BOTTOM w0.254: U60300.13 69.24,82.33 69.21,82.35 68.6,82.35 68.32,82.63 v2(67.28,82.63) 67.04,82.39 67.04,81.66 R60301.2 66.65,81.05 R60344.1 R60300.1
VRAVDDQ_MODE: length 2.3
  BOTTOM w0.254: U60300.14 69.03,82.83 68.29,83.57 R60346.1
VRAVDDQ_OTW#: length 1.4
  BOTTOM w0.254: R60348.1 68.45,81.33 U60300.11
VRAVDDQ_VOUT: length 18.8
  L10 w0.254: v3(76.15,74.17) 76.15,73.69 74.77,72.32 68.5,72.32 65.88,74.93 v1(65.27,74.93)
  BOTTOM w0.254: PAD60300.3 76.27,74.05 v3(76.15,74.17) ; v1(65.27,74.93) 65.1,75.11 65.1,76.58 65.25,76.74 65.25,77.88 65.69,78.32 C60348.2 65.69,79.42 R60300.2
VRAVR_ON: length 4.4
  TOP w0.254: v1(81.89,160.98) 82.1,161.19 82.1,161.76 81.98,161.88 U66000.43
  BOTTOM w0.254: TP66001.1 80.11,161.85 R66001.1 R66000.2 81.77,161.1 v1(81.89,160.98)
VRB1V05A_BST: length 2.1
  BOTTOM w0.254: v2(225.07,52.35) 225.01,52.35 224.99,52.37 U60900.1
  BOTTOM w0.381: R60915.1 225.16,52.26 v2(225.07,52.35)
VRB1V05A_BST1: length 1.1
  BOTTOM w0.254: C60915.1 227.22,53.05 R60915.2
VRB1V8S_BST: length 1.3
  TOP w0.254: U67400.1 197.91,178.14 R67415.1
VRB1V8S_BST1: length 1
  TOP w0.381: R67415.2 198.75,179.34 C67415.1
VRB3V3A_BST: length 2.5
  TOP w0.254: v2(195.25,26.39) 195.25,26.05 U60100.8
  TOP w0.381: v2(195.25,26.39) 195.25,27.22 R60115.1
VRB3V3A_BST1: length 1.9
  TOP w0.381: C60115.1 196.1,28.44 196.08,28.46 196.08,28.57 v2(196.06,28.59) 196.05,28.58 R60115.2
VRB5V0_BST: length 2.3
  BOTTOM w0.254: v2(60.51,82.01) 60.51,81.91 60.72,81.69 U60250.1
  BOTTOM w0.381: R60265.1 60.51,82.78 v2(60.51,82.01)
VRB5V0_BST1: length 1
  BOTTOM w0.381: C60265.1 59.9,84.19 R60265.2
VRB5V0_VCC: length 3.5
  BOTTOM w0.254: U60250.17 59.41,79 58.98,78.57
  BOTTOM w0.381: v2(58.24,76.71) 58.24,77.02 58.64,77.42 C60259.1 58.64,78.18 58.64,78.23 58.98,78.57
VRB5V0A_BST:
  vias: v2(246.1,26.8)
VRB5V0A_BST1: length 2
  TOP w0.381: R60215.2 246.79,28.95 v2(247.29,28.45) 247.32,28.43 247.32,27.67 C60215.1
VRB5V0A_VCC: length 1.2
  TOP w0.381: C60209.1 246.91,22.08 246.58,22.41 246.58,22.86
VRB_VDD3: length 641.8
  TOP w0.305: U67400.15 197.91,173.85 198.22,173.54 v1(198.5,173.54) 198.5,173.35 199.16,172.69 C67430.1
  TOP w0.381: R67009.1 137.04,60.04 137.39,59.69 v1(137.39,58.5) ; PAD60100.4 210.34,25.86 211.15,25.05 v1(211.15,24.04)
  L3 w0.381: v1(137.39,58.5) 137.39,58.96 135.89,60.46 87.78,60.46 80.49,67.75 77.47,67.75 76.6,68.61 76.6,70.08 75.89,70.79 v1(75.49,70.79) 75.49,80 73.09,82.4 v1(73.09,84.67) 74.16,85.75 74.16,97.24 73,98.41 v1(73,99.67) ; v1(63.86,40.33) 65,41.46 65,45.77 57.96,52.81 v1(57.96,64.62)
  L5 w0.381: v1(220.88,52.91) 219.3,52.91 216.3,49.91 212.01,49.91 211.63,50.3 211.63,53.22 210.55,54.3 208.81,54.3 208.67,54.16 207.69,54.16 207.31,54.54 v1(207.31,54.93) ; v1(157.35,54.85) 154.74,57.46 139.24,57.46 138.2,58.5 v1(137.39,58.5) ; v1(198.5,173.54) 198.25,173.29 192.6,173.29 191.54,174.35 191.54,176.08 188.95,178.67 156.41,178.67 154.43,176.69 154.43,171.89 153.22,170.69 153.22,163.49 152.5,162.77 146.96,162.77 146.33,163.4 v1(146.33,165.84)
  L8 w0.381: 196.85,57.05 186.89,57.05 186.84,57 ; 196.85,57.05 206.59,57.05 206.87,56.77 206.87,55.37 v1(207.31,54.93) ; 196.85,57.05 196.86,57.04 196.86,55.33 v1(197.28,54.9) ; 186.84,57 186.84,55.33 v1(187.24,54.93) ; 186.84,57 176.78,57 ; 166.89,57 176.78,57 ; 166.89,57 166.85,56.96 166.85,55.25 v1(167.25,54.85) ; 166.89,57 161.06,57 158.36,54.31 157.76,54.31 157.44,54.63 157.44,54.76 v1(157.35,54.85) ; 176.78,57 176.78,55.33 v1(177.23,54.88) ; v1(146.33,165.84) 146.33,164.42 144.01,162.11 144.01,147.35 143.23,146.56 143.23,142.83 142.59,142.19 141.2,142.19 140.74,141.74 140.74,126.19 141.18,125.75 141.18,120.34 143.77,117.75 143.77,113.55 142.34,112.12 142.34,108.21 142.85,107.7 142.85,100.07 142.34,99.57 142.34,92.41 141.32,91.39 141.32,72.14 139.46,70.28 139.46,60.58 v1(137.39,58.5)
  L10 w0.381: v1(67.61,82.05) 69.01,83.44 72.51,83.44 73.09,84.02 v1(73.09,84.67) ; v1(63.86,40.33) 64.72,39.47 89.41,39.47 94.59,34.29 105.51,34.29 106.5,33.3 125.32,33.3 125.54,33.52 133.06,33.52 134.9,31.68 142.61,31.68 144.13,30.15 160.22,30.15 161.25,29.12 171.41,29.12 174.52,26.01 185.95,26.01 186.69,26.75 195.83,26.75 196.57,26.01 198.85,26.01 199.13,25.73 210,25.73 211.15,24.59 v1(211.15,24.04) ; v1(57.96,64.62) 63.33,64.62 69.93,71.21 75.07,71.21 v1(75.49,70.79)
  BOTTOM w0.254: U67050.20 198.75,56.27 198.46,56.56 198.46,56.69 198.21,56.94 C67059.1 197.73,56.94 196.87,56.08 196.87,55.31 v1(197.28,54.9) R67057.1 ; C60930.1 220.88,53.95 v1(220.88,52.91) 221.07,52.72 U60900.15 ; U67020.20 168.72,56.22 168.46,56.47 168.46,56.63 168.19,56.91 C67029.1 167.99,56.82 167.32,56.82 166.91,56.4 166.91,55.19 v1(167.25,54.85) R67027.1 ; R67067.1 v1(207.31,54.93) 206.93,55.3 206.93,56.37 207.46,56.89 208.02,56.89 C67069.1 208.14,56.96 208.81,56.3 U67060.20 ; U67040.20 188.71,56.3 188.44,56.57 188.44,56.72 188.12,57.04 C67049.1 187.84,57.04 187.68,56.87 187.17,56.87 186.84,56.55 186.84,55.33 v1(187.24,54.93) R67047.1 ; R67017.1 v1(157.35,54.85) 157,55.21 157,56.26 157.51,56.78 158.02,56.78 C67019.1 158.21,56.91 158.53,56.59 158.53,56.51 158.82,56.22 U67010.20 ; U67030.20 178.7,56.25 178.42,56.53 178.42,56.71 178.17,56.96 C67039.1 177.81,56.96 176.88,56.03 176.88,55.23 v1(177.23,54.88) 177.23,54.88 R67037.1
  BOTTOM w0.356: U60300.3 72.67,84.26 v1(73.09,84.67) 73.61,85.2 73.64,85.2 C60309.2
  BOTTOM w0.381: v1(67.61,82.05) 67.52,81.95 R60348.2 ; v1(73,99.67) R60506.1
VRB_VDD5: length 565.7
  TOP w0.381: R66109.1 85.39,173.71 v1(85.39,174.4) v2(84.12,174.4) 77.6,174.4 76.99,173.79 R66137.2 76.99,172.91 76.27,172.18 R66424.2 ; R67230.1 245.42,80.91 v1(245.92,81.41) ; PAD60200.4 v1(260.74,20.04)
  L3 w0.381: v1(267.18,76.69) 261.39,76.69 259.52,78.55 v1(247.6,78.55) 246.12,78.55 245.33,79.34 v1(240.7,79.34)
  L5 w0.381: v1(145.84,145.82) 146.33,145.82 146.75,146.24 146.75,148.52 153.24,155.01 181.49,155.01 188.5,162.02 194.67,162.02 195.35,161.34 195.35,159.9 197.52,157.73 197.52,100.88 205.67,92.73 205.67,91.96 205.67,89.15 210.69,84.13 230.6,84.13 234.08,80.65 v1(234.08,78.82) 235.48,78.82 236.98,80.32 239.72,80.32 v1(240.7,79.34) ; v1(85.39,174.4) 85.49,174.3 92.09,174.3 v1(94.87,171.52) 94.87,171.52 v1(105.66,171.52) 115.87,171.52 v1(116.07,171.31) 126.19,171.31 v1(126.44,171.57) 142.2,171.57 143.43,170.34 143.43,166.35 v1(143.53,166.25) ; v1(247.6,78.55) 247.6,80.22 246.4,81.41 v1(245.92,81.41)
  L8 w0.381: v1(85.39,174.4) 78.79,174.4 78.1,173.71 78.1,171.48 78.34,171.24 78.34,167.91 77.42,166.98 77.42,155.27 84.17,148.52 v1(84.17,147.2) 84.17,143.79 79.65,139.27 79.65,128.38 77.77,126.5 77.77,126.37 77.77,120.96 72.86,116.04 72.86,111.75 74.76,109.85 77.56,109.85 78.67,108.73 78.67,100.42 77.69,99.44 75.05,99.44 74.62,99.01 70.99,99.01 70.68,99.32 v1(69.01,99.32) ; v1(267.18,76.69) 267.18,75.95 275.23,67.9 283.66,67.9 284.1,68.33 288.39,68.33 290.22,66.5 290.22,65.36 290.85,64.72 291.46,64.72 292.68,63.5 293.16,63.5 294.04,62.63 294.05,62.63 294.57,62.11 294.57,58.27 293.75,57.45 293.75,50.07 292.2,48.52 292.2,36.61 297.15,31.65 297.15,24.18 294.38,21.42 294.38,21.11 293.08,19.8 269.97,19.8 269.38,20.39 261.1,20.39 v1(260.74,20.04)
  L10 w0.381: v1(143.53,166.25) 143.58,166.2 143.58,161.2 142.52,160.14 142.52,153.39 145.18,150.73 145.18,146.49 v1(145.84,145.82)
  BOTTOM w0.33: U66010.2 98.14,173.42 97.87,173.69 ; U66040.2 129.28,173.54 ; U66020.2 108.5,173.49 108.2,173.79 ; 118.55,173.79 118.92,173.42 U66030.2 ; U66040.29 127.14,171.35
  BOTTOM w0.381: R67209.2 234.69,78.41 234.29,78.82 v1(234.08,78.82) ; R66317.1 83.61,147.91 84.17,147.35 v1(84.17,147.2) ; 127.14,171.35 C66047.1 126.67,171.34 v1(126.44,171.57) 126.44,174.29 126.82,174.67 R66047.2 127.54,174.39 128.09,173.84 128.98,173.84 129.28,173.54 ; U66610.4 143.53,166.82 v1(143.53,166.25) 143.53,165.78 C66617.1 ; 94.89,171.52 94.89,173.94 95.57,174.63 R66017.2 96.41,174.28 97,173.69 97.87,173.69 ; 94.89,171.52 v1(94.87,171.52) ; 94.89,171.52 95.6,171.52 C66017.1 95.96,171.55 96.21,171.3 U66010.29 ; v1(69.01,99.32) 69.37,99.68 R60505.2 ; U66030.29 116.77,171.3 C66037.1 v1(116.07,171.31) 116.07,173.57 116.71,174.21 R66037.2 117.17,174.32 117.71,173.79 118.55,173.79 ; U66020.29 106.74,171.31 106.53,171.52 C66027.1 v1(105.66,171.52) 105.66,174.29 106.04,174.67 R66027.2 106.77,174.33 107.31,173.79 108.2,173.79
VRP1V0S_DGPU_PH:
  vias: v2(148.08,169.02)
VRP1V2_PH: length 9.8
  TOP w0.254: U67400.6 195.56,176.63 195.4,176.79 v1(195.4,176.94)
  TOP w0.381: C67415.2 200.26,178.92 L67400.1
  TOP w0.508: R67416.1 200.81,176.83 L67400.1
  BOTTOM w0.381: v1(198.78,176.94) v2(197.94,176.94) v1(195.4,176.94)
VRP1V05A_PH: length 8.2
  BOTTOM w0.178: U60900.6 223.37,50.07 223.37,52.87 U60900.20
  BOTTOM w0.508: R60916.1 223.25,57.72 ; C60915.2 224.48,53.29
VRP1V05A_VIN:
  vias: v2(226.21,49.33)
VRP1V8:
  vias: v2(205.69,172.98)
VRP1V8A: length 11.7
  TOP w0.432: v1(211.76,21.06) 212,20.82 R60600.2 212.45,20.82 C60605.1
  L8 w0.508: v1(220.77,20.73) 217.53,20.73 217.35,20.91 217.35,21.26 216.84,21.77 212.47,21.77 v1(211.76,21.06)
  vias: v2(221.36,28.1)
VRP1V8A_PH:
  vias: v2(216.81,24.87)
VRP1V8A_VIN:
  vias: v2(213.28,25.12)
VRP1V8S_VIN: length 7.9
  TOP w0.254: R67405.2 v1(195.27,172.65)
  L3 w0.254: v1(192.96,177.19) 192.15,176.38 192.15,173.83 192.62,173.36 194.56,173.36 v1(195.27,172.65)
  vias: v2(194.81,178.79)
VRP2V5: length 8.9
  BOTTOM w0.254: C60400.1 75.93,66.97 75.93,66.87 74.88,65.81 v2(74.88,61.9) C60405.1 R60400.1
VRP2V5_PH:
  vias: v2(79.93,61.6)
VRP2V5_VIN:
  vias: v2(78.66,56.9)
VRP3V3A:
  vias: v2(207.46,23.45)
VRP3V3A_LDO: length 16
  TOP w0.254: U60100.6 194.28,23.27 194.65,22.9 v1(194.81,22.9) 194.81,22.8 194.92,22.7 194.92,21.87 C60191.1
  BOTTOM w0.254: v1(194.81,22.9) 194.65,23.07 v2(193.19,23.07) 192.42,23.83 192.07,23.83 191.65,24.25 191.65,27.9 192.1,28.35 192.91,28.35 193.54,28.98 193.54,30.95 PAD60191.1 193.67,31.61 193.09,32.19 R7037.1
VRP3V3A_PH: length 4.7
  TOP w0.432: C60115.2 196.85,26.87 196.96,26.98 R60166.1
  TOP w0.508: 197.14,23.36 R60166.1
VRP3V3A_RTC: length 3.1
  BOTTOM w0.432: D4700.2 239.92,29.42 R4752.1 239.21,30.11 v2(239.01,30.31) 239.14,30.43 R4751.2
VRP3V3A_VIN:
  vias: v2(188.77,27.36)
VRP5V0:
  vias: v2(52.7,77.09)
VRP5V0_PH: length 8.2
  L10 w0.508: v1(58.82,83.09) 61.21,83.09 v3(63.36,80.94)
  BOTTOM w0.254: v3(63.36,80.94) 63.36,80.63 U60250.6
  BOTTOM w0.381: R60266.1 58.04,84.06 C60265.2
  BOTTOM w0.508: R60266.1 57.94,83.14
VRP5V0_VIN: length 1.4
  TOP w0.508: C60262.1 v1(64.79,82.43)
  BOTTOM w0.305: U60250.2 U60250.3
  vias: v2(62.4,82.12)
VRP5V0A:
  vias: v2(258.42,23.08)
VRP5V0A_PH: length 7.7
  TOP w0.432: 247.32,26.06 247.32,26.8 C60215.2
  TOP w0.508: R60216.1 248.34,25.96
  BOTTOM w0.508: v1(243.44,25.65) v2(244.32,25.65) v1(249.37,25.65)
VRP5V0A_VIN:
  vias: v2(240.61,29.37)
VRPCHG_HG: length 21.4
  TOP w0.508: v5(55.8,42.27) 56.23,41.84 56.23,37.43 52.1,33.3 47.14,33.3 v2(45.68,31.84) 44.82,30.98 v5(44.76,30.98)
  BOTTOM w0.254: v5(55.8,42.27) 56.08,42.55 U60000.26
  BOTTOM w0.381: Q60000.4 v5(44.76,30.98)
VRPCHG_LG: length 21
  TOP w0.508: v5(57.81,42.63) 58.04,42.41 58.04,36.22 v2(54.26,32.45) 53.44,31.63 53.44,29.76 v5(50.81,27.13)
  BOTTOM w0.254: U60000.23 57.28,43.56 57.31,43.51 57.31,43.19 57.6,42.89 57.6,42.84 v5(57.81,42.63)
  BOTTOM w0.381: Q60001.4 50.39,27.46 50.72,27.13 v5(50.81,27.13)
VRPCHG_PH: length 27.5
  TOP w0.508: v5(45.15,29.52) 44.79,29.52 v2(44.31,29.99) 43.75,30.56 43.75,31.69 46.61,34.55 51.81,34.55 54.91,37.65 54.91,42.62 v5(55.04,42.75)
  BOTTOM w0.254: U60000.27 55.68,43.21 55.22,42.75 v5(55.04,42.75)
  BOTTOM w0.381: Q60000.3 Q60000.2
  BOTTOM w0.432: v5(55.04,42.75) 55.04,42.59 C60015.2
  BOTTOM w0.508: L60000.1 v5(45.15,29.52)
VRPGPU_BST1: length 3.1
  BOTTOM w0.254: U67010.21 159.2,56.81 159.2,57.28 158.77,57.71 157.57,57.71 157.44,57.58 157.11,57.58 C67015.1
VRPGPU_BST2: length 3
  BOTTOM w0.254: U67020.21 169.14,56.78 169.14,57.15 168.58,57.71 167.46,57.71 167.36,57.62 C67025.1
VRPGPU_BST3: length 3
  BOTTOM w0.254: U67030.21 179.1,56.82 179.1,57.17 178.51,57.76 177.5,57.76 177.37,57.64 C67035.1
VRPGPU_BST4: length 3.1
  BOTTOM w0.254: U67040.21 189.13,56.86 189.13,57.13 188.41,57.84 187.5,57.84 187.32,57.65 186.99,57.65 C67045.1
VRPGPU_BST5: length 3.1
  BOTTOM w0.254: U67050.21 199.16,56.83 199.16,57.13 198.47,57.81 197.54,57.81 197.36,57.63 197.03,57.63 C67055.1
VRPGPU_BST6: length 2.9
  BOTTOM w0.254: C67065.1 207.05,57.65 207.38,57.65 207.45,57.72 208.57,57.72 209.14,57.15 209.14,56.9 U67060.21
VRPGPU_SW1: length 4.3
  BOTTOM w0.508: C67015.2 157.07,59.43 158.31,60.67 159.94,60.67
VRPGPU_SW2: length 5.7
  BOTTOM w0.508: 171.43,60.18 167.74,60.18 167.01,59.45 C67025.2
VRPGPU_SW3: length 5.5
  BOTTOM w0.508: 181.33,60.2 178.03,60.2 176.97,59.14 C67035.2
VRPGPU_SW4: length 5.1
  BOTTOM w0.508: 190.84,60.25 187.73,60.25 186.95,59.47 C67045.2
VRPGPU_SW5: length 5.2
  BOTTOM w0.508: C67055.2 196.99,59.53 197.66,60.2 200.9,60.2
VRPGPU_SW6: length 5.1
  BOTTOM w0.508: 210.89,60.23 207.77,60.23 207.02,59.47 C67065.2
VRPGT_HG1: length 18.3
  L3 w0.508: v5(68.5,135.41) 68.5,135.66 72.29,139.45 v4(72.29,140.69) 78.27,146.67 v5(78.59,146.67)
  BOTTOM w0.356: v5(78.59,146.67) 78.98,147.06 U66310.8
  BOTTOM w0.508: Q66311.1 72.74,140.24 v4(72.29,140.69) ; Q66310.1 68.5,135.97 v5(68.5,135.41)
VRPGT_LG1: length 21.2
  L3 w0.254: v5(77.19,135.44) 77.14,135.49
  L3 w0.508: 77.14,135.49 76.02,135.49 72.66,132.13 v5(72.66,131.7) ; v5(79.91,145.32) 81.3,143.92 81.3,140.97 77.19,136.86 v5(77.19,135.44)
  BOTTOM w0.254: v5(79.91,145.32) 80.28,145.69 U66310.5
  BOTTOM w0.508: v5(72.66,131.7) 72.99,132.03 72.99,132.45 ; Q66311.8 77.19,135.77 v5(77.19,135.44)
VRPGT_PH1: length 15.6
  L3 w0.508: v5(78.89,145.39) 74.16,140.66 v5(74.16,137.87)
  BOTTOM w0.254: U66310.7 78.97,146.11 78.69,146.11 C66315.1
  BOTTOM w0.508: L66310.1 68.88,131.09 R66316.2 ; C66315.1 78.68,145.39 78.88,145.39 78.89,145.39 v5(78.89,145.39)
  vias: v2(69.69,133.48)
VRPSA_HG1: length 10.5
  L10 w0.508: v5(145.74,169.12) 145.31,168.68 143.68,168.68 143.35,168.35 138.02,168.35 v5(137.42,168.95)
  BOTTOM w0.33: U66610.8 145.53,169.12 v5(145.74,169.12)
  BOTTOM w0.508: Q66610.1 v5(137.42,168.95)
VRPSA_LG1: length 1.3
  BOTTOM w0.305: Q66610.8 143.64,169.22 U66610.5
VRPSA_PH1: length 8.9
  TOP w0.508: v1(144.17,170.11) 143.3,170.11 142.41,169.21 v3(141.54,169.21) 141.5,169.25 R66616.1
  BOTTOM w0.254: U66610.7 144.64,169.67 C66615.2
  BOTTOM w0.508: v1(144.17,170.11) 144.6,170.11 144.83,169.88 C66615.2 ; v3(141.54,169.21) 140.78,169.97 Q66610.9
VRPVBAT_DGPU:
  vias: v2(163.39,47.17) v2(217.52,57.46) v5(161.92,44.38) v5(162.3,45.06) v5(162.68,44.38) v5(163.06,45.06) v5(163.42,44.4) v5(163.83,45.06) v5(164.18,44.4) v5(164.59,45.06) v5(164.92,44.4) v5(165.33,45.06) v5(165.68,44.4) v5(166.09,45.06) v5(217.34,60.43) v5(217.34,59.69) v5(217.37,58.93) v5(218.11,60.43) v5(218.11,59.69)
VRPVBAT_NVVDD: length 33.6
  TOP w0.508: v1(159.23,59.59) 159.23,60.2 158.72,60.71 154.28,60.71 153.83,61.15 130.15,61.15 128.9,59.91 R67088.2
  BOTTOM w0.508: C67012.1 159.52,59.3 v1(159.23,59.59)
  vias: v1(158.84,52.77) v1(158.84,52.03) v1(158.86,51.29) v1(159.52,52.77) v1(159.52,52.03) v1(159.52,51.29) v1(160.27,52.86) v1(160.27,52.18) v1(168.69,52.82) v1(168.69,52.16) v1(168.72,51.42) v1(169.38,52.82) v1(169.38,52.16) v1(169.37,51.42) v1(170.18,52.84) v1(170.2,52.18) v1(178.7,52.84) v1(178.7,52.16) v1(178.72,51.42) v1(179.38,52.84) v1(179.38,52.16) v1(179.38,51.42) v1(180.16,52.84) v1(180.16,52.2) v1(188.71,52.89) v1(188.71,52.16) v1(188.73,51.42) v1(189.39,52.89) v1(189.39,52.16) v1(189.39,51.42) v1(190.17,52.89) v1(190.17,52.25) v1(198.76,52.89) v1(198.76,52.16) v1(198.79,51.42) v1(199.45,51.42) v1(199.45,52.89) v1(199.45,52.16) v1(200.2,52.89) v1(200.2,52.25) v1(208.67,52.89) v1(208.67,52.16) v1(208.7,51.42) v1(209.38,52.89) v1(209.38,52.16) v1(209.39,51.42) v1(210.16,52.89) v1(210.16,52.23) v2(210.38,50.68)
VRPVCCIO:
  vias: v2(79.12,109.63)
VRPVCCIO_PH: length 4.6
  BOTTOM w0.381: R60516.1 72.83,101.83 C60515.2
  BOTTOM w0.508: L60500.1 72.93,103.33 R60516.1
VRPVCCIO_VIN:
  vias: v2(66.42,104.58)
VRPVDDQ: length 12.3
  L8 w0.508: v3(74.27,72.8) 74.27,74.02 75.71,75.47 75.71,79.94 74.34,81.31 v1(74.34,82.17)
  BOTTOM w0.356: U60300.6 73.99,82.33 74.14,82.17 v1(74.34,82.17)
VRPVDDQ_PH: length 1.1
  BOTTOM w0.381: C60315.2 67.48,77.37 ; R60347.1 66.67,77.58 67.1,77.14
VRPVDDQ_VIN:
  vias: v2(69.9,85.17)
VRPVTT: length 6.4
  L8 w0.508: v3(75.02,83.24) 73.95,83.24 73.28,82.57 73.28,80.95 v1(73.43,80.8)
  BOTTOM w0.356: U60300.8 73.2,80.8 v1(73.43,80.8) ; 74.15,83.06 73.5,83.06 73.27,82.83 U60300.5
VRPVTT_REF: length 2.1
  BOTTOM w0.356: v2(73.75,81.57) 73.5,81.83 U60300.7
  BOTTOM w0.432: C60351.1 73.97,81.35 v2(73.75,81.57)
WLAN_CLK: length 2.7
  TOP w0.109: R1352.2 287.53,28.14 v2(287.52,28.15) 287.53,28.16 287.53,28.77 v1(287.58,28.81)
  BOTTOM w0.109: v1(287.58,28.81) 287.58,28.7 287.7,28.58 CN1300.64
WLAN_CLKREQ14#: length 1.8
  TOP w0.102: R1358.1 283.76,24.2 R1357.2 282.88,24.44 v2(282.37,24.95)
WLAN_I2C_CLK: length 7.7
  TOP w0.109: v1(291.39,29.72) 291.54,29.72 TP1307.1
  BOTTOM w0.109: v1(291.39,29.72) 290.8,29.14 288.67,29.14 288.3,29.5 287.15,29.5 286.7,29.05 CN1300.60
WLAN_I2C_DAT: length 7.2
  TOP w0.109: v1(290.39,29.76) 290.83,30.19 TP1300.1
  BOTTOM w0.109: v1(290.39,29.76) 289.67,29.76 289.37,30.06 289.35,30.06 289.12,30.28 287.24,30.28 286.21,29.25 286.21,28.84 286.2,28.83 286.2,27.64 CN1300.58
WLAN_WAKE#: length 4.3
  TOP w0.102: R1359.1 286.25,21.24 286.24,21.26 v1(285.45,21.26) 285.44,21.25 v2(285.44,20.48) 285.15,20.19 Q1314.2
  BOTTOM w0.102: CN1300.55 285.45,21.25 v1(285.45,21.26)
WOL_PWEN: length 191.1
  L10 w0.102: v1(34.49,44.85) 37.85,44.85 39.95,42.75 53.91,42.75 55.04,41.61 66.77,41.61 66.93,41.76 67.77,41.76 69.19,40.34 89.59,40.34 95.23,34.7 111.43,34.7 111.9,35.17 134.37,35.17 135.35,34.19 149.55,34.19 151.54,32.2 167.52,32.2 169.11,30.61 173.91,30.61 176.79,27.73 185.16,27.73 185.51,28.08 186.51,29.08 192.57,29.08 192.69,28.96 195.31,28.96 195.59,29.24 197.94,29.24 198.68,29.98 200.71,29.98 202.59,31.86 203.22,31.86 204.03,32.67 211.3,32.67 v1(212.39,33.76)
  BOTTOM w0.102: CN603.19 v1(34.49,44.85) ; U1.109 212.97,34.33 v1(212.39,33.76)
WP_RCOMP: length 8.1
  BOTTOM w0.089: 258.74,67.06 258.53,66.86 258.52,66.86 257.26,65.6 257.26,65.08 U4710.BA1
  BOTTOM w0.102: R4600.1 v2(261.85,69.14) 261.85,68.36 260.73,67.24
  BOTTOM w0.109: 260.73,67.24 258.92,67.24 258.74,67.06
WR_CLK_DN: length 73.4
  TOP w0.107: R1338.1 277.47,24.39 277.47,25.93 276.16,27.24 276.16,40.47 275.99,40.64 274.85,40.64 274.62,40.87 274.62,41.24 274.85,41.47 276.32,41.47 276.45,41.59 276.45,41.75 276.32,41.88 274.85,41.88 274.62,42.11 274.62,42.48 274.85,42.71 276.32,42.71 276.45,42.83 276.45,42.99 276.32,43.12 274.85,43.12 274.62,43.35 274.62,43.72 274.85,43.94 276.32,43.94 276.45,44.07 276.45,44.23 276.32,44.36 274.85,44.36 274.62,44.58 274.62,44.96 274.85,45.18 276.34,45.18 276.45,45.29 276.45,61.53 271.03,66.95 264.76,66.95 261.39,63.58 259.06,63.58 258.81,63.83 258.47,63.83 v1(258.35,63.71)
  BOTTOM w0.107: v1(258.35,63.71) 258.37,63.71 258.49,63.83 258.72,63.83 258.84,63.71 U4710.BD4
WR_CLK_DP: length 73.5
  TOP w0.107: R1337.1 277.68,24.3 277.68,26.02 276.37,27.33 276.37,40.56 276.08,40.85 274.94,40.85 274.83,40.95 274.83,41.15 274.94,41.26 276.41,41.26 276.66,41.51 276.66,41.84 276.41,42.09 274.94,42.09 274.83,42.19 274.83,42.39 274.94,42.5 276.41,42.5 276.66,42.75 276.66,43.08 276.41,43.32 274.94,43.32 274.83,43.43 274.83,43.63 274.94,43.74 276.41,43.74 276.66,43.98 276.66,44.32 276.41,44.56 274.94,44.56 274.83,44.67 274.83,44.87 274.94,44.98 276.43,44.98 276.66,45.21 276.66,61.62 271.12,67.16 264.67,67.16 261.3,63.79 259.15,63.79 v3(258.62,64.31)
  BOTTOM w0.107: U4710.BE3 v3(258.62,64.31)
WR_LANE0_DN: length 72.9
  TOP w0.107: R1366.1 275.45,24 275.74,24.29 275.74,24.8 275.49,25.06 275.49,37.87 273.83,39.53 273.83,45.56 274.29,46.02 275.63,46.02 275.74,46.13 275.74,46.32 275.63,46.43 274.16,46.43 273.94,46.66 273.94,47.03 274.16,47.26 275.63,47.26 275.74,47.36 275.74,47.56 275.63,47.67 274.16,47.67 273.94,47.9 273.94,48.27 274.16,48.5 275.63,48.5 275.74,48.6 275.74,48.8 275.63,48.91 274.16,48.91 273.94,49.14 273.94,49.51 274.16,49.74 275.63,49.74 275.74,49.84 275.74,61.14 271.4,65.48 267.39,65.48 267.18,65.69 266.65,65.69 266.17,66.17 v1(266.14,66.17)
  BOTTOM w0.089: 259.99,66.19 259.97,66.19 259.95,66.21 259.11,66.21 258.03,65.12 258.03,64.65 U4710.BB3
  BOTTOM w0.107: v1(266.14,66.17) 266.27,66.17 266.64,66.54 266.64,67.14 266.19,67.59 263.01,67.59 261.61,66.19 259.99,66.19
WR_LANE0_DP: length 73
  TOP w0.107: v3(266.85,66.17) 267.61,65.69 271.49,65.69 275.95,61.23 275.95,49.76 275.72,49.53 274.25,49.53 274.14,49.42 274.14,49.22 274.25,49.12 275.72,49.12 275.95,48.89 275.95,48.52 275.72,48.29 274.25,48.29 274.14,48.18 274.14,47.98 274.25,47.88 275.72,47.88 275.95,47.65 275.95,47.28 275.72,47.05 274.25,47.05 274.14,46.94 274.14,46.75 274.25,46.64 275.72,46.64 275.95,46.41 275.95,46.04 275.72,45.81 274.38,45.81 274.04,45.48 274.04,39.61 275.69,37.96 275.69,25.14 275.95,24.89 275.95,24.22 R1324.1
  BOTTOM w0.089: 259.99,66.4 259.97,66.4 259.95,66.38 259.04,66.38 257.85,65.19 257.85,64.57 U4710.BB4
  BOTTOM w0.107: v3(266.85,66.17) 266.85,67.22 266.28,67.8 262.93,67.8 261.53,66.4 259.99,66.4
WR_LANE1_DN: length 73.1
  TOP w0.107: v3(268.19,64.77) 268.42,64.55 268.42,64.31 268.65,64.08 271.92,64.08 274.85,61.15 274.85,54.41 274.74,54.31 273.38,54.31 273.15,54.08 273.15,53.58 273.38,53.35 274.71,53.35 274.82,53.25 274.82,53.05 274.71,52.94 273.38,52.94 273.15,52.71 273.15,52.34 273.38,52.11 274.71,52.11 274.82,52.01 274.82,51.81 274.71,51.7 273.38,51.7 273.15,51.47 273.15,51.1 273.38,50.87 274.71,50.87 274.82,50.77 274.82,50.57 274.71,50.46 273.43,50.46 272.97,50 272.97,38.72 274.85,36.84 274.85,25.95 273.89,24.99 273.89,24.42 R1328.1
  BOTTOM w0.089: 258.47,66.15 258.46,66.14 258.43,66.14 257.61,65.32 257.61,64.66 257.66,64.61 257.66,64.39 257.65,64.38 257.65,64.2 U4710.BA3
  BOTTOM w0.107: v3(268.19,64.77) 268.42,65 268.42,66.26 266.4,68.28 262.73,68.28 261.1,66.65 258.96,66.65 258.47,66.15
