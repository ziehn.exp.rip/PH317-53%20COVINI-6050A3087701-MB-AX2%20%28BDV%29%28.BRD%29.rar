# Allegro board PH317-53 COVINI-6050A3087701-MB-AX2 (BDV)(.BRD).brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
DP_IFPB_0#: length 208.4
  TOP w0.091: v1(286.23,62.26) 286.37,62.11 286.37,61.84 286.61,61.61 286.61,58.1 287.24,57.47 287.24,56.94 287.34,56.84 287.62,56.84 C51626.1
  L10 w0.076: v1(286.23,62.26) 286.33,62.26 286.46,62.13 286.46,61.95 286.13,61.62 275.34,61.62 273.63,63.33 264.92,63.33 263.88,64.37 262.51,64.37 262.21,64.08 260.36,64.08 259.42,65.02 252.51,65.02 252.31,65.22 252.31,66.77 250.57,68.51 236.53,68.51 235.97,68.51 234,66.55 221.67,66.55 220.28,67.94 220.28,71.11 219.39,72 216.79,72 215.41,73.38 167.26,73.38 161.84,78.79 161.84,81.09 155.52,87.41 155.52,87.65 154.89,88.29 154.89,92.28 151.01,96.16 149.56,96.16 142.91,102.81 142.91,111.66 144.87,113.61 144.87,121.02 150.55,126.7 155.27,126.7 155.37,126.6 v4(155.37,126.39)
  BOTTOM w0.091: v4(155.37,126.39) 155.39,126.39 U50000.BF20
DP_IFPB_1: length 205
  TOP w0.091: v3(285.87,63.25) 285.66,63.04 285.66,61.66 286.12,61.2 286.12,56.32 286.86,55.58 287.28,55.58 C51625.1
  L10 w0.076: v4(153.95,125.75) 153.89,125.69 150.18,125.69 145.96,121.46 145.96,114.06 143.83,111.93 143.83,105.26 152.02,97.08 152.02,95.8 155.94,91.88 155.94,88.99 162.3,82.63 162.3,78.98 167.45,73.84 215.6,73.84 216.98,72.45 219.85,72.45 220.73,71.58 220.73,68.13 221.86,67 233.82,67 235.78,68.97 236.16,68.97 236.16,68.97 236.72,68.97 252.37,68.97 252.84,68.49 255.91,68.49 256.64,67.77 256.64,67.59 258.33,65.9 263.93,65.9 265.93,63.89 274.56,63.89 275.65,62.81 283.19,62.81 283.41,62.59 285.39,62.59 285.65,62.85 285.65,63.03 v3(285.87,63.25)
  BOTTOM w0.091: v4(153.95,125.75) 153.95,125.8 154.25,126.08 U50000.BH20
DP_IFPB_1#: length 205.1
  TOP w0.091: C51624.1 287.29,55.39 286.78,55.39 285.92,56.24 285.92,61.12 285.47,61.58 285.47,62.99 v1(285.21,63.25)
  L10 w0.076: v1(285.21,63.25) 285.43,63.03 285.43,62.94 285.3,62.81 283.5,62.81 283.28,63.02 275.74,63.02 274.65,64.11 266.02,64.11 264.02,66.11 258.43,66.11 256.86,67.68 256.86,67.86 256,68.71 252.93,68.71 252.46,69.18 236.81,69.18 236.81,69.18 236.25,69.18 235.69,69.18 233.72,67.22 221.95,67.22 220.95,68.22 220.95,71.67 219.94,72.67 217.07,72.67 215.69,74.05 167.54,74.05 162.52,79.07 162.52,82.72 156.16,89.09 156.16,91.97 152.23,95.89 152.23,97.17 144.05,105.35 144.05,111.84 146.18,113.97 146.18,121.37 150.27,125.47 153.74,125.47 153.81,125.4 154.34,125.4 v4(154.71,125.77)
  BOTTOM w0.091: U50000.BG20 154.95,126.08 154.71,125.82 v4(154.71,125.77)
DP_IFPB_2: length 204.9
  TOP w0.091: C51623.1 287.37,53.87 287.1,53.87 285.38,55.59 285.38,60.95 284.25,62.08 284.25,64.09 v3(284.47,64.32)
  L10 w0.076: v3(284.47,64.32) 284.25,64.1 284.25,63.86 283.88,63.49 276.16,63.49 274.39,65.25 268.97,65.25 268.83,65.39 265.39,65.39 264.13,66.65 260.34,66.65 259.18,67.82 259.18,68.05 257.57,69.66 235.42,69.66 233.44,67.68 222.14,67.68 221.41,68.41 221.41,71.86 220.4,72.86 220.13,73.13 217.26,73.13 215.88,74.51 167.73,74.51 162.97,79.26 162.97,82.92 158.17,87.72 158.17,91.89 144.51,105.56 144.51,111.65 147.12,114.26 147.12,120.95 150.95,124.78 154.45,124.78 154.66,124.99 v4(154.66,125.02)
  BOTTOM w0.091: U50000.BG18 155,124.78 154.76,125.02 v4(154.66,125.02)
DP_IFPB_2#: length 204.9
  TOP w0.091: v1(283.81,64.32) 284.05,64.08 284.05,62 285.18,60.87 285.18,55.51 287.02,53.67 287.2,53.67 C51622.1
  L10 w0.076: v1(283.81,64.32) 284.03,64.1 284.03,63.95 283.79,63.71 276.25,63.71 274.48,65.47 269.06,65.47 268.92,65.61 265.48,65.61 264.22,66.87 260.43,66.87 259.39,67.91 259.39,68.14 257.66,69.88 235.33,69.88 233.34,67.9 222.23,67.9 221.63,68.5 221.63,71.77 221.63,71.95 220.62,72.95 220.23,73.35 217.35,73.35 215.97,74.73 167.82,74.73 163.19,79.35 163.19,83.01 158.39,87.82 158.39,91.98 144.73,105.65 144.73,111.56 147.34,114.17 147.34,120.86 151.04,124.57 154.76,124.57 155.22,125.02 v4(155.39,125.02)
  BOTTOM w0.091: v4(155.39,125.02) 155.7,124.72 U50000.BF18
DP_IFPB_3: length 202.4
  TOP w0.091: C51621.1 287.28,51.97 287.04,51.97 285.09,53.92 285.09,54.86 283.92,56.03 283.92,59.92 283.11,60.74 283.11,64.8 v3(283.33,65.03)
  L10 w0.076: v4(156.04,124.36) 156.04,124.36 155.85,124.36 155.5,124.01 155.2,124.01 155.18,124.03 155.18,124.03 155.17,124.04 151.47,124.04 148.01,120.58 148.01,108.91 148.58,108.33 149.9,108.33 150.62,107.61 150.62,103.74 161.2,93.16 161.2,89.05 161.39,88.86 161.39,86.77 162,86.16 162,85.16 163.87,83.29 163.87,83.27 166.52,80.62 213.7,80.62 213.97,80.88 214.84,81.76 231.8,81.76 232.51,81.05 233.08,81.05 233.74,80.39 234.18,80.39 235.2,79.37 235.2,75.38 236.4,74.18 239.83,74.18 240.1,74.46 247.67,74.46 248.52,73.6 248.52,72.23 250.2,70.56 261.68,70.56 264.44,67.8 275.44,67.8 276.64,66.59 279.13,66.59 279.42,66.88 282.34,66.88 283.12,66.1 283.12,65.24 v3(283.33,65.03)
  BOTTOM w0.091: v4(156.04,124.36) 156.4,124 U50000.BE17
DP_IFPB_3#: length 202.4
  TOP w0.091: v1(282.67,65.03) 282.91,64.79 282.91,60.66 283.72,59.84 283.72,55.95 284.89,54.78 284.89,53.84 286.96,51.78 287.29,51.78 C51620.1
  L10 w0.076: v6(155.35,124.37) 155.24,124.26 151.38,124.26 147.79,120.67 147.79,108.82 148.49,108.12 149.81,108.12 150.4,107.52 150.4,103.65 160.98,93.07 160.98,88.96 161.17,88.77 161.17,86.68 161.78,86.07 161.78,85.07 163.65,83.2 163.65,83.18 166.43,80.4 213.79,80.4 214.19,80.79 214.93,81.54 231.71,81.54 232.42,80.83 232.99,80.83 233.65,80.17 234.09,80.17 234.98,79.28 234.98,75.29 236.31,73.96 239.92,73.96 240.19,74.24 247.58,74.24 248.3,73.51 248.3,72.14 250.11,70.34 261.59,70.34 264.35,67.58 275.35,67.58 276.55,66.37 279.22,66.37 279.51,66.66 282.25,66.66 282.9,66.01 282.9,65.15 282.77,65.03 v1(282.67,65.03)
  BOTTOM w0.091: v6(155.35,124.37) 155.44,124.37 155.7,124.11 U50000.BF17
DP_IFPB_AUX: length 193.1
  TOP w0.091: v3(300.92,61.29) R51660.2 301.78,60.63 302.11,60.29 Q51660.2
  L3 w0.076: v1(151.83,119.41) 151.83,119.27 152.31,118.79 152.31,117.95 150.72,116.37 150.72,112.09 152.92,109.89 152.92,102.34 158.93,96.33 158.93,95.78 163.06,91.65 163.06,86.8 166.65,83.21 212.97,83.21 213.93,84.18 233.33,84.18 233.78,83.73 234.29,83.73 234.68,83.33 234.92,83.09 235.35,83.09 235.75,82.69 238.02,80.42 271.01,80.42 281.39,70.05 283.27,70.05 286.18,67.14 286.18,66.38 289.43,63.12 293.1,63.12 293.68,62.54 300.02,62.54 300.7,61.86 300.7,61.51 v3(300.92,61.29)
  BOTTOM w0.091: U50000.BK9 152.07,118.78 151.91,118.94 151.91,118.94 151.83,119.02 v1(151.83,119.41)
DP_IFPB_AUX#: length 193.1
  TOP w0.091: Q51640.2 299.61,60.47 R51640.1 v1(300.26,61.29)
  L3 w0.076: v1(151.38,118.93) 151.49,119.03 151.76,119.03 152.09,118.7 152.09,118.04 150.5,116.46 150.5,112 152.7,109.8 152.7,102.25 158.71,96.24 158.71,95.69 162.85,91.56 162.85,86.7 166.56,83 213.06,83 214.02,83.96 233.23,83.96 233.69,83.51 234.19,83.51 234.46,83.24 234.83,82.87 235.26,82.87 235.53,82.6 237.93,80.2 270.92,80.2 281.3,69.83 283.18,69.83 285.96,67.05 285.96,66.28 289.34,62.9 293,62.9 293.59,62.32 299.93,62.32 300.48,61.77 300.48,61.51 v1(300.26,61.29)
  BOTTOM w0.091: v1(151.38,118.93) 151.45,119 151.58,119 U50000.BL9
DP_IFPB_MODS: length 20.2
  TOP w0.102: Q51630.1 298.82,55.49 Q51641.1 299.05,57.54 v1(299.05,57.91) 297.87,57.91 297.43,58.35 297.43,61.04 297.71,61.31 C51671.1 297.71,63.69 R51672.1 297.35,64.05 Q51670.6 ; 301.68,57.91 v1(302.53,57.91) ; 301.68,57.91 Q51661.1 ; 301.68,57.91 302.46,57.12 302.46,55.97 301.98,55.49 Q51650.1
  L5 w0.102: v1(302.53,57.91) v1(299.05,57.91)
DP_LANE_0N: length 2.5
  TOP w0.091: U55800.5 290.08,56.62 289.87,56.82 289.51,56.82 289.07,57.26 288.89,57.26 C51626.2
DP_LANE_0P: length 2.4
  TOP w0.091: U55800.4 290.02,57.11 289.93,57.02 289.59,57.02 289.15,57.45 288.77,57.45 C51627.2
DP_LANE_1N: length 2.3
  TOP w0.091: C51624.2 288.81,55.38 289.58,55.38 289.69,55.26 289.98,55.26 290.12,55.11 U55800.8
DP_LANE_1P: length 2.4
  TOP w0.091: U55800.7 290.13,55.61 289.98,55.47 289.76,55.47 289.66,55.57 288.85,55.57 C51625.2
DP_LANE_2N: length 2.4
  TOP w0.091: C51622.2 288.89,53.65 289.67,53.65 289.76,53.73 290.05,53.73 290.18,53.61 U55800.11
DP_LANE_2P: length 2.3
  TOP w0.091: C51623.2 288.77,53.84 289.57,53.84 289.66,53.93 290.04,53.93 290.22,54.11 U55800.10
DP_LANE_3N: length 2.5
  TOP w0.091: U55800.14 290.13,52.11 289.98,52.26 289.74,52.26 289.26,51.78 288.82,51.78 C51620.2
DP_LANE_3P: length 2.5
  TOP w0.091: U55800.13 290.17,52.61 290.01,52.45 289.66,52.45 289.18,51.97 288.84,51.97 C51621.2
DP_MA_HPD#: length 37.2
  L5 w0.102: v1(272.46,69.55) 272.46,67.14 272.52,67.08 272.52,66.74 272.23,66.45 272.23,61.83 273.66,60.4 273.66,55.73 v1(272.46,54.54)
  L8 w0.102: v3(257.5,49.44) 260.15,49.44 261.01,50.3 261.5,50.3 262.16,50.96 265.45,50.96 267.15,52.66 268.22,52.66 269.52,53.95 271.88,53.95 v1(272.46,54.54)
  BOTTOM w0.089: U4710.BD34 257.73,49.44 v3(257.5,49.44)
  BOTTOM w0.102: Q56280.3 273.31,69.55 v1(272.46,69.55) 272.66,69.75 R56282.1
DP_NA_HPD: length 3.3
  BOTTOM w0.102: R56281.1 273.37,66.93 R56280.2 274.11,66.93 v2(274.27,66.78) 274.71,67.22 Q56280.1
DP_NV_HPD: length 2.9
  BOTTOM w0.102: Q56260.1 271.68,68.13 R56261.1 271.09,67.36 v2(270.86,67.14) 270.71,67.29 R56260.2
DP_P1_HPD: length 10.8
  BOTTOM w0.089: 256.15,67.85 255.47,67.17 254.79,67.17 254.11,66.49 254.11,66.43 254.1,66.42 254.1,64.54 254.2,64.45 254.2,62.8 U4710.AT6
  BOTTOM w0.102: 256.15,67.85 256.19,67.89 256.19,68.16 256.2,68.17 256.2,68.3 257.71,69.81 v2(257.71,70.18) 258.37,70.84 R4853.2
DP_P2_HPD: length 1.5
  TOP w0.102: R4854.2 252.41,60.23 v1(252.73,60.23)
  BOTTOM w0.089: v1(252.73,60.23) 252.73,60.28 252.81,60.36 U4710.AN10
DP_REP_CFG0: length 2.1
  TOP w0.102: R55818.1 295.32,58.68 v2(294.89,58.25) 294.76,58.11 U55800.37
DP_REP_CFG1: length 2.3
  TOP w0.102: U55800.38 293.91,58.61 v2(294.81,59.51) 294.81,59.51 294.89,59.59 R55819.1
DP_REP_EQ0: length 2.5
  TOP w0.102: U55800.39 292.92,59.3 v2(293.65,60.02) 293.09,60.58 R55812.1
DP_REP_EQ1: length 2.1
  TOP w0.102: U55800.40 292.42,59.98 v2(292.38,60.02) 292,60.4 R55813.1
DP_REP_EQ2: length 2.3
  TOP w0.102: R55814.1 v2(291.11,60.02) 291.21,60.02 291.92,59.31 U55800.41
DP_REP_EQ3: length 3
  TOP w0.102: U55800.42 291.42,59.15 291.11,59.46 290.37,59.46 v2(289.84,60) 289.84,60.49 R55815.1
DP_REP_HPD: length 3.6
  BOTTOM w0.102: R56271.1 276.4,66.04 v2(276.45,66.09) 276.65,66.29 R56270.2 276.65,67.03 277.61,67.99 Q56270.1
DP_REP_HPD#: length 32
  TOP w0.102: U55800.20 292.42,49.65 v1(292.04,49.26) 291.26,48.49 R55830.1
  L5 w0.102: v1(292.04,49.26) 290.98,50.32 290.98,57.99 290.52,58.45 287.73,58.45 285.98,60.2 284.5,60.2 281.33,63.37 281.33,64.67 v3(278.94,67.06)
  BOTTOM w0.102: v3(278.94,67.06) 278.69,67.31 278.69,68.51 278.48,68.71 278.13,68.71 277.06,69.78 Q56270.3
DP_REP_I2CEN: length 2.9
  TOP w0.102: R55810.1 R55811.1 v2(293.09,49.2) 293.09,49.91 292.92,50.08 U55800.21
DP_REP_SW0: length 2.4
  TOP w0.102: R55817.1 289.01,58.75 v2(289.34,58.42) 289.65,58.11 U55800.2
DP_REP_SW1: length 3.8
  TOP w0.102: U55800.1 290.38,58.61 289.73,59.26 288.98,59.26 v2(288.63,59.61) 288.95,59.93 R55816.1
DP_UTIL: length 5.1
  TOP w0.102: TP4500.1 v1(130.88,142.24)
  BOTTOM w0.076: U4555.A33 126.85,141.38 129.99,141.38 130.86,142.24 v1(130.88,142.24)
DPB_DDCCLK: length 2.9
  TOP w0.109: v1(252.64,59.01) 252.64,59.08 v2(253.28,59.72) 254.54,59.72 R4806.1
  BOTTOM w0.109: v1(252.64,59.01) 252.61,58.98 252.46,58.98 252.38,58.91 252.18,58.91 U4710.AL13
DPB_DDCDATA: length 3.3
  TOP w0.109: v1(253.54,62.11) 253.98,62.54 R4807.1 253.98,63.8 v2(253.67,64.11)
  BOTTOM w0.109: v1(253.54,62.11) 253.94,61.7 U4710.AR8
DPC_DDCCLK: length 1.6
  TOP w0.109: v3(253.74,58.53) 254.01,58.8 R4808.1
  BOTTOM w0.109: U4710.AN13 253.41,58.87 v3(253.74,58.53)
DPC_DDCDATA: length 2.8
  TOP w0.109: v1(252.78,60.81) 252.88,60.91 v2(253.78,60.91) 253.81,60.89 254.26,60.89 R4809.1
  BOTTOM w0.107: U4710.AL10 252.54,60.79 252.76,60.79 v1(252.78,60.81)
DPC_L_TX0N: length 19.8
  L3 w0.076: CN56200.5 310.65,53.83 309.85,53.83 308.86,54.82 308.49,54.82 307.83,55.48 307.83,56 307.64,56.19 306.77,56.19 306.48,56.48 306.48,57.95 305.95,58.48 303.57,58.48 303.49,58.41 303.49,57.91 303.57,57.83 305.11,57.83 305.85,57.09 305.85,56.34 305.65,56.14 305.3,56.14 v3(305.11,55.95)
  BOTTOM w0.091: v3(305.11,55.95) 304.87,56.19 304.34,56.19 304.21,56.06 303.77,56.06 D56220.2 D56220.9 302.52,56.03 302.31,56.24 301.93,56.24 301.7,56.02 L56220.4
DPC_L_TX0P: length 19.8
  L3 w0.076: v1(305.11,56.61) 305.36,56.36 305.56,56.36 305.63,56.43 305.63,57 305.02,57.61 303.48,57.61 303.27,57.81 303.27,58.5 303.48,58.7 306.04,58.7 306.7,58.04 306.7,56.57 306.86,56.41 307.73,56.41 308.05,56.09 308.05,55.57 308.58,55.04 308.95,55.04 309.94,54.04 310.82,54.04 CN56200.3
  BOTTOM w0.091: v1(305.11,56.61) 304.88,56.38 304.38,56.38 304.23,56.53 D56220.1 D56220.10 302.52,56.53 302.43,56.44 302.05,56.44 301.68,56.82 L56220.3
DPC_L_TX1N: length 21
  L3 w0.076: CN56200.11 308.71,51.97 308.55,51.97 308.47,51.9 308.47,50.28 308.15,49.97 306.64,49.97 306.43,50.17 306.43,50.92 306.64,51.12 307.5,51.12 307.58,51.2 307.58,51.5 307.5,51.58 306.64,51.58 306.43,51.79 306.43,52.27 306.64,52.48 307.5,52.48 307.58,52.55 307.58,52.86 307.5,52.93 306.64,52.93 306.43,53.14 306.43,53.87 306.64,54.07 307.39,54.07 307.46,54.15 307.46,54.82 307.11,55.17 306.17,55.17 305.71,54.72 305.32,54.72 305.09,54.49 v3(305.09,54.45)
  BOTTOM w0.091: L56221.4 301.65,54.29 301.97,54.61 302.77,54.61 D56220.6 D56220.5 304.27,54.53 304.43,54.69 304.85,54.69 304.91,54.63 v3(305.09,54.45)
DPC_L_TX1P: length 20.9
  L3 w0.076: CN56200.9 308.77,52.19 308.46,52.19 308.25,51.99 308.25,50.37 308.06,50.18 306.73,50.18 306.65,50.26 306.65,50.83 306.73,50.91 307.59,50.91 307.79,51.11 307.79,51.6 307.59,51.8 306.73,51.8 306.65,51.88 306.65,52.18 306.73,52.26 307.59,52.26 307.79,52.46 307.79,52.95 307.59,53.15 306.73,53.15 306.65,53.23 306.65,53.78 306.73,53.85 307.48,53.85 307.68,54.06 307.68,54.91 307.2,55.39 306.08,55.39 305.62,54.93 305.28,54.93 v1(305.11,55.11)
  BOTTOM w0.091: L56221.3 301.75,55.09 302.04,54.81 302.3,54.81 302.52,55.03 D56220.7 D56220.4 304.27,55.03 304.41,54.88 304.88,54.88 v1(305.11,55.11)
DPC_L_TX2N: length 23.3
  L3 w0.076: v1(305.06,52.4) 305.06,52.49 305.21,52.64 305.36,52.64 305.56,52.44 305.56,51.95 305.15,51.54 301.22,51.54 300.96,51.29 300.96,49 301.17,48.8 302.57,48.8 303.06,49.29 308.84,49.29 309.7,50.15 310.73,50.15 CN56200.17
  BOTTOM w0.091: v1(305.06,52.4) 305.06,52.44 304.82,52.68 304.3,52.68 304.19,52.57 D56225.2 D56225.9 302.44,52.57 302.28,52.73 301.88,52.73 301.7,52.56 L56225.4
DPC_L_TX2P: length 23.3
  L3 w0.076: v3(305.06,53.06) 305.26,52.86 305.45,52.86 305.78,52.54 305.78,51.86 305.24,51.32 301.31,51.32 301.18,51.2 301.18,49.09 301.26,49.02 302.48,49.02 302.97,49.51 308.74,49.51 309.61,50.37 310.75,50.37 CN56200.15
  BOTTOM w0.091: v3(305.06,53.06) 304.87,52.88 304.39,52.88 304.19,53.07 D56225.1 D56225.10 302.47,53.07 302.34,52.94 302.07,52.94 301.65,53.36 L56225.3
DPC_L_TX3N: length 6.5
  BOTTOM w0.091: L56226.4 301.57,50.83 301.96,51.22 302.4,51.22 302.55,51.07 D56225.6 D56225.5 304.19,51.07 304.34,51.22 305.11,51.22 305.79,51.91 306.05,51.91 306.06,51.91 306.22,51.75 CN56200.12
DPC_L_TX3P: length 6.5
  BOTTOM w0.091: L56226.3 301.75,51.64 301.97,51.42 302.32,51.42 302.33,51.42 302.39,51.42 302.54,51.57 D56225.7 D56225.4 304.19,51.57 304.35,51.41 305.03,51.41 305.71,52.1 305.97,52.1 306.22,52.35 CN56200.10
DPWROK: length 69.6
  L10 w0.102: v3(205.15,31.14) 205.53,30.76 209.24,30.76 209.85,30.15 215.95,30.15 216.18,29.92 216.68,29.92 216.71,29.95 219.05,29.95 219.2,29.8 222.5,29.8 222.96,29.34 231.62,29.34 232.72,30.45 237.53,30.45 238.86,31.78 241.63,31.78 244.98,35.13 248.1,35.13 248.87,35.9 248.87,38.32 249.3,38.75 249.3,40.53 253.71,44.94 253.95,44.94 254.25,45.24 254.32,45.24 254.88,45.8 255.67,45.8 v1(255.93,45.55)
  BOTTOM w0.089: U4710.AW41 256.02,45.36 255.93,45.45 v1(255.93,45.55)
  BOTTOM w0.102: v3(205.15,31.14) 205.15,31.04 203.76,29.65 203.76,28.88 203.32,28.45 203.32,27.3 203.77,26.85 204.47,26.85 205.49,25.84 U1.19
EC_ACPRESENT: length 67
  L10 w0.102: v1(217.18,28.05) 217.18,28.02 217.97,27.24 222.8,27.24 224.88,25.16 228.54,25.16 228.68,25.3 229.02,25.3 229.16,25.16 231.24,25.16 234.22,28.15 247.2,28.15 247.86,28.81 252.41,28.81 252.96,29.36 254.89,31.29 254.89,32.63 256.33,34.07 256.33,36.64 258.88,39.2 260.15,39.2 265.58,44.62 265.58,44.96 v1(266.24,45.62)
  BOTTOM w0.102: D4801.3 266.32,45.7 v1(266.24,45.62) ; v1(217.18,28.05) 217.18,28.36 v2(216.89,28.65) 216.65,28.89 R367.1 215.82,28.89 215.57,29.13 U1.122
EC_CPU_PROCHOT#: length 3.6
  BOTTOM w0.109: R339.1 217.76,34.62 v2(216.99,34.62) 216.96,34.59 215.27,34.59 215.14,34.72 214.88,34.72 214.86,34.74 U1.108
EC_CTL1: length 75.2
  TOP w0.102: R2554.1 279.52,26.8 v1(279.2,26.47)
  L5 w0.102: v3(212.11,24.04) 213.47,25.4 215.62,25.4 216,25.78 216,26.22 216.35,26.57 220.85,26.57 223.8,23.62 239.31,23.62 242.19,26.5 250.83,26.5 251.47,27.14 257.07,27.14 257.92,26.29 260.57,26.29 261.28,27 267.93,27 269.35,28.43 277.16,28.43 279.12,26.47 v1(279.2,26.47)
  BOTTOM w0.102: v3(212.11,24.04) 212.11,24.06 212.29,24.23 U1.2
EC_CTL2: length 78.7
  TOP w0.102: v1(286.25,26.47) 285.77,26.95 R2553.1
  L5 w0.102: v1(215.39,26.09) 216.07,26.78 220.93,26.78 223.88,23.83 239.23,23.83 242.11,26.71 250.75,26.71 251.39,27.35 267.99,27.35 269.88,29.24 276.65,29.24 278.99,26.9 285.82,26.9 v1(286.25,26.47)
  BOTTOM w0.102: U1.128 214.29,26.33 v2(214.73,25.89) 215.19,25.89 v1(215.39,26.09)
EC_CTL3: length 100.9
  TOP w0.102: v1(287.32,26.47) 286.66,27.13 R2558.1
  L8 w0.102: v1(287.32,26.47) 287.32,26 286.65,25.33 284.78,25.33 282.52,23.07 281.29,23.07 280.96,23.4 280.16,23.4 279.83,23.07 270.56,23.07 268.86,24.77 268.86,26.82 266.15,29.53 257.84,29.53 257.53,29.21 255.62,29.21 254.4,30.43 254.4,33.61 252.7,35.31 247,35.31 245.56,36.76 240.77,36.76 240.03,36.02 238.44,36.02 237.73,36.73 231.23,36.73 227.7,40.26 209.3,40.26 207.6,38.56 205.58,38.56 v1(204.77,39.37)
  BOTTOM w0.102: v2(205.2,42.22) 205.09,42.1 U1.77 205.09,39.69 v1(204.77,39.37)
EC_GPG2: length 5.1
  BOTTOM w0.102: U1.100 215.66,37.94 216.28,38.55 216.28,39.64 216.51,39.87 216.53,39.87 216.54,39.88 216.63,39.88 v2(216.94,40.19) 216.95,40.19 R324.2
EC_GPJ0: length 267.9
  L5 w0.102: v1(204.44,43.22) 204.35,43.13 194.38,43.13 v1(193.79,42.55) 191.43,44.91 168.33,44.91 167.31,45.93 152.24,45.93 149.96,43.64 146.68,43.64 146.43,43.39 142.19,43.39 141.36,44.21 139.28,44.21 137.69,45.8 133.27,45.8 133.25,45.83 128.01,45.83 127.02,44.83 125.42,44.83 124.43,45.83 120.37,45.83 119.78,46.41 102.84,46.41 102.78,46.47 89.41,46.47 85.67,50.22 71.81,50.22 68.38,53.65 68.38,57.93 66.98,59.34 66.98,72.86 67.26,73.14 67.26,79.12 68.38,80.24 69.27,80.24 71.17,82.14 71.17,88.45 71.95,89.24 71.95,94.03 70.71,95.28 70.71,110.62 71.24,111.16 71.24,112.58 77.39,118.73 77.39,119.38 77.39,119.38 77.39,127.11 79.55,129.28 79.55,138.09 82.7,141.23 82.7,154.07 v1(80.53,156.25)
  BOTTOM w0.102: R344.2 205.04,43.29 204.5,43.29 v1(204.44,43.22) 204.35,43.13 204.35,42 204.69,41.67 U1.76 ; v1(80.53,156.25) 80.53,156.91 v2(77.76,159.67) 76.43,161 CN253.2 ; C302.2 v1(193.79,42.55)
EC_PECI: length 4
  BOTTOM w0.109: C314.1 R300.1 216.74,30.92 216.63,31.02 215.93,31.02 v2(215.8,30.89) 215.66,31.02 215.11,31.02 215.09,31.04 214.38,31.04 U1.117
EC_PWRBTN#: length 120
  L3 w0.102: v1(108.61,33.86) 109.37,33.1 125.98,33.1 128.93,30.15 136.5,30.15 137.28,30.93 153.82,30.93 154.46,31.56 158.25,31.56 160.75,29.06 173.53,29.06 174.83,30.37 175.82,30.37 176.54,31.09 177.55,31.09 179.11,32.65 193.8,32.65 194.48,33.33 196.68,33.33 196.75,33.27 210.12,33.27 211.45,34.6 219.2,34.6 v1(219.63,35.03)
  BOTTOM w0.102: v1(108.61,33.86) 108.23,34.24 R254.1 ; R333.2 218.15,35.85 218.97,35.85 219.63,35.18 219.63,35.03 v1(219.63,35.03)
EC_RST#: length 20.6
  L8 w0.102: v1(205.97,30.08) 205.97,29.82 205.22,29.08 200.06,29.08 200.03,29.1 199.53,29.1 199.51,29.08 198.38,29.08 198.15,28.85 197.02,28.85 196.67,28.5 v1(196.67,28.32)
  BOTTOM w0.102: v1(205.97,30.08) 207.13,28.91 207.13,26.5 207.49,26.14 U1.14 ; v1(196.67,28.32) 196.59,28.4 v2(195.86,28.4) 195.48,28.02 194.92,28.02 C63.2 R321.2 193.64,27.02 D300.1
EC_RTC_RESET: length 39.8
  L5 w0.102: v1(245.97,30.84) 245.06,29.92 243.89,29.92 243.33,29.37 235.87,29.37 235.42,28.92 225.51,28.92 222.96,31.47 217.9,31.47 v1(217.8,31.58)
  BOTTOM w0.102: 246.2,31.25 246.2,31.07 v1(245.97,30.84) 245.97,30.61 246.2,30.38 Q300.2 246.2,28.96 v2(246.3,28.86) 246.4,28.76 R7031.2 ; 246.2,31.25 Q300.5 ; 246.2,31.25 247.24,31.25 247.54,30.94 R7032.1 ; v1(217.8,31.58) 216.64,32.73 U1.113
EC_SCI#: length 57.7
  L10 w0.102: v1(203.02,30.89) 203.02,31.17 204.06,32.21 219.78,32.21 220.13,31.86 224.86,31.86 225.19,32.19 232.35,32.19 232.52,32.02 237.17,32.02 242.9,37.75 242.9,38.03 v1(244.14,39.27)
  BOTTOM w0.089: U4710.U47 245.87,42.1 245.87,41.02 244.14,39.3 v1(244.14,39.27)
  BOTTOM w0.102: v1(203.02,30.89) 203.02,29.21 202.66,28.86 202.66,26.98 203.45,26.19 203.59,26.19 203.89,25.9 U1.23 203.89,24.1 203.7,23.92 R318.2
EC_SMB1_CLK: length 216.6
  TOP w0.109: R361.2 216.2,32.14 216.35,31.99 v1(216.35,31.58) ; R6050.1 28.8,30.71 v3(29.41,31.32)
  L3 w0.076: v1(216.35,31.58) 215.3,32.63 196.72,32.63 196.49,32.86 194.68,32.86 194,32.18 179.3,32.18 177.75,30.62 176.74,30.62 176.02,29.9 175.03,29.9 173.24,28.11 161.1,28.11 160.61,28.59 160.56,28.59 158.06,31.09 154.65,31.09 154.02,30.46 137.47,30.46 136.7,29.68 128.73,29.68 126.22,32.2 68.21,32.2 61.41,39 61.41,45.19 v1(57.71,48.9)
  L5 w0.076: v1(57.71,48.9) 56.66,47.86 55.11,47.86 50.14,42.89 48.67,42.89 38.3,32.52 30.6,32.52 v3(29.41,31.32)
  BOTTOM w0.109: U60000.12 56.93,47.76 56.93,48.2 57.63,48.9 v1(57.71,48.9) ; U1.115 214.81,31.93 214.89,32.02 215.39,32.02 215.41,32.04 215.9,32.04 216.35,31.59 v1(216.35,31.58)
EC_SMB1_DATA: length 211.4
  TOP w0.109: R362.2 215.29,31.88 v3(215.62,31.55) ; R6051.1 30.65,34.19 v1(31.42,34.95)
  L3 w0.076: v1(56.87,48.92) 60.96,44.83 60.96,38.81 67.76,32.01 67.76,32.01 68.02,31.74 117.79,31.74 118.56,30.97 126.8,30.97 128.54,29.23 136.89,29.23 137.66,30 154.21,30 154.3,30.09 158.41,30.09 160.85,27.65 174.51,27.65 177.02,30.17 177.94,30.17 179.49,31.72 194.7,31.72 195.38,32.4 196.3,32.4 196.53,32.17 214.99,32.17 v3(215.62,31.55)
  L5 w0.076: v1(31.42,34.95) 32.2,34.17 39.3,34.17 48.48,43.35 49.96,43.35 54.92,48.31 56.26,48.31 v1(56.87,48.92)
  BOTTOM w0.109: v1(56.87,48.92) 56.44,48.5 56.44,47.75 U60000.11 ; v3(215.62,31.55) 215.6,31.53 214.83,31.53 214.83,31.53 U1.116
EC_SMBCLK0: length 85.7
  L3 w0.076: v1(215.59,45.23) 214.13,46.7 156.03,46.7 153.2,43.86 144.41,43.86 144.08,44.19 138.87,44.19 138.17,44.89 134.45,44.89 v1(134.26,45.08)
  BOTTOM w0.109: v1(134.26,45.08) 134.82,45.64 Q51530.3 ; R305.1 v1(215.59,45.23)
EC_SMBDATA0: length 85
  L3 w0.076: v1(137.46,44.25) 137.82,44.25 138.67,43.4 153.39,43.4 156.22,46.24 212.99,46.24 214.6,44.63 217.67,44.63 v1(218.27,45.23)
  BOTTOM w0.109: R303.1 218.26,45.22 v1(218.27,45.23) ; Q51530.6 137.07,44.64 v1(137.46,44.25)
EC_SMI#: length 56
  L10 w0.102: v1(243.48,37.82) 237.47,31.81 232.43,31.81 232.26,31.98 225.28,31.98 224.95,31.65 220.05,31.65 219.7,32.01 207.29,32.01 v3(206.45,31.17)
  BOTTOM w0.089: U4710.T48 244.73,41.87 244.47,41.61 244.47,41.43 244.23,41.19 244.23,41.11 243.42,40.3 243.42,39.09
  BOTTOM w0.102: R319.2 207.09,23.89 U1.15 207.09,26.26 206.93,26.41 206.93,28.6 206.08,29.44 205.91,29.44 205.51,29.85 205.51,30.23 v3(206.45,31.17) ; 243.42,39.09 243.4,39.08 243.4,37.9 v1(243.48,37.82) 243.2,37.54 243.2,37.34 R4699.1
EDP_AUX_DN: length 192.6
  L10 w0.084: v3(42.59,59.69) 42.59,59.53 42.71,59.42 42.93,59.42 44.89,61.38 72.17,61.38 72.95,62.15 80.16,62.15 80.51,62.51 80.51,71.29 83.87,74.65 145.88,74.65 147.12,75.9 147.12,85.64 143.79,88.98 143.79,89.7 136.8,96.68 136.8,109.22 129.33,116.7 129.33,117.69 126.28,120.74 126.28,134.64 127.2,135.56 127.77,135.56 128.14,135.94 128.14,136.55 128.01,136.68 v1(127.83,136.68)
  BOTTOM w0.076: v1(127.83,136.68) 127.99,136.68 128.17,136.5 128.17,136.36 127.68,135.87 126.06,135.87 125.91,136.01 125.91,136.11 126.02,136.21 126.13,136.21 U4555.B26
  BOTTOM w0.107: C3019.2 42.75,60.53 43.09,60.19 43.09,59.66 42.93,59.5 42.78,59.5 v3(42.59,59.69)
EDP_AUX_DP: length 192.7
  L10 w0.084: v1(128.55,136.48) 128.35,136.28 128.35,135.85 127.85,135.35 127.29,135.35 126.49,134.55 126.49,120.82 129.54,117.78 129.54,116.79 137.01,109.31 137.01,96.77 144,89.78 144,89.07 147.33,85.73 147.33,75.81 145.96,74.44 83.95,74.44 80.72,71.21 80.72,62.42 80.24,61.94 73.03,61.94 72.26,61.17 44.97,61.17 43.06,59.26 v1(42.64,58.93)
  BOTTOM w0.076: U4555.C26 125.99,135.7 127.75,135.7 128.52,136.48 v1(128.55,136.48)
  BOTTOM w0.107: C3020.2 43.3,59.57 42.66,58.93 v1(42.64,58.93)
EDP_BKLTEN: length 11.3
  BOTTOM w0.102: CN5.20 35.95,64.4 36.79,63.55 v2(36.98,63.55) 38.68,61.85 39.68,61.85 D3000.2 39.78,61.63 39.39,61.24 R3008.2 38.7,60.41 38.7,60.4 C3007.1 38.7,59.66 38.7,59.52 38.7,59.52 R3013.2 38.7,59.05 38.25,58.61 R3014.1
EDP_HPD: length 248.3
  TOP w0.089: v2(252.28,64.19) R4858.2
  TOP w0.102: R4858.2 252.45,63.21 252.45,62.59 252.2,62.35 252,62.35 v1(251.72,62.07)
  L8 w0.102: v1(35.05,65) 35.47,65.42 46.01,65.42 47.24,64.19 52.12,64.19 64.4,51.91 99.95,51.91 107.07,44.78 111.08,44.78 114.84,41.02 121.67,41.02 128.2,34.49 133.02,34.49 133.8,33.71 145.34,33.71 146.01,34.38 167.31,34.38 167.87,34.94 170.39,34.94 171.18,35.73 175.77,35.73 185.85,45.81 215.39,45.81 218.07,45.81 220.58,48.31 233.04,48.31 235.15,50.42 236.83,50.42 237.87,51.46 237.87,53.72 240.62,56.47 241.51,56.47 243.44,58.4 245.6,58.4 247.94,60.74 249.1,60.74 250.43,62.07 v1(251.72,62.07)
  BOTTOM w0.089: v1(251.72,62.07) 251.79,62.13 252.73,62.13 U4710.AN6
  BOTTOM w0.102: v1(35.05,65) 34.95,65.1 CN5.22
EDP_PWM: length 6.2
  BOTTOM w0.102: CN5.21 35.45,65.23 35.58,65.1 v2(35.58,63.94) 35.84,63.94 36.99,62.78 R3006.1 C3008.1 36.99,60.69 R3005.2
EDP_TX0_DN: length 206.1
  L10 w0.084: v3(45.21,58.68) 45.35,58.82 46.09,58.82 47.17,57.74 53.6,57.74 54.43,58.57 80.26,58.57 83.12,61.42 83.12,66.64 85.67,69.19 147.22,69.19 152.31,74.29 152.31,85.38 149.4,88.29 149.4,94.31 139.41,104.3 139.41,110.33 138.02,111.72 138.02,117.38 140.47,119.83 140.47,135.91 137.46,138.92 124.54,138.92 v1(124.53,138.92)
  BOTTOM w0.076: U4555.E29 v1(124.53,138.92)
  BOTTOM w0.107: v3(45.21,58.68) 45.01,58.88 44.77,58.88 44.41,59.24 C3014.2
EDP_TX0_DP: length 206
  L10 w0.084: v1(45.21,59.34) 45.21,59.24 45.42,59.03 46.17,59.03 47.25,57.95 53.51,57.95 54.34,58.78 80.18,58.78 82.9,61.51 82.9,66.73 85.58,69.4 147.13,69.4 152.1,74.38 152.1,85.29 149.19,88.21 149.19,94.23 139.2,104.22 139.2,110.24 137.81,111.63 137.81,117.46 140.26,119.92 140.26,135.82 137.37,138.71 124.87,138.71 124.49,138.33 124.49,138.17 v1(124.53,138.13)
  BOTTOM w0.076: v1(124.53,138.13) 124.47,138.2 124.47,138.35 124.66,138.54 U4555.D29
  BOTTOM w0.107: v1(45.21,59.34) 44.95,59.08 44.85,59.08 44.61,59.32 44.61,60.13 C3013.2
EDP_TX1_DN: length 202.6
  L10 w0.084: v1(124.53,137.34) 129.86,137.34 129.91,137.39 132.28,137.39 132.7,136.97 133.68,136.97 134.82,138.1 137.33,138.1 139.87,135.56 139.87,120.81 137.16,118.09 137.16,111.73 138.81,110.08 138.81,101.04 148.59,91.26 148.59,88.22 151.41,85.41 151.41,74.63 150.56,73.78 149.73,73.78 145.81,69.86 85.36,69.86 82.52,67.02 82.52,61.67 80.99,60.14 79.99,60.14 79.99,60.14 78.84,60.14 77.94,59.25 54.25,59.25 53.43,58.43 47.54,58.43 46.21,59.76 46.21,60.03 v3(46.02,60.22)
  BOTTOM w0.076: v1(124.53,137.34) 124.21,137.66 U4555.E28
  BOTTOM w0.107: v3(46.02,60.22) 46.24,60.44 46.24,60.75 C3016.2
EDP_TX1_DP: length 202.5
  L10 w0.084: v1(46.68,60.22) 46.42,59.96 46.42,59.85 47.63,58.64 53.35,58.64 54.16,59.46 77.85,59.46 78.75,60.36 80.08,60.36 80.9,60.35 82.31,61.76 82.31,67.11 85.27,70.07 145.73,70.07 149.64,73.99 150.47,73.99 151.2,74.72 151.2,85.32 148.38,88.13 148.38,91.17 138.6,100.95 138.6,109.99 136.95,111.64 136.95,118.18 139.66,120.89 139.66,135.47 137.24,137.89 134.91,137.89 133.77,136.76 132.62,136.76 132.19,137.18 129.99,137.18 129.95,137.13 125.16,137.13 124.99,136.96 124.37,136.96 124.26,136.96 v1(123.88,137.34)
  BOTTOM w0.076: v1(123.88,137.34) 123.88,137.46 123.59,137.75 U4555.F28
  BOTTOM w0.107: v1(46.68,60.22) 46.45,60.44 46.45,60.74 C3017.2
EDP_TX2_DN: length 190.6
  L10 w0.084: v1(131.88,136.69) 131.59,136.41 131.59,123.9 133.68,121.82 133.68,114.36 138.21,109.83 138.21,97.76 150.41,85.56 150.41,76.84 149.3,75.74 149.3,74.2 145.56,70.46 85.11,70.46 81.92,67.27 81.92,61.92 80.74,60.74 80.24,60.74 73.53,60.74 72.63,59.85 53.39,59.85 52.57,59.03 48.44,59.03 47.82,59.65 47.82,60.06 v3(47.65,60.23)
  BOTTOM w0.076: U4555.B29 126.32,138.7 126.32,138.81 126.6,139.08 127.56,139.08 127.8,138.84 130.08,138.84 130.48,138.43 130.51,138.43 130.53,138.42
  BOTTOM w0.107: 130.53,138.42 131.7,137.24 131.7,136.87 v1(131.88,136.69) ; C3027.2 47.7,60.87 47.7,60.27 v3(47.65,60.23)
EDP_TX2_DP: length 190.6
  L10 w0.084: v1(131.22,136.69) 131.4,136.51 131.38,136.5 131.38,123.82 133.47,121.73 133.47,114.28 138,109.74 138,97.67 150.19,85.47 150.19,76.93 149.09,75.82 149.09,74.28 145.48,70.67 85.02,70.67 81.71,67.36 81.71,62.01 80.65,60.95 80.33,60.95 73.44,60.95 72.55,60.06 53.3,60.06 52.48,59.24 48.53,59.24 48.03,59.74 48.03,60.04 48.22,60.23 v1(48.31,60.23)
  BOTTOM w0.076: 130.38,138.27 130.37,138.28 130.37,138.32 130.01,138.67 127.73,138.67 127.49,138.92 126.67,138.92 126.49,138.74 126.49,138.38 126.56,138.31 126.74,138.31 126.81,138.38 U4555.A29
  BOTTOM w0.107: C3026.2 48.12,60.94 47.9,60.72 47.9,60.55 48.23,60.23 v1(48.31,60.23) ; 130.38,138.27 131.49,137.16 131.49,136.83 131.36,136.69 v1(131.22,136.69)
EDP_TX3_DN: length 190.5
  L10 w0.084: v3(49.55,60.61) 49.78,60.38 49.78,60.07 50.23,59.63 52.32,59.63 53.14,60.45 72.38,60.45 73.28,61.34 80.49,61.34 81.32,62.17 81.32,70.96 84.2,73.84 146.56,73.84 149.81,77.09 149.81,84.13 144.6,89.34 144.6,90.07 137.61,97.05 137.61,109.58 133.04,114.15 133.04,118.74 129.33,122.46 127.85,122.46 127.06,123.26 127.06,127.04 128.76,128.74 128.76,134.2 129.98,135.43 129.98,136.45 130.2,136.67 v1(130.2,136.68)
  BOTTOM w0.076: U4555.B28 126.04,137.75 125.97,137.68 125.97,137.53 126.04,137.46 129.68,137.46 129.94,137.2 129.94,136.94 v1(130.2,136.68)
  BOTTOM w0.107: v3(49.55,60.61) C3029.2
EDP_TX3_DP: length 190.4
  L10 w0.084: v1(129.55,136.67) 129.77,136.45 129.77,135.51 128.55,134.29 128.55,128.83 126.84,127.13 126.84,123.17 127.77,122.25 129.24,122.25 132.83,118.65 132.83,114.06 137.4,109.49 137.4,96.97 144.39,89.98 144.39,89.25 149.6,84.04 149.6,77.18 146.47,74.05 84.12,74.05 81.11,71.05 81.11,62.26 80.4,61.55 73.19,61.55 72.3,60.66 53.05,60.66 52.23,59.84 50.32,59.84 49.99,60.16 49.99,60.49 50.11,60.61 v1(50.21,60.61)
  BOTTOM w0.076: v1(129.55,136.67) 129.78,136.89 129.78,137.13 129.61,137.29 125.97,137.29 125.8,137.46 125.8,137.68 125.72,137.75 U4555.C28
  BOTTOM w0.107: v1(50.21,60.61) 50.14,60.61 49.76,60.99 49.76,61.23 50.08,61.55 C3028.2
EN_1V0S_DGPU: length 223.1
  L3 w0.102: v1(204.95,169.55) 204.75,169.35 200.83,169.35 199.79,168.3 195.35,168.3 194.1,169.55 193.11,169.55 190.65,172.01 190.65,177.14 189.2,178.59 155.67,178.59 150.01,172.93 150.01,170.87 v1(149.93,170.79)
  L8 w0.102: v1(149.93,170.79) 149.93,170.69 147.7,168.46 146.63,168.46 145.82,167.64 145.82,164.47 143.65,162.3 143.65,160.41 142.01,158.77 142.01,154.41 138.35,150.75 138.35,146.66 139.98,145.04 139.98,140.14 140.37,139.74 140.37,125.16 140.76,124.77 140.76,119.35 138.4,116.99 138.4,113.34 141.55,110.19 141.55,108.47 142.48,107.55 142.48,100.27 140.03,97.82 140.03,91.32 140.05,91.29 140.05,72.34 139.14,71.43 139.14,71.38 139.14,71.38 139.14,71.04 139.14,71.04 139.14,70.48 139.09,70.43 139.09,63.48 134.62,59.01 129.69,59.01 128.11,57.43 126.72,57.43 124.28,54.99 ; v1(119.15,55.02) 120.16,55.02 120.18,55 124.27,55 124.28,54.99 ; 124.28,54.99 v1(124.28,50.45)
  BOTTOM w0.102: v1(119.15,55.02) 118.82,55.35 TP53582.1 117.8,55.55 C53582.1 116.47,55.84 D53581.1 117.34,56.71 117.5,56.55 R53581.2 ; v1(124.28,50.45) 124.77,49.96 U53590.1 ; TP67601.1 151.1,172.24 150.69,171.83 U67600.5 150.16,171.02 v1(149.93,170.79) ; R55221.1 v1(204.95,169.55)
EN_1V05A: length 55.7
  L8 w0.102: v1(220.44,39.86) 220.27,40.03 216.2,40.03 215.92,39.75 215.92,38.71 215.08,37.87 213.13,37.87 211.81,36.55 197.35,36.55 196.77,35.97 193.22,35.97 188.16,30.91 v1(188.16,29.57)
  BOTTOM w0.102: v1(220.44,39.86) 220.44,41.79 219.5,42.73 219.5,49.25 TP60901.1 ; v1(188.16,29.57) C139.1 188.16,28.41 188.17,28.4 R7003.2 188.95,27.16 188.95,25.2 188.48,24.73 D7005.1
  BOTTOM w0.254: TP60901.1 220.26,49.36 221.07,50.17 U60900.11
EN_1V8: length 12
  TOP w0.102: v1(209.88,20.55) 210.05,20.38 R148.2 210.07,19.89 210.8,19.89 R7002.2 210.74,20 210.74,20.82 210.42,21.14 C138.1 ; U60600.1 216.66,21.03 216.56,20.93 v1(216.56,20.88) 216.56,20.78 TP60601.1
  L5 w0.102: v1(216.56,20.88) 216.13,20.45 209.98,20.45 v1(209.88,20.55)
EN_1V8S_DGPU: length 210.5
  TOP w0.102: TP67401.1 195.23,173.93 v1(195.53,173.93) U67400.11
  L5 w0.102: v1(195.53,173.93) 195.53,175.87 192.12,179.28 156.13,179.28 149.17,172.32 v1(149.17,171.3)
  L8 w0.102: v1(149.17,171.3) 147.9,171.3 146.3,169.7 146.3,168.81 145.41,167.92 145.41,164.68 143.24,162.51 143.24,160.58 141.12,158.46 141.12,154.1 137.94,150.92 137.94,146.49 139.57,144.87 139.57,139.97 139.96,139.57 139.96,124.95 140.36,124.55 140.36,119.52 137.74,116.9 137.74,112.37 140.53,109.58 140.53,108.57 140.53,108.4 142.07,106.87 142.07,101.73 141.49,101.15 140.81,101.15 139.71,100.04 139.71,72.48 137.87,70.65 137.87,66.9 138.07,66.69 138.07,63.87 133.41,59.21 129.6,59.21 128.26,57.86 125.93,57.86 123.9,55.83 117.8,55.83 114.53,52.56 v1(114.53,51.26)
  BOTTOM w0.102: R53500.2 109.91,51.31 C53501.2 110.49,51.14 R53501.2 111.32,51.67 TP53501.1 112.57,50.8 TP53502.1 113.08,51.26 v1(114.53,51.26)
EN_1V8S_R_DGPU: length 4.1
  BOTTOM w0.102: U53500.4 108.15,48.67 108.66,49.18 108.66,50.4 108.23,50.82 R53500.1 v2(107.44,51.31)
EN_2V5: length 24
  BOTTOM w0.102: TP60401.1 76.21,61.25 U60400.1 77,60.21 77.58,59.63 78.34,59.63 78.84,60.13 80.62,60.13 82.01,58.73 93.68,58.73 R7027.2 95.1,57.43 C7033.1 95.91,56.55 R7040.2
EN_3A5A: length 33.7
  TOP w0.102: v1(217.95,29.34) 218.18,29.57 R7012.1
  L8 w0.102: v1(217.95,29.34) 217.55,29.75 216.59,29.75 216.57,29.72 215.08,29.72 214.17,30.64 208.18,30.64 207.18,31.63 198.73,31.63 198.19,31.08 191.49,31.08 v1(191.25,31.32)
  BOTTOM w0.102: R7033.2 R6988.2 v1(191.25,31.32) ; R7033.2 R7013.1 ; R7033.2 190.67,29.96 190.67,29.95 190.67,29.56 190.64,29.54 C7006.1 R6987.2
EN_3V: length 5.3
  TOP w0.102: U60100.11 193.28,26.88 192.34,27.82 R60110.2 192.34,28.85 v1(192.86,29.37) 193.32,29.82 TP60101.1
  BOTTOM w0.102: R6987.1 192.58,29.09 v1(192.86,29.37)
EN_5V: length 72.6
  TOP w0.102: TP60201.1 241.37,20.95 R60204.1 ; R60204.1 241.89,20.55 242.54,20.55 242.87,20.88 242.87,21.01 243.28,21.42 243.48,21.42 244.44,22.37 U60200.12 ; R60204.1 241.4,21.03 v1(240.61,21.03) 240.61,20.2 R60205.2
  L8 w0.102: v1(189.15,31.32) 189.56,31.73 194.35,31.73 194.8,31.28 198.1,31.28 198.65,31.83 207.36,31.83 208.35,30.84 214.37,30.84 215.16,30.05 217.86,30.05 223.74,24.17 230.18,24.17 230.37,24.36 242.57,24.36 243.18,23.75 243.18,22.63 241.63,21.09 240.74,21.09 240.69,21.03 v1(240.61,21.03)
  BOTTOM w0.102: R6900.2 R6980.2 189.71,31.43 R6988.1 v1(189.15,31.32)
EN_5V0: length 169.7
  L5 w0.102: v1(62.99,77.3) 61.46,75.77 60.03,75.77 58.54,74.29 58.54,65.94 64.51,59.97 64.51,55.62 71.72,48.42 74.8,48.42 84.48,38.74 103.76,38.74 104.59,39.58 113.36,39.58 114.57,38.36 138.22,38.36 139.09,37.49 160.6,37.49 160.77,37.49 162.6,35.67 166.17,35.67 167.78,37.27 168.45,37.27 183.51,37.27 183.51,37.27 186.56,37.27 v1(187.5,38.21)
  BOTTOM w0.102: v1(187.5,38.21) 187.5,37.19 189.76,34.93 189.76,33.12 R6980.1
  BOTTOM w0.254: U60250.12 62.07,77.55 62.12,77.5 62.12,77.5 62.27,77.35 62.27,77.35 62.33,77.3 v1(62.99,77.3) 62.99,77.07 63.69,76.36 R60254.1 63.8,76.36 64.36,75.8 TP60251.1
EN_NVVDD: length 3.1
  BOTTOM w0.102: U53570.2 U53570.1 121.29,55.9 v2(121.15,56.04) R53573.2
EN_PEXVDD: length 3.9
  BOTTOM w0.102: R53584.2 122.46,58.3 U53580.2 ; R53584.2 R53583.2 ; R53584.2 122.96,59.59 v2(122.79,59.76)
EN_PEXVDD_AND: length 6.3
  BOTTOM w0.102: D53581.3 115.52,58.66 116.42,57.75 R53581.1 118.19,57.65 U53580.4 119.34,56.76 v2(119.15,56.57) 119.13,56.55 R53580.1
EN_PVCORE: length 161.5
  L3 w0.102: v1(59.92,67.47) 59,67.47 49.91,58.37 49.91,48.53 52.3,46.15 52.3,40.31 58.98,33.63 v1(58.98,33.3)
  L5 w0.102: v1(82.34,159.85) 79.96,159.85 79.07,158.96 79.07,156.95 79.57,156.45 79.57,153.12 81.91,150.78 81.91,141.56 78.77,138.42 78.77,129.6 76.6,127.44 76.6,119.06 70.46,112.91 70.46,111.49 69.92,110.95 69.92,94.95 71.17,93.7 71.17,89.65 69.66,88.14 69.66,81.74 68.95,81.03 68.05,81.03 66.47,79.45 66.47,73.93 60.01,67.47 v1(59.92,67.47)
  BOTTOM w0.102: D7002.1 57.82,34.28 58.17,33.94 R7004.2 R7007.2 59.25,33.02 v1(58.98,33.3) ; v1(59.92,67.47) 60.02,67.47 61.31,68.76 64.64,68.76 65,69.12 Q4751.5 ; R66000.1 81.83,160.25 82.23,159.85 v1(82.34,159.85)
EN_VCCIO: length 20.5
  L8 w0.102: v1(67.48,99.5) 67.89,99.9 67.89,100.77 66.29,102.37 66.29,106.02 67.08,106.81 67.08,107.78 67.71,108.41 v1(68.68,108.41)
  BOTTOM w0.102: TP60501.1 68.02,109.53 R60523.1 68.51,108.57 v1(68.68,108.41) 68.68,107.88 68.75,107.81 U60500.5 ; C7036.1 71.09,98.6 R7054.2 70.14,98.6 D7004.1 68.13,98.41 67.48,99.06 v1(67.48,99.5)
EN_VDDQ: length 43.6
  L8 w0.102: v1(66.42,84.15) 65.86,83.59 64.73,83.59 63.8,82.66 63.8,81.54 63.78,81.51 63.78,80.54 63.78,65.18 70.28,58.68 75.31,58.68 76.04,57.94 v1(76.04,57.23)
  BOTTOM w0.102: U60300.15 69.28,83.33 68.4,84.2 67.64,84.2 TP60301.1 66.93,84.66 v1(66.42,84.15) ; R7041.2 C7000.1 76.04,56.16 v1(76.04,57.23) 76.56,57.23 R7042.2
EN_VRAM_DGPU: length 312.2
  TOP w0.102: R55231.1 202,167.8 v1(202.11,167.8)
  L5 w0.102: v1(194.61,161.12) 194.61,160.12 197.15,157.58 197.15,100.73 205.31,92.58 205.31,92.12 205.3,88.98 210.52,83.76 230.45,83.76 233.32,80.89 233.32,78.85 233.88,78.29 235.68,78.29 236.29,77.68 236.29,75.95 238.55,73.69 239.34,73.69 240.07,74.41 241.46,74.41 243.76,76.71 246.58,76.71 v1(246.81,76.94)
  L8 w0.102: v1(194.61,161.12) 195.09,161.12 201.77,167.8 v1(202.11,167.8) ; v1(248.92,73.33) 248.13,72.55 248.13,70.94 247.27,70.08 236.61,70.08 231.5,64.98 231.22,64.98 222.95,64.98 219.35,61.38 219.35,58.95 217.45,57.04 217.45,51.07 216.35,49.97 187.58,49.97 181.38,49.97 176.22,44.81 168.61,44.81 166.6,42.8 159.85,42.8 157.28,40.24 157.11,40.24 153.61,40.24 153.2,40.64 135.06,40.64 134.4,39.98 129.76,39.98 123.28,46.46 v1(122.65,46.46)
  BOTTOM w0.102: v1(122.65,46.46) 122.42,46.46 TP53592.1 121.72,47.16 C53592.2 120.25,47.46 R53591.2 ; TP67201.1 237.18,81.46 237.69,80.95 R67211.1 238.58,81.16 238.86,81.16 239.06,81.36 239.62,81.36 240.28,82.02 246.48,82.02 247.16,81.33 247.16,77.3 v1(246.81,76.94) 248.13,75.62 248.13,74.12 v1(248.92,73.33)
EN_VTT: length 18.6
  L5 w0.102: v1(65.35,73.38) 66.27,74.3 66.27,79.53 67.97,81.23 68.86,81.23 69.33,81.7 69.33,84.19 v1(69.03,84.48)
  BOTTOM w0.102: U60300.16 69.59,83.83 69.03,84.38 v1(69.03,84.48) 68.86,84.66 68.78,84.66 68.46,84.99 TP60351.1 ; v1(65.35,73.38) 65.78,73.81 R7001.2 C7015.1 66.52,73.15 66.65,73.02 D7000.1
ESPI_LPC#: length 6.5
  BOTTOM w0.089: 262.51,56.62 v2(262.48,56.62) 261.85,55.99 261.85,55.16 260.72,54.04 260.34,54.04 260.28,53.98 259.72,53.98 U4710.BF24
  BOTTOM w0.102: R4703.1 R4702.1 262.73,56.39 262.51,56.62
ESPI_RST#: length 7.4
  BOTTOM w0.089: U4710.BF38 259.94,46.92 260.14,46.71 260.91,46.71 261.46,47.27 262.51,47.27
  BOTTOM w0.102: 262.51,47.27 262.63,47.27 v2(263.29,47.93) 263.34,47.98 R4897.1 264.77,47.48 265.78,47.48 R4902.1
EVENT_PCH#: length 16.5
  TOP w0.102: v1(245.64,42.97) 245.02,42.36 245.02,35.41 R4921.2 242.99,33.38 v2(238.86,33.38) 238.8,33.38 R4822.2
  BOTTOM w0.089: v1(245.64,42.97) 245.28,43.33 U4710.T45
FAN1_PWM: length 184.7
  L3 w0.102: v1(63.9,57.23) 63.9,56.42 66.62,53.7 66.62,50.12 68.47,48.26 68.47,40.84 71.06,38.26 72.72,38.26 76.2,34.78 98.39,34.78 98.82,35.21 104.99,35.21 105.41,35.63 105.83,35.63 133.23,35.63 134.13,34.73 147.39,34.73 147.92,35.26 158.7,35.26 160.35,33.61 168.8,33.61 169.08,33.33 174.58,33.33 176.64,35.39 188.85,35.39 190.25,36.79 195.6,36.79 195.84,37.03 195.84,37.36 196.07,37.6 204.24,37.6 v1(204.62,37.21)
  BOTTOM w0.102: v1(63.9,57.23) 62.67,58.47 R4301.2 60.93,58.47 C4301.1 60.68,58.22 TP4302.1 59.89,59.36 59.2,60.05 57.6,60.05 57.33,59.77 CN4300.3 ; v1(204.62,37.21) 203.45,36.05 203.45,33.3 201.44,31.3 201.44,30.15 200.96,29.67 200.96,28.71 201.27,28.4 201.27,26.95 201.09,26.77 U1.30
FAN1_TACH: length 179.1
  L3 w0.102: v1(63.24,57.26) 63.24,56.65 66.32,53.58 66.32,49.99 68.17,48.14 68.17,40.72 74.18,34.71 75.83,34.71 76.07,34.47 98.52,34.47 98.95,34.9 105.12,34.9 105.54,35.32 133.1,35.32 134.01,34.42 147.51,34.42 148.05,34.95 158.49,34.95 160.68,32.77 164.46,32.77 165,33.3 168.67,33.3 168.95,33.02 174.49,33.02 174.71,33.02 176.76,35.08 188.97,35.08 190.37,36.48 196.19,36.48 196.9,37.19 v1(203.86,37.19)
  BOTTOM w0.102: v1(63.24,57.26) 61.98,55.99 R4300.2 61.82,55.99 C4305.1 60.93,55.99 57.27,55.99 v2(56.59,56.67) 56.07,57.18 CN4300.2 ; v1(203.86,37.19) 203.1,36.43 203.1,33.53 201.9,32.33 U1.47
FAN2_PWM: length 125.8
  TOP w0.102: v1(273.51,76.05) C4306.1 273.51,75.21 R4302.2
  L5 w0.102: v1(273.51,76.05) 273.96,75.6 273.96,52.99 269.82,48.85 268.26,48.85 264.87,45.46 264.87,44.49 260.27,39.89 258.05,39.89 257.35,39.2 246,39.2 243,36.2 238.66,36.2 237.94,36.91 232.81,36.91 231.49,35.59 221.69,35.59 220.72,34.62 219.07,34.62 218.89,34.8 217.14,34.8 216.61,35.33 206.7,35.33 206.12,35.92 205.13,35.92 v1(204.67,35.46)
  BOTTOM w0.102: U1.28 201.89,25.14 201.89,25.9 201.89,25.97 201.75,26.11 201.75,26.57 201.9,26.72 201.9,29.29 201.83,29.37 201.83,31.09 204.67,33.94 v1(204.67,35.46) ; TP4303.1 281.81,75.06 281.35,75.52 281.35,76.61 281.14,76.83 CN4301.3 274.28,76.83 v1(273.51,76.05)
FAN2_TACH: length 115
  TOP w0.102: v3(276.42,76.33) C4300.1 276.42,75.21 R4305.2
  L5 w0.102: v1(205.61,35.44) 206.21,34.84 216.65,34.84 216.99,34.5 218.77,34.5 218.95,34.32 220.85,34.32 221.81,35.28 231.62,35.28 232.94,36.6 237.82,36.6 238.53,35.89 243.13,35.89 246.12,38.89 257.47,38.89 258.17,39.59 260.78,39.59 266.98,45.78 266.98,47.14 267.8,47.96 270,47.96 271.17,49.13 271.17,49.51 274.27,52.61 274.27,75.67 274.93,76.33 v3(276.42,76.33)
  BOTTOM w0.102: CN4301.2 278.35,75.57 277.54,76.38 276.47,76.38 v3(276.42,76.33) ; v1(205.61,35.44) 205.61,36.4 205.79,36.58 205.79,39.75 205.89,39.85 U1.79
FB_PLLAVDD: length 25.2
  TOP w0.102: TP50300.1 180.02,123.7 179.85,123.87 v4(179.75,123.87)
  TOP w0.2: v4(164.55,141.13) 164.41,140.9 164.41,140.82 C50100.1 ; v4(179.75,123.87) 179.69,123.87 179.48,123.66 C50300.1 ; C50111.1 179.75,132.83 v4(179.86,132.72)
  TOP w0.254: C50200.1 179.52,138.35 v4(179.95,138.35) 179.95,139.05 C50102.1 ; C50100.1 164.2,140.61 163.84,140.61 163.65,140.41 TP50100.1 ; TP50400.1 175,120.1 v4(175,120.11) 175.03,120.13 C50400.1 ; C50110.1 170.06,141.29 C50101.1 170.1,141.71 v4(170.01,141.8)
  TOP w0.381: TP50200.1 189.61,160.01 v1(190.03,159.59) ; C50103.1 189.45,159.01 v1(190.03,159.59) ; v1(190.03,159.59) 190.77,159.59 L50100.2
  L6 w0.381: v4(170.01,141.8) 170.01,141.51 170.4,141.13 171.81,141.13 172.72,140.21 174.47,140.21 174.77,139.91 175.21,139.91 175.55,140.25 177.96,140.25 178.14,140.07 178.88,140.07 179.73,139.22 179.73,138.53 179.91,138.35 v4(179.95,138.35)
  BOTTOM w0.2: v4(179.75,123.87) 179.83,123.95 U50000.L17
  BOTTOM w0.25: U50000.V11 175,120.08 v4(175,120.11) ; v4(179.86,132.72) U50000.L29
  BOTTOM w0.3: v4(179.95,138.35) 179.98,138.38 179.98,138.46 U50000.L38 ; v4(170.01,141.8) U50000.AF42 ; v4(164.55,141.13) U50000.AN42
FBA1_VREFC: length 1.2
  TOP w0.4: v4(185.44,168.18) 185.67,167.95 R50510.2
  BOTTOM w0.305: U50500.K1 185.11,167.85 v4(185.44,168.18)
FBA2_VREFC: length 1.3
  TOP w0.305: R50610.2 158.63,168.25 v4(158.78,168.39)
  BOTTOM w0.3: U50600.K1 159.08,168.39 v4(158.78,168.39)
FBA_CLK0: length 32
  L10 w0.097: v4(169.28,143.27) 169.4,143.73 169.41,143.74 169.41,143.74 169.47,143.98 169.88,144.39 169.88,146.25 169.57,146.56 169.57,152.87 178.5,161.8 178.5,165.78 178.28,166 178.28,166.19 178.61,166.52 179.12,166.52 179.37,166.78 179.37,168.59 179.17,168.79 178.82,168.79 v4(178.65,168.97)
  BOTTOM w0.122: U50000.AG45 169,143.55 v4(169.28,143.27) ; U50500.J10 v4(178.65,168.97)
FBA_CLK0#: length 32
  L10 w0.097: v4(168.72,143.96) 168.72,143.81 168.85,143.68 169.03,143.68 169.18,143.79 169.2,143.88 169.23,143.98 169.24,143.99 169.25,144.01 169.25,144.08 169.65,144.49 169.65,146.16 169.34,146.47 169.34,152.97 178.27,161.9 178.27,165.69 178.06,165.91 178.06,166.28 178.52,166.75 179.02,166.75 179.15,166.87 179.15,168.5 179.08,168.57 178.75,168.57 178.65,168.47 v4(178.65,168.22)
  BOTTOM w0.122: U50500.K10 178.28,167.85 v4(178.65,168.22) ; U50000.AG46 168.75,143.96 v4(168.72,143.96)
FBA_CLK1: length 33.5
  L3 w0.097: v4(165.65,167.51) 165.65,167.73 165.77,167.85 165.91,167.85 166.89,166.87 167.45,166.87 168.08,167.5 170.7,167.5 170.93,167.27 170.93,165.84 169.84,164.75 169.84,159.82 166.84,156.82 166.84,149.44 166.99,149.29 166.99,146.66 166.66,146.33 166.66,145.67 166.6,145.61 166.6,144.44 166.72,144.32 166.72,144.11 v4(166.58,143.97)
  BOTTOM w0.122: v4(165.65,167.51) 165.69,167.47 166.3,167.47 166.42,167.59 166.42,167.74 166.31,167.85 U50600.J10 ; v4(166.58,143.97) 166.88,144.28 U50000.AK46
FBA_CLK1#: length 33.5
  L3 w0.097: v4(166.63,143.26) 166.63,143.27 166.63,143.29 166.94,143.82 166.94,144.41 166.82,144.54 166.82,145.52 166.88,145.58 166.88,146.24 167.21,146.57 167.21,149.39 167.07,149.53 167.07,156.73 170.07,159.73 170.07,164.66 171.16,165.75 171.16,167.36 170.79,167.73 167.98,167.73 167.35,167.09 166.98,167.09 166,168.07 165.79,168.07 v4(165.65,168.22)
  BOTTOM w0.122: v4(166.63,143.26) 166.63,143.31 U50000.AK45 ; v4(165.65,168.22) U50600.K10
FBA_CMD0: length 33
  L10 w0.086: v1(186.8,169.34) 186.75,169.55 185.79,170.11 183.57,170.11 v4(183.17,169.71)
  BOTTOM w0.137: v1(186.8,169.34) 188.52,166.28 188.52,164.45 187.62,161.36 186.94,160.18 179.18,152.42 175.52,150.42 174.24,149.14 174.24,148.33 173.89,147.8 U50000.Y51 ; v4(183.17,169.71) U50500.H3
FBA_CMD1: length 30.6
  L10 w0.086: v1(186.31,168.58) 186.29,168.6 184.28,168.6 v4(183.91,168.22)
  BOTTOM w0.109: U50500.K3 183.53,167.85 v4(183.91,168.22) 183.53,168.6 U50500.J3
  BOTTOM w0.137: v1(186.31,168.58) 188.14,166.18 188.14,164.58 187.27,161.63 187.04,161.22 186.67,160.46 186.64,160.41 180.54,154.31 179.63,154.31 178.8,153.49 175.59,150.91 173.9,149.22 U50000.Y52
FBA_CMD2_RST: length 30.2
  BOTTOM w0.137: U50500.J1 185.54,168.6 186.69,167.44 187.62,166.23 R50506.1 186.92,165.3 186.92,161.78 186.75,161.48 186.34,160.64 180.92,155.22 179.57,155.22 177.44,153.09 177.34,153.09 173.55,149.3 173.55,146.73 U50000.Y49
FBA_CMD3: length 33.2
  L10 w0.086: v1(186.59,166.06) 186.86,166.33 186.86,168.61 186.66,168.81 186.62,168.83 186.47,168.98 186.09,168.98 185.62,169.26 185.52,169.32 183.77,169.32 183.55,169.11 183.55,168.71 183.44,168.6 U50500.J4 182.41,168.22 v4(182.41,168.2)
  BOTTOM w0.109: U50500.K4 182.43,168.2 v4(182.41,168.2) 182.41,168.22 U50500.J4
  BOTTOM w0.137: U50000.AA52 173.2,149.71 177.43,153.94 177.76,153.94 181.33,157.51 181.63,157.51 182.6,157.51 186.09,161 186.37,161.57 186.37,165.84 v1(186.59,166.06)
FBA_CMD4: length 29.9
  L10 w0.086: v1(186.19,167.28) 186.19,167.33 185.71,167.82 183.5,167.82 v4(183.16,167.47)
  BOTTOM w0.137: v4(183.16,167.47) 183.53,167.1 U50500.L3 ; U50000.AA51 173.2,148.02 172.88,148.35 172.88,149.78 181.7,158.6 183.16,158.6 185.73,161.18 185.95,161.66 185.95,167.04 v1(186.19,167.28)
FBA_CMD5: length 24.6
  BOTTOM w0.137: U50000.AA50 173.2,147.29 172.85,147.64 172.85,147.98 172.62,148.21 172.62,150.12 181.15,158.65 181.15,158.72 181.16,158.73 181.16,159.66 181.45,159.94 181.45,161.07 181.43,161.09 181.43,161.18 181.23,161.39 181.22,163.35 181.1,163.48 181.1,165.69 181.3,165.89 181.81,165.89 181.88,165.96 182.39,165.96 U50500.M4
FBA_CMD6: length 26.5
  BOTTOM w0.109: U50500.K5 182.03,167.88 181.71,168.2 182.03,168.53 U50500.J5
  BOTTOM w0.137: U50000.AC50 171.8,147.26 172.15,147.61 172.15,147.93 172.38,148.16 172.38,150.41 179.93,157.96 179.93,158.98 181.07,160.13 181.07,161.07 180.82,161.32 180.82,166.48 181.03,166.69 181.03,166.91 181.58,167.47 181.58,168.08 181.71,168.2
FBA_CMD7: length 29.2
  L8 w0.076: v4(181.43,169.75) v4(181.12,168.16) 181.12,167.92 181.2,167.83 181.29,167.83 181.4,167.72 181.4,167.29 181.23,167.11 181.23,166.94 181.31,166.86 181.51,166.86 v4(181.56,166.91)
  BOTTOM w0.109: U50500.H5 181.72,169.35 181.43,169.64 v4(181.43,169.75) ; U50500.L5 181.77,167.1 181.58,166.91 v4(181.56,166.91)
  BOTTOM w0.137: U50000.AC51 171.8,147.92 172.12,148.24 172.12,148.34 172.12,148.35 172.12,148.61 172.12,148.62 172.12,150.69 178.72,157.29 178.72,158.36 180.69,160.33 180.69,160.99 180.57,161.12 180.57,166.84 180.67,166.94 180.67,167.71 v4(181.12,168.16)
FBA_CMD8: length 27.5
  BOTTOM w0.137: U50500.G4 182.41,170.47 181.54,170.47 180.67,169.6 180.67,169.02 180.41,168.76 180.41,167.27 180.24,167.1 180.24,161.09 180.32,161.01 180.32,160.66 177.44,157.78 177.44,156.57 171.81,150.94 171.81,148.49 U50000.AC52
FBA_CMD9: length 30.2
  BOTTOM w0.137: U50000.AC49 171.45,146.73 171.45,151.12 176.19,155.86 176.19,157.2 179.88,160.89 179.88,161.07 180,161.19 180,167.38 180.15,167.53 180.15,168.49 179.74,168.9 179.74,170.18 179.45,170.47 177.91,170.47 177.53,170.1 U50500.G11
FBA_CMD10_CKE: length 30.1
  TOP w0.137: R50505.1 179.73,167.73 v4(179.75,167.76)
  L8 w0.076: v4(179.01,166) 179.32,166 179.75,166.43 179.75,166.81 179.67,166.89 179.57,166.89 179.48,166.98 179.48,167.19 179.57,167.29 179.67,167.29 179.75,167.37 v4(179.75,167.76) 179.75,169 v4(178.77,169.98)
  BOTTOM w0.109: v4(179.01,166) 178.66,166.35 U50500.M10 ; v4(178.77,169.98) 178.65,170.1 U50500.G10
  BOTTOM w0.137: v4(179.75,167.76) 179.75,161.47 175.49,157.2 175.49,156.01 172.21,152.73 172.21,152.42 171.1,151.31 U50000.AD52
FBA_CMD11: length 28.2
  BOTTOM w0.109: U50500.L10 178.81,167.1 179.06,167.35 179.06,168.14 179.23,168.3 179.07,168.46 179.07,169.1 178.71,169.45 178.39,169.45 178.28,169.35 U50500.H10
  BOTTOM w0.137: U50000.AD51 171.1,147.97 170.77,148.3 170.77,151.51 171.85,152.6 171.85,153.24 175.11,156.5 175.11,157.36 179.04,161.29 179.08,161.29 179.49,161.7 179.49,166.64 179.35,166.78 179.35,168.18 179.23,168.3
