# Allegro board PH317-53 COVINI-6050A3087701-MB-AX2 (BDV)(.BRD).brd (continued)
## Library data of the parts (continued)
R52002 = RSC_0402: part number: RSC_0402-0_5%_2_DY,60130B0000ZT_DY,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-0OHM-5%-1/16W-0402-TAP; signal model: R2_60130B0000ZT_DY_0_5%_2_DY; room: Sheet98
R52006 = RSC_0402: part number: RSC_0402-1K_1%_2,60130B10019Z,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-1K-1%-1/16W-0402-TAP; signal model: R2_60130B10019Z_1K_1%_2; room: Sheet98
R52007 = RSC_0402: part number: RSC_0402-30K_1%_2_DY,60130B30029Z_DY,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-30K-1%-1/16W-0402-TAP; signal model: R2_60130B30029Z_DY_30K_1%_2_DY; room: Sheet98
R52010 R52020 = RSC_0402: part number: RSC_0402-287_1%_2,6013A008780D,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-287-1%-1/16W-0402-TAP; signal model: R2_6013A008780D_287_1%_2; room: Sheet98
R52012 R52022 = RSC_0402: part number: RSC_0402-100_1%_2,6013A0016701,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-100OHM-1%-1/16W-0402-TAP; signal model: R2_6013A0016701_100_1%_2; room: Sheet98
R52013 R52023 = RSC_0402: part number: RSC_0402-649_1%_2,6013A008790K,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP,649,1%,1/16W,0402,TAP; signal model: R2_6013A008790K_649_1%_2; room: Sheet98
R52014 R52024 = RSC_0402: part number: RSC_0402-75K_1%_2,6013A008860M,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-75K-1%-1/16W-0402-TAP; signal model: R2_6013A008860M_75K_1%_2; room: Sheet98
R52036-R52039 R52055 R52061 R52070 = RSC_0402: part number: RSC_0402-10K_1%_2,60130B10029Z,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-10K-1%-1/16W-0402-TAP; signal model: R2_60130B10029Z_10K_1%_2; room: Sheet98
R52050 = RSC_0402: part number: RSC_0402-365K_1%_2,6013A0057601,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-365K-1%-1/16W-0402-TAP; signal model: R2_6013A0057601_365K_1%_2; room: Sheet98
R52051 = RSC_0402: part number: RSC_0402-681K_1%_2,6013A0089002,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-681K-1%-1/16W-0402-TAP; signal model: R2_6013A0089002_681K_1%_2; room: Sheet98
R52053 = RSC_0402: part number: RSC_0402-243K_1%_2,6013A008880E,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-243K-1%-1/16W-0402-TAP; signal model: R2_6013A008880E_243K_1%_2; room: Sheet98
R52054 = RSC_0402: part number: RSC_0402-90.9K_1%_2,6013A0088701,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-90.9K-1%-1/16W-0402-TAP; signal model: R2_6013A0088701_90_9K_1%_2; room: Sheet98
R52060 = RSC_0402: part number: RSC_0402-49.9K_1%_2,6013A0014301,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-49.9K-1%-1/16W-0402-TAP; signal model: R2_6013A0014301_49_9K_1%_2; room: Sheet98
R52071 = RSC_0402: part number: RSC_0402-100K_1%_2,6013A0014701,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-100K-1%-1/16W-0402-TAP; signal model: R2_6013A0014701_100K_1%_2; room: Sheet98
R52072 = RSC_0402: part number: RSC_0402-10K_1%_2_DY,60130B10029Z_DY,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-10K-1%-1/16W-0402-TAP; signal model: R2_60130B10029Z_DY_10K_1%_2_DY; room: Sheet98
R52073 = RSC_0603: part number: RSC_0603-0_5%_3,60130B00000Z,RSC_160X080X055_2,0.7MM,RSC_0603,0603,RES-CHIP-0-5%-1/10W-TAP; signal model: R2_60130B00000Z_0_5%_3; room: Sheet98
R52074 = RSC_0603: part number: RSC_0603-0_5%_3_DY,60130B00000Z_DY,RSC_160X080X055_2,0.7MM,RSC_0603,0603,RES-CHIP-0-5%-1/10W-TAP; signal model: R2_60130B00000Z_0_5%_3_DY; room: Sheet98
R52101 = RSC_0402: part number: RSC_0402-10K_1%_2,60130B10029Z,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-10K-1%-1/16W-0402-TAP; signal model: R2_60130B10029Z_10K_1%_2; room: Sheet99
R52102 = RSC_0402: part number: RSC_0402-2.21K_1%_2,6013A008810E,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP,2.21K,1%,1/16W,0402,TAP; signal model: R2_6013A008810E_2_21K_1%_2; room: Sheet99
R52110 R52111 = RSC_0402: part number: RSC_0402-0_5%_2,60130B0000ZT,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-0OHM-5%-1/16W-0402-TAP; signal model: R2_60130B0000ZT_0_5%_2; room: Sheet99
R52200 = RSC_0402: part number: RSC_0402-49.9_1%_2,6013A0076901,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-49.9-1%-1/16W-0402-TAP; signal model: R2_6013A0076901_49_9_1%_2; room: Sheet100
R52210-R52212 = RSC_0402: part number: RSC_0402-40.2_1%_2,6013A008750F,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-40.2-1%-1/16W-0402-TAP; signal model: R2_6013A008750F_40_2_1%_2; room: Sheet100
R52230 R52231 = RSC_0402: part number: RSC_0402-2_1%_2,6013B0172801,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP,2,1%,1/16W,0402,TR; signal model: R2_6013B0172801_2_1%_2; room: Sheet100
R53500 R53531 R53551 R53573 R55601 = RSC_0402: part number: RSC_0402-0_5%_2,60130B0000ZT,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-0OHM-5%-1/16W-0402-TAP; signal model: R2_60130B0000ZT_0_5%_2; room: Sheet105
R53501 = RSC_0402: part number: RSC_0402-100K_1%_2_DY,6013A0014701_DY,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-100K-1%-1/16W-0402-TAP; signal model: R2_6013A0014701_DY_100K_1%_2_DY; room: Sheet105
R53505 R53510 R53511 R53530 R53541 R53571 R55602 = RSC_0402: part number: RSC_0402-10K_1%_2,60130B10029Z,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-10K-1%-1/16W-0402-TAP; signal model: R2_60130B10029Z_10K_1%_2; room: Sheet105
R53512 R53515 R53581 R53583 R55600 = RSC_0603: part number: RSC_0603-0_5%_3,60130B00000Z,RSC_160X080X055_2,0.7MM,RSC_0603,0603,RES-CHIP-0-5%-1/10W-TAP; signal model: R2_60130B00000Z_0_5%_3; room: Sheet105
R53520 R53540 R53552 R53555 R53570 R53580 R53585 R53590 = RSC_0402: part number: RSC_0402-100K_1%_2,6013A0014701,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-100K-1%-1/16W-0402-TAP; signal model: R2_6013A0014701_100K_1%_2; room: Sheet105
R53550 R53574 = RSC_0402: part number: RSC_0402-0_5%_2_DY,60130B0000ZT_DY,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-0OHM-5%-1/16W-0402-TAP; signal model: R2_60130B0000ZT_DY_0_5%_2_DY; room: Sheet105
R53584 = RSC_0603: part number: RSC_0603-0_5%_3_DY,60130B00000Z_DY,RSC_160X080X055_2,0.7MM,RSC_0603,0603,RES-CHIP-0-5%-1/10W-TAP; signal model: R2_60130B00000Z_0_5%_3_DY; room: Sheet105
R53591 = RSC_0402: part number: RSC_0402-33K_1%_2,6013A0049501,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-33K-1%-1/16W-0402-TAP; signal model: R2_6013A0049501_33K_1%_2; room: Sheet105
R55210 R55211 R55220 R55221 R55230 R55231 = RSC_0402: part number: RSC_0402-10K_1%_2,60130B10029Z,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-10K-1%-1/16W-0402-TAP; signal model: R2_60130B10029Z_10K_1%_2; room: Sheet106
R55215-R55218 R55225-R55228 R55235-R55238 = RSC_0805: part number: RSC_0805-2.2_5%_5,60130B2R203T,RSC_200X125X130_2,1.45MM,RSC_0805,0805,RES-CHIP-2.2OHM-5%-1/8W-0805-TAP; signal model: R2_60130B2R203T_2_2_5%_5; room: Sheet106
R55810 = RSC_0402: part number: RSC_0402-4.7K_5%_2,60130B4720ZT,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-4.7K-5%-1/16W-0402-TAP; signal model: R2_60130B4720ZT_4_7K_5%_2; room: Sheet92
R55811-R55819 R55831 R55832 = RSC_0402: part number: RSC_0402-4.7K_5%_2_DY,60130B4720ZT_DY,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-4.7K-5%-1/16W-0402-TAP; signal model: R2_60130B4720ZT_DY_4_7K_5%_2_DY; room: Sheet92
R55820 R55821 = RSC_0603: part number: RSC_0603-0_5%_3,60130B00000Z,RSC_160X080X055_2,0.7MM,RSC_0603,0603,RES-CHIP-0-5%-1/10W-TAP; signal model: R2_60130B00000Z_0_5%_3; room: Sheet92
R55830 = RSC_0402: part number: RSC_0402-100K_1%_2_DY,6013A0014701_DY,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-100K-1%-1/16W-0402-TAP; signal model: R2_6013A0014701_DY_100K_1%_2_DY; room: Sheet92
R56200 = RSC_0402: part number: RSC_0402-1M_5%_2,60130B10500Y,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-1M-5%-1/16W-0402-TAP; signal model: R2_60130B10500Y_1M_5%_2; room: Sheet93
R56201 = RSC_0402: part number: RSC_0402-5.1M_5%_2,6013A009000P,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP,5.1M,5%,1/16W,0402,TAP; signal model: R2_6013A009000P_5_1M_5%_2; room: Sheet93
R56202 R56251 = RSC_0402: part number: RSC_0402-0_5%_2,60130B0000ZT,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-0OHM-5%-1/16W-0402-TAP; signal model: R2_60130B0000ZT_0_5%_2; room: Sheet93
R56250 = RSC_0805: part number: RSC_0805-2.2_5%_5,60130B2R203T,RSC_200X125X130_2,1.45MM,RSC_0805,0805,RES-CHIP-2.2OHM-5%-1/8W-0805-TAP; signal model: R2_60130B2R203T_2_2_5%_5; room: Sheet93
R56260 R56261 R56270 R56271 R56280 R56281 = RSC_0402: part number: RSC_0402-100K_1%_2,6013A0014701,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-100K-1%-1/16W-0402-TAP; signal model: R2_6013A0014701_100K_1%_2; room: Sheet93
R56282 = RSC_0402: part number: RSC_0402-10K_1%_2_DY,60130B10029Z_DY,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-10K-1%-1/16W-0402-TAP; signal model: R2_60130B10029Z_DY_10K_1%_2_DY; room: Sheet93
R56290 = RSC_0402: part number: RSC_0402-0_5%_2_DY,60130B0000ZT_DY,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-0OHM-5%-1/16W-0402-TAP; signal model: R2_60130B0000ZT_DY_0_5%_2_DY; room: Sheet93
R56410 R56411 R56413 R56414 R56472 = RSC_0402: part number: RSC_0402-10K_1%_2,60130B10029Z,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-10K-1%-1/16W-0402-TAP; signal model: R2_60130B10029Z_10K_1%_2; room: Sheet95
R56412 = RSC_0402: part number: RSC_0402-11K_1%_2_DY,6013B0095801_DY,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RESISTOR-CHIP,11K,1%,1/16W,0402,TAP; signal model: R2_6013B0095801_DY_11K_1%_2_DY; room: Sheet95
R56430 = RSC_0402: part number: RSC_0402-22K_1%_2,6013A0075901,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-22K-1%-1/16W-0402-TAP; signal model: R2_6013A0075901_22K_1%_2; room: Sheet95
R56431 = RSC_0402: part number: RSC_0402-100K_1%_2_DY,6013A0014701_DY,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-100K-1%-1/16W-0402-TAP; signal model: R2_6013A0014701_DY_100K_1%_2_DY; room: Sheet95
R56432 = RSC_0402: part number: RSC_0402-22K_1%_2_DY,6013A0075901_DY,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHI   P-22K-1%-1/16W-0402-TAP; signal model: R2_6013A0075901_DY_22K_1%_2_DY; room: Sheet95
R56433 R56470 = RSC_0402: part number: RSC_0402-100K_1%_2,6013A0014701,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-100K-1%-1/16W-0402-TAP; signal model: R2_6013A0014701_100K_1%_2; room: Sheet95
R56435 R56471 = RSC_0402: part number: RSC_0402-1K_1%_2,60130B10019Z,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-1K-1%-1/16W-0402-TAP; signal model: R2_60130B10019Z_1K_1%_2; room: Sheet95
R56436 = RSC_0402: part number: RSC_0402-1K_1%_2_DY,60130B10019Z_DY,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-1K-1%-1/16W-0402-TAP; signal model: R2_60130B10019Z_DY_1K_1%_2_DY; room: Sheet95
R56440 R56450 R56451 R56453 = RSC_0603: part number: RSC_0603-0_5%_3,60130B00000Z,RSC_160X080X055_2,0.7MM,RSC_0603,0603,RES-CHIP-0-5%-1/10W-TAP; signal model: R2_60130B00000Z_0_5%_3; room: Sheet95
R56452 = RSC_0603: part number: RSC_0603-0_5%_3_DY,60130B00000Z_DY,RSC_160X080X055_2,0.7MM,RSC_0603,0603,RES-CHIP-0-5%-1/10W-TAP; signal model: R2_60130B00000Z_0_5%_3_DY; room: Sheet95
R56462 R56463 = RSC_0402: part number: RSC_0402-0_5%_2_DY,60130B0000ZT_DY,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-0OHM-5%-1/16W-0402-TAP; signal model: R2_60130B0000ZT_DY_0_5%_2_DY; room: Sheet95
R56620 R56671 R56673 R56674 R56676 R56677 R56679 = RSC_0402: part number: RSC_0402-22_1%_2,6013A0118801,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-22-1%-1/16W-0402-TAP; signal model: R2_6013A0118801_22_1%_2; room: Sheet96
R56621 = RSC_0402: part number: RSC_0402-47K_5%_2,60130B4730ZT,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-47K-5%-1/16W-0402-TAP; signal model: R2_60130B4730ZT_47K_5%_2; room: Sheet96
R56670 R56690 = RSC_0402: part number: RSC_0402-1K_1%_2,60130B10019Z,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-1K-1%-1/16W-0402-TAP; signal model: R2_60130B10019Z_1K_1%_2; room: Sheet96
R56672 R56675 R56678 R56680 = RSC_0402: part number: RSC_0402-2K_1%_2,6013A0018401,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-2K-1%-1/16W-0402-TAP; signal model: R2_6013A0018401_2K_1%_2; room: Sheet96
R56681-R56688 = RSC_0402: part number: RSC_0402-0_5%_2,60130B0000ZT,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-0OHM-5%-1/16W-0402-TAP; signal model: R2_60130B0000ZT_0_5%_2; room: Sheet96
R56691 R56692 = RSC_0402: part number: RSC_0402-1.8K_1%_2,6013A0067101,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-1.8K-1%-1/16W-0402-TAP; signal model: R2_6013A0067101_1_8K_1%_2; room: Sheet96
R60000 = RSC_1206_4PIN: part number: RSC_1206_4PIN-0.005_1%_6,6013B0240201,RSC_320X160X080_4_P2,0.9MM,RSC_1206_4PIN,RESISTOR-M/F,0.005,1%,1W,1206,TR; signal model: R4_6013B0240201_0_005_1%_6; room: Sheet8
R60001 = RSC_1206_4PIN: part number: RSC_1206_4PIN-0.01_1%_6,6013B0109401,RSC_320X160X089_4_P2,0.989MM,RSC_1206_4PIN,RES-M/F,0.01,1%,1W,1206,TR; signal model: R4_6013B0109401_0_01_1%_6; room: Sheet8
R60002 = RSC_0402: part number: RSC_0402-200K_1%_2,60130B20039Z,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-200K-1%-1/16W-0402-TAP; signal model: R2_60130B20039Z_200K_1%_2; room: Sheet8
R60003 = RSC_0402: part number: RSC_0402-51K_1%_2,6013A0018501,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-51K-1%-1/16W-0402-TAP; signal model: R2_6013A0018501_51K_1%_2; room: Sheet8
R60004 R60005 R60011 = RSC_0402: part number: RSC_0402-4.3K_5%_2,60130B43200Z,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-4.3K-5%-1/16W-0402-TAP; signal model: R2_60130B43200Z_4_3K_5%_2; room: Sheet8
R60007 = RSC_0402: part number: RSC_0402-10K_5%_2,60130B1030ZT,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP,10K,5%,1/16W,0402,TR; signal model: R2_60130B1030ZT_10K_5%_2; room: Sheet8
R60008 R60010 R60012 = RSC_0402: part number: RSC_0402-10_5%_2,60130B10000X,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-10-5%-1/16W-0402-TAP; signal model: R2_60130B10000X_10_5%_2; room: Sheet8
R60009 = RSC_0805: part number: RSC_0805-10_5%_5,60130BA1003S,RSC_200X125X115_2,1.3MM,RSC_0805,0805,RES-CHIP-10-5%-1/8W-0805-TAP; signal model: R2_60130BA1003S_10_5%_5; room: Sheet8
R60013 = RSC_0402: part number: RSC_0402-20K_1%_2,6013A0015301,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-20K-1%-1/16W-0402-TAP; signal model: R2_6013A0015301_20K_1%_2; room: Sheet8
R60014 = RSC_0402: part number: RSC_0402-49.9K_1%_2,6013A0014301,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-49.9K-1%-1/16W-0402-TAP; signal model: R2_6013A0014301_49_9K_1%_2; room: Sheet8
R60015 R60016 = RSC_0603: part number: RSC_0603-2.2_5%_3,60130B2R200T,RSC_160X080X080_2,0.95MM,RSC_0603,0603,RES-CHIP-2.2-5%-1/10W-0603-TAP; signal model: R2_60130B2R200T_2_2_5%_3; room: Sheet8
R60017 R60018 = RSC_0402: part number: RSC_0402-470K_5%_2,60130B47400Z,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-470K-5%-1/16W-0402-TAP; signal model: R2_60130B47400Z_470K_5%_2; room: Sheet9
R60019 = RSC_0402: part number: RSC_0402-1M_5%_2,60130B10500Y,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-1M-5%-1/16W-0402-TAP; signal model: R2_60130B10500Y_1M_5%_2; room: Sheet9
R60020 = RSC_0402: part number: RSC_0402-3M_5%_2,6013A009000H,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP,3M,5%,1/16W,0402,TR; signal model: R2_6013A009000H_3M_5%_2; room: Sheet9
R60021 = RSC_SHORT: part number: RSC_SHORT-SHORT_0402_15,SHORT_0402_15,RSC_100X050X040_2_15_SHORT,0.127MM,RSC_SHORT,SHORT_0402_15; signal model: R2_short_0402_15_short_0402_15; room: Sheet8
R60022 = RSC_0402: part number: RSC_0402-0_5%_2_DY,60130B0000ZT_DY,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-0OHM-5%-1/16W-0402-TAP; signal model: R2_60130B0000ZT_DY_0_5%_2_DY; room: Sheet8
R60026 = RSC_0402: part number: RSC_0402-1K_5%_2,60130B1020ZT,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-1K-5%-1/16W-0402-TAP; signal model: R2_60130B1020ZT_1K_5%_2; room: Sheet9
R60110 = RSC_0402: part number: RSC_0402-RSC_0402,RSC_0402,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RSC_0402; signal model: R2_RSC_0402_RSC_0402; room: Sheet12
R60115 = RSC_0603: part number: RSC_0603-3.3_5%_3,6013B0049701,RSC_160X080X055_2,0.7MM,RSC_0603,0603,RESISTOR-CHIP,3.3,5%,1/10W,0603,TR,+/-400PPM/DEGREEC; signal model: R2_6013B00497013_3_5%_3; room: Sheet12
R60166 = RSC_0603: part number: RSC_0603-RSC_0603,RSC_0603,RSC_160X080X080_2,0.95MM,RSC_0603,0603,RSC_0603; signal model: R2_RSC_0603_RSC_0603; room: Sheet12
R60199 = RSC_SHORT: part number: RSC_SHORT-SHORT_0402_15,SHORT_0402_15,RSC_100X050X040_2_15_SHORT,0.127MM,RSC_SHORT,SHORT_0402_15; signal model: R2_short_0402_15_short_0402_15; room: Sheet12
R60203 = RSC_SHORT: part number: RSC_SHORT-SHORT_0402_15,SHORT_0402_15,RSC_100X050X040_2_15_SHORT,0.127MM,RSC_SHORT,SHORT_0402_15; signal model: R2_short_0402_15_short_0402_15; room: Sheet10
R60204 = RSC_0402: part number: RSC_0402-0_5%_2,60130B0000ZT,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-0OHM-5%-1/16W-0402-TAP; signal model: R2_60130B0000ZT_0_5%_2; room: Sheet10
R60205 = RSC_0402: part number: RSC_0402-100K_5%_2,60130B1040ZT,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-100K-5%-1/16W-0402-TAP; signal model: R2_60130B1040ZT_100K_5%_2; room: Sheet10
R60215 = RSC_0603: part number: RSC_0603-0_5%_3,60130B00000Z,RSC_160X080X055_2,0.7MM,RSC_0603,0603,RES-CHIP-0-5%-1/10W-TAP; signal model: R2_60130B00000Z_0_5%_3; room: Sheet10
R60216 = RSC_0603: part number: RSC_0603-RSC_0603,RSC_0603,RSC_160X080X080_2,0.95MM,RSC_0603,0603,RSC_0603; signal model: R2_RSC_0603_RSC_0603; room: Sheet10
R60239 = RSC_0402: part number: RSC_0402-1K_5%_2,60130B1020ZT,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-1K-5%-1/16W-0402-TAP; signal model: R2_60130B1020ZT_1K_5%_2; room: Sheet10
R60253 = RSC_SHORT: part number: RSC_SHORT-SHORT_0402_15,SHORT_0402_15,RSC_100X050X040_2_15_SHORT,0.127MM,RSC_SHORT,SHORT_0402_15; signal model: R2_short_0402_15_short_0402_15; room: Sheet11
R60254 = RSC_0402: part number: RSC_0402-0_5%_2,60130B0000ZT,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-0OHM-5%-1/16W-0402-TAP; signal model: R2_60130B0000ZT_0_5%_2; room: Sheet11
R60265 = RSC_0603: part number: RSC_0603-0_5%_3,60130B00000Z,RSC_160X080X055_2,0.7MM,RSC_0603,0603,RES-CHIP-0-5%-1/10W-TAP; signal model: R2_60130B00000Z_0_5%_3; room: Sheet11
R60266 = RSC_0603: part number: RSC_0603-RSC_0603_DY,RSC_0603_DY,RSC_160X080X080_2,0.95MM,RSC_0603,0603,RSC_0603_DY; signal model: R2_RSC_0603_DY_RSC_0603_DY; room: Sheet11
R60289 = RSC_0402: part number: RSC_0402-1K_1%_2,60130B10019Z,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-1K-1%-1/16W-0402-TAP; signal model: R2_60130B10019Z_1K_1%_2; room: Sheet11
R60300 = RSC_0402: part number: RSC_0402-10.2K_1%_2,6013A0074801,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-10.2K-1%-1/16W-0402-TAP; signal model: R2_6013A0074801_10_2K_1%_2; room: Sheet13
R60301 = RSC_0402: part number: RSC_0402-10K_1%_2,60130B10029Z,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-10K-1%-1/16W-0402-TAP; signal model: R2_60130B10029Z_10K_1%_2; room: Sheet13
R60302 = RSC_SHORT: part number: RSC_SHORT-SHORT_0402_5,SHORT_0402_5,RSC_100X050X040_2_SHORT,0.127MM,RSC_SHORT,SHORT_0402_5; signal model: R2_short_0402_5_short_0402_5; room: Sheet13
R60315 = RSC_SHORT: part number: RSC_SHORT-SHORT_0603_25,SHORT_0603_25,RSC_160X080X080_2_25_SHORT,0.127MM,RSC_SHORT,SHORT_0603_25; signal model: R2_short_0603_25_short_0603_25; room: Sheet13
R60316 = RSC_0603: part number: RSC_0603-RSC_0603,RSC_0603,RSC_160X080X080_2,0.95MM,RSC_0603,0603,RSC_0603; signal model: R2_RSC_0603_RSC_0603; room: Sheet13
R60344 R60347 R60348 = RSC_0402: part number: RSC_0402-RSC_0402,RSC_0402,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RSC_0402; signal model: R2_RSC_0402_RSC_0402; room: Sheet13
R60346 R60349 = RSC_SHORT: part number: RSC_SHORT-SHORT_0402_15,SHORT_0402_15,RSC_100X050X040_2_15_SHORT,0.127MM,RSC_SHORT,SHORT_0402_15; signal model: R2_short_0402_15_short_0402_15; room: Sheet13
R60400 = RSC_0402: part number: RSC_0402-324K_1%_2,6013A008880W,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-324K-1%-1/16W-0402-TAP; signal model: R2_6013A008880W_324K_1%_2; room: Sheet15
R60401 = RSC_0402: part number: RSC_0402-100K_1%_2,6013A0014701,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-100K-1%-1/16W-0402-TAP; signal model: R2_6013A0014701_100K_1%_2; room: Sheet15
R60505 R60516 = RSC_0603: part number: RSC_0603-RSC_0603,RSC_0603,RSC_160X080X080_2,0.95MM,RSC_0603,0603,RSC_0603; signal model: R2_RSC_0603_RSC_0603; room: Sheet17
R60506 R60515 = RSC_0603: part number: RSC_0603-2.2_5%_3,60130B2R200T,RSC_160X080X080_2,0.95MM,RSC_0603,0603,RES-CHIP-2.2-5%-1/10W-0603-TAP; signal model: R2_60130B2R200T_2_2_5%_3; room: Sheet17
R60522 = RSC_0402: part number: RSC_0402-100K_5%_2,60130B1040ZT,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-100K-5%-1/16W-0402-TAP; signal model: R2_60130B1040ZT_100K_5%_2; room: Sheet17
R60523 = RSC_0402: part number: RSC_0402-470K_5%_2,60130B47400Z,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-470K-5%-1/16W-0402-TAP; signal model: R2_60130B47400Z_470K_5%_2; room: Sheet17
R60524 R60525 = RSC_0402: part number: RSC_0402-RSC_0402,RSC_0402,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RSC_0402; signal model: R2_RSC_0402_RSC_0402; room: Sheet17
R60526 = RSC_SHORT: part number: RSC_SHORT-SHORT_0402_15,SHORT_0402_15,RSC_100X050X040_2_15_SHORT,0.127MM,RSC_SHORT,SHORT_0402_15; signal model: R2_short_0402_15_short_0402_15; room: Sheet17
R60529 = RSC_SHORT: part number: RSC_SHORT-SHORT_0402_5,SHORT_0402_5,RSC_100X050X040_2_SHORT,0.127MM,RSC_SHORT,SHORT_0402_5; signal model: R2_short_0402_5_short_0402_5; room: Sheet17
R60600 = RSC_0402: part number: RSC_0402-20.5K_1%_2,6013A008840P,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-20.5K-1%-1/16W-0402-TAP; signal model: R2_6013A008840P_20_5K_1%_2; room: Sheet14
R60601 = RSC_0402: part number: RSC_0402-10K_1%_2,60130B10029Z,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-10K-1%-1/16W-0402-TAP; signal model: R2_60130B10029Z_10K_1%_2; room: Sheet14
R60900 = RSC_0402: part number: RSC_0402-100K_1%_2,6013A0014701,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-100K-1%-1/16W-0402-TAP; signal model: R2_6013A0014701_100K_1%_2; room: Sheet16
R60901 = RSC_0402: part number: RSC_0402-133K_1%_2,6013A008870H,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-133K-1%-1/16W-0402-TAP; signal model: R2_6013A008870H_133K_1%_2; room: Sheet16
R60905 = RSC_0402: part number: RSC_0402-RSC_0402,RSC_0402,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RSC_0402; signal model: R2_RSC_0402_RSC_0402; room: Sheet16
R60915 = RSC_0603: part number: RSC_0603-0_5%_3,60130B00000Z,RSC_160X080X055_2,0.7MM,RSC_0603,0603,RES-CHIP-0-5%-1/10W-TAP; signal model: R2_60130B00000Z_0_5%_3; room: Sheet16
R60916 = RSC_0603: part number: RSC_0603-RSC_0603,RSC_0603,RSC_160X080X080_2,0.95MM,RSC_0603,0603,RSC_0603; signal model: R2_RSC_0603_RSC_0603; room: Sheet16
R60920 = RSC_0402: part number: RSC_0402-1K_5%_2,60130B1020ZT,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-1K-5%-1/16W-0402-TAP; signal model: R2_60130B1020ZT_1K_5%_2; room: Sheet16
R66000 = RSC_SHORT: part number: RSC_SHORT-SHORT_0402_5,SHORT_0402_5,RSC_100X050X040_2_SHORT,0.127MM,RSC_SHORT,SHORT_0402_5; signal model: R2_short_0402_5_short_0402_5; room: Sheet18
R66001 R66104 R66115 R66136 R66137 R66602 = RSC_0402: part number: RSC_0402-RSC_0402,RSC_0402,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RSC_0402; signal model: R2_RSC_0402_RSC_0402; room: Sheet18
R66005 = RSC_0402: part number: RSC_0402-33.2K_1%_2,6013A0024701,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-33.2K-1%-1/16W-0402-TAP; signal model: R2_6013A0024701_33_2K_1%_2; room: Sheet18
R66015 R66025 R66035 R66045 = RSC_0603: part number: RSC_0603-3.3_5%_3,6013B0049701,RSC_160X080X055_2,0.7MM,RSC_0603,0603,RESISTOR-CHIP,3.3,5%,1/10W,0603,TR,+/-400PPM/DEGREEC; signal model: R2_6013B00497013_3_5%_3; room: Sheet19
R66016 R66026 R66036 R66046 = RSC_0603: part number: RSC_0603-10_5%_3,60130B10000Z,RSC_160X080X080_2,0.95MM,RSC_0603,0603,RES-CHIP-10-5%-1/10W-0603-TAP; signal model: R2_60130B10000Z_10_5%_3; room: Sheet19
R66017 R66027 R66037 R66047 = RSC_0603: part number: RSC_0603-2.2_5%_3,60130B2R200T,RSC_160X080X080_2,0.95MM,RSC_0603,0603,RES-CHIP-2.2-5%-1/10W-0603-TAP; signal model: R2_60130B2R200T_2_2_5%_3; room: Sheet19
R66018 R66028 R66038 R66048 = RSC_SHORT: part number: RSC_SHORT-SHORT_0402_15,SHORT_0402_15,RSC_100X050X040_2_15_SHORT,0.127MM,RSC_SHORT,SHORT_0402_15; signal model: R2_short_0402_15_short_0402_15; room: Sheet19
R66019 R66029 R66039 R66049 = RSC_0402: part number: RSC_0402-220_1%_2,60130B22009T,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RESISTOR-CHIP,220,1%,1/16W,0402,TR; signal model: R2_60130B22009T_220_1%_2; room: Sheet19
R66090 R66690 = RSC_0402: part number: RSC_0402-130K_1%_2,6013A0075701,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-130K-1%-1/16W-0402-TAP; signal model: R2_6013A0075701_130K_1%_2; room: Sheet18
R66091 = RSC_0402: part number: RSC_0402-24.9K_1%_2,6013A0088503,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-24.9K-1%-1/16W-0402-TAP; signal model: R2_6013A0088503_24_9K_1%_2; room: Sheet18
R66092 = RSC_0402: part number: RSC_0402-4.3K_1%_2,6013A0067501,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-4.3K-1%-1/16W-0402-TAP; signal model: R2_6013A0067501_4_3K_1%_2; room: Sheet18
R66093 = RSC_0402: part number: RSC_0402-110K_1%_2,60130B11039Y,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-110K-1%-1/16W-0402-TAP; signal model: R2_60130B11039Y_110K_1%_2; room: Sheet18
R66100 = RSC_0402: part number: RSC_0402-100_1%_2,6013A0016701,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-100OHM-1%-1/16W-0402-TAP; signal model: R2_6013A0016701_100_1%_2; room: Sheet18
R66101 = RSC_0402: part number: RSC_0402-45.3_1%_2,6013A008750L,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-45.3-1%-1/16-0402-TAP; signal model: R2_6013A008750L_45_3_1%_2; room: Sheet18
R66102 R66170 R66470 = RSC_0402: part number: RSC_0402-49.9_1%_2,6013A0076901,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-49.9-1%-1/16W-0402-TAP; signal model: R2_6013A0076901_49_9_1%_2; room: Sheet18
R66103 R66113 R66123 R66133 R66143 R66413 R66651 = RSC_0402: part number: RSC_0402-10_1%_2,6013A0014201,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-10OHM-1%-1/16W-0402-TAP; signal model: R2_6013A0014201_10_1%_2; room: Sheet18
R66105 = RSC_0402: part number: RSC_0402-75_1%_2,6013A0050301,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-75-1%-1/16W-0402-TAP; signal model: R2_6013A0050301_75_1%_2; room: Sheet18
R66107 = RSC_0402: part number: RSC_0402-26.7K_1%_2,6013A0073701,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-26.7K-1%-1/16W-0402-TAP; signal model: R2_6013A0073701_26_7K_1%_2; room: Sheet18
R66109 = RSC_0402: part number: RSC_0402-2_5%_2,6013B0172701,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP,2,5%,1/16W,0402,TR; signal model: R2_6013B0172701_2_5%_2; room: Sheet18
R66112 R66122 R66132 R66142 = RSC_0402: part number: RSC_0402-93.1K_1%_2,6013A0088702,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RESISTOR-CHIP,93.1KOHM,1%,1/16W,0402,TAP; signal model: R2_6013A0088702_93_1K_1%_2; room: Sheet18
R66114 R66124 R66134 R66144 = RSC_0402: part number: RSC_0402-4.64K_1%_2,6013B0124101,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP,4.64K,1%,1/16W,0402,TAP; signal model: R2_6013B0124101_4_64K_1%_2; room: Sheet18
R66150 R66160 R66450 R66460 R66650 = RSC_THERMISTOR: part number: RSC_THERMISTOR-100K_1%_NTC,6013B0171701,RSC_100X050X055_2,0.7MM,RSC_THERMISTOR,,RESISTOR-THER,NTC,100K,0402,1%,0.1A,0.1W,SMD,TR; signal model: R2_6013B0171701_100K_1%_NTC; room: Sheet18
R66151 R66451 = RSC_0402: part number: RSC_0402-75K_1%_2,6013A008860M,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-75K-1%-1/16W-0402-TAP; signal model: R2_6013A008860M_75K_1%_2; room: Sheet18
R66152 R66452 = RSC_0402: part number: RSC_0402-165K_1%_2,6013A008870T,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-165K-1%-1/16W-0402-TAP; signal model: R2_6013A008870T_165K_1%_2; room: Sheet18
R66161 R66180 R66181 R66195 R66461 R66480 R66481 R66680 R66681 = RSC_SHORT: part number: RSC_SHORT-SHORT_0402_15,SHORT_0402_15,RSC_100X050X040_2_15_SHORT,0.127MM,RSC_SHORT,SHORT_0402_15; signal model: R2_short_0402_15_short_0402_15; room: Sheet18
R66162 R66462 = RSC_0402: part number: RSC_0402-18.7K_1%_2,6013A0017101,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-18.7K-1%-1/16W-0402-TAP; signal model: R2_6013A0017101_18_7K_1%_2; room: Sheet18
R66171 R66182 R66471 R66482 R66670 = RSC_0402: part number: RSC_0402-1K_1%_2,60130B10019Z,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-1K-1%-1/16W-0402-TAP; signal model: R2_60130B10019Z_1K_1%_2; room: Sheet18
R66172 R66472 = RSC_0402: part number: RSC_0402-3K_1%_2,6013A0067201,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-3K-1%-1/16W-0402-TAP; signal model: R2_6013A0067201_3K_1%_2; room: Sheet18
R66197 = RSC_0402: part number: RSC_0402-16K_1%_2,6013B0198501,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RESISTOR-CHIP,16K,1%,1/16W,0402,TR,+/-100PPM/DEGREEC; signal model: R2_6013B0198501_16K_1%_2; room: Sheet18
R66199 R66424 = RSC_0402: part number: RSC_0402-1K_5%_2,60130B1020ZT,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-1K-5%-1/16W-0402-TAP; signal model: R2_60130B1020ZT_1K_5%_2; room: Sheet18
R66305 = RSC_0402: part number: RSC_0402-13K_1%_2,6013A0088404,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-13K-1%-1/16W-0402-TAP; signal model: R2_6013A0088404_13K_1%_2; room: Sheet18
R66311 = RSC_0402: part number: RSC_0402-51_5%_2,60130B5100ZT,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-51-5%-1/16W-0402-TAP; signal model: R2_60130B5100ZT_51_5%_2; room: Sheet20
R66315 R66317 = RSC_0603: part number: RSC_0603-2.2_5%_3,60130B2R200T,RSC_160X080X080_2,0.95MM,RSC_0603,0603,RES-CHIP-2.2-5%-1/10W-0603-TAP; signal model: R2_60130B2R200T_2_2_5%_3; room: Sheet20
R66316 = RSC_0603: part number: RSC_0603-10_5%_3,60130B10000Z,RSC_160X080X080_2,0.95MM,RSC_0603,0603,RES-CHIP-10-5%-1/10W-0603-TAP; signal model: R2_60130B10000Z_10_5%_3; room: Sheet20
R66318 R66319 = RSC_SHORT: part number: RSC_SHORT-SHORT_0402_15,SHORT_0402_15,RSC_100X050X040_2_15_SHORT,0.127MM,RSC_SHORT,SHORT_0402_15; signal model: R2_short_0402_15_short_0402_15; room: Sheet20
R66393 = RSC_0402: part number: RSC_0402-25.5K_1%_2,6013A0088504,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP,25.5KOHM,1%,1/16W,0402,TAP; signal model: R2_6013A0088504_25_5K_1%_2; room: Sheet18
R66407 = RSC_0402: part number: RSC_0402-32.4K_1%_2,6013A008850E,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-32.4K-1%-1/16W-0402-TAP; signal model: R2_6013A008850E_32_4K_1%_2; room: Sheet18
R66412 = RSC_0402: part number: RSC_0402-54.9K_1%_2,6013A0077501,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-54.9K-1%-1/16W-0402-TAP; signal model: R2_6013A0077501_54_9K_1%_2; room: Sheet18
R66414 = RSC_0402: part number: RSC_0402-5.1K_1%_2,6013A0082001,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-5.1K-1%-1/16W-0402-TAP; signal model: R2_6013A0082001_5_1K_1%_2; room: Sheet18
R66605 = RSC_0402: part number: RSC_0402-40.2K_1%_2,6013A0016001,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-40.2K-1%-1/16W-0402-TAP; signal model: R2_6013A0016001_40_2K_1%_2; room: Sheet18
R66607 = RSC_0402: part number: RSC_0402-127K_1%,6013A008870F,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-127K-1%-1/16-0402-TAP; signal model: R2_6013A008870F_127K_1%; room: Sheet18
R66615 = RSC_0603: part number: RSC_0603-2.2_5%_3,60130B2R200T,RSC_160X080X080_2,0.95MM,RSC_0603,0603,RES-CHIP-2.2-5%-1/10W-0603-TAP; signal model: R2_60130B2R200T_2_2_5%_3; room: Sheet21
R66616 = RSC_0603: part number: RSC_0603-RSC_0603,RSC_0603,RSC_160X080X080_2,0.95MM,RSC_0603,0603,RSC_0603; signal model: R2_RSC_0603_RSC_0603; room: Sheet21
R66618 = RSC_SHORT: part number: RSC_SHORT-SHORT_0402_15,SHORT_0402_15,RSC_100X050X040_2_15_SHORT,0.127MM,RSC_SHORT,SHORT_0402_15; signal model: R2_short_0402_15_short_0402_15; room: Sheet21
R66619 = RSC_0402: part number: RSC_0402-220_1%_2,60130B22009T,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RESISTOR-CHIP,220,1%,1/16W,0402,TR; signal model: R2_60130B22009T_220_1%_2; room: Sheet21
R66652 = RSC_0402: part number: RSC_0402-14K_1%_2,6013A0088407,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-14K-1%-1/16-0402-TAP; signal model: R2_6013A0088407_14K_1%_2; room: Sheet18
R66653 = RSC_0402: part number: RSC_0402-7.5K_1%_2,6013A0085901,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-7.5K-1%-1/16W-0402-TAP; signal model: R2_6013A0085901_7_5K_1%_2; room: Sheet18
R66682 = RSC_0402: part number: RSC_0402-2K_1%_2,6013A008810A,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-2K-1%-1/16W-0402-TAP; signal model: R2_6013A008810A_2K_1%_2; room: Sheet18
R66683 = RSC_0402: part number: RSC_0402-6.98K_1%_2,6013A0088306,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-6.98K-1%-1/16W-0402-TAP; signal model: R2_6013A0088306_6_98K_1%_2; room: Sheet18
R66693 = RSC_0402: part number: RSC_0402-37.4K_1%_2,6013A0092201,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-37.4K-1%-1/16W-0402-TAP; signal model: R2_6013A0092201_37_4K_1%_2; room: Sheet18
R67000 R67001 R67004 R67008-R67010 R67012 R67090 = RSC_0402: part number: RSC_0402-0_5%_2,60130B0000ZT,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-0OHM-5%-1/16W-0402-TAP; signal model: R2_60130B0000ZT_0_5%_2; room: Sheet108
R67002 R67003 = RSC_0402: part number: RSC_0402-100_1%_2,6013A0016701,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-100OHM-1%-1/16W-0402-TAP; signal model: R2_6013A0016701_100_1%_2; room: Sheet108
R67005 = RSC_0402: part number: RSC_0402-RSC_0402_NTC,RSC_0402_NTC,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RSC_0402; signal model: R2_RSC_0402_NTC_RSC_0402_NTC; room: Sheet108
R67006 R67007 R67091 = RSC_0402: part number: RSC_0402-4.99K_1%_2,6013A0015201,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-4.99K-1%-1/16W-0402-TAP; signal model: R2_6013A0015201_4_99K_1%_2; room: Sheet108
R67013 = RSC_0402: part number: RSC_0402-10K_5%_2,60130B1030ZT,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP,10K,5%,1/16W,0402,TR; signal model: R2_60130B1030ZT_10K_5%_2; room: Sheet108
R67014 R67080 R67089 R67095 R67096 = RSC_0402: part number: RSC_0402-RSC_0402,RSC_0402,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RSC_0402; signal model: R2_RSC_0402_RSC_0402; room: Sheet108
R67016 R67026 = RSC_0603: part number: RSC_0603-RSC_0603,RSC_0603,RSC_160X080X080_2,0.95MM,RSC_0603,0603,RSC_0603; signal model: R2_RSC_0603_RSC_0603; room: Sheet109
R67017 R67027 = RSC_0402: part number: RSC_0402-2K_5%_2,60130B2020ZT,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-2K-5%-1/16W-0402-TAP; signal model: R2_60130B2020ZT_2K_5%_2; room: Sheet109
R67036 R67046 = RSC_0603: part number: RSC_0603-RSC_0603,RSC_0603,RSC_160X080X080_2,0.95MM,RSC_0603,0603,RSC_0603; signal model: R2_RSC_0603_RSC_0603; room: Sheet110
R67037 R67047 = RSC_0402: part number: RSC_0402-2K_5%_2,60130B2020ZT,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-2K-5%-1/16W-0402-TAP; signal model: R2_60130B2020ZT_2K_5%_2; room: Sheet110
R67056 R67066 = RSC_0603: part number: RSC_0603-RSC_0603,RSC_0603,RSC_160X080X080_2,0.95MM,RSC_0603,0603,RSC_0603; signal model: R2_RSC_0603_RSC_0603; room: Sheet111
R67057 R67067 = RSC_0402: part number: RSC_0402-2K_5%_2,60130B2020ZT,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-2K-5%-1/16W-0402-TAP; signal model: R2_60130B2020ZT_2K_5%_2; room: Sheet111
R67081-R67086 = RSC_0402: part number: RSC_0402-1K_5%_2,60130B1020ZT,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-1K-5%-1/16W-0402-TAP; signal model: R2_60130B1020ZT_1K_5%_2; room: Sheet108
R67087 = RSC_0402: part number: RSC_0402-66.5K_1%_2,6013A008860G,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP,66.5KOHM,1%,1/16W,0402,TAP; signal model: R2_6013A008860G_66_5K_1%_2; room: Sheet108
R67088 = RSC_0402: part number: RSC_0402-1M_1%_2,60130B10049Z,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-1M-1%-1/16W-0402-TAP; signal model: R2_60130B10049Z_1M_1%_2; room: Sheet108
R67092 = RSC_0402: part number: RSC_0402-402_1%_2,6013A0023801,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-402-1%-1/16W-0402-TAP; signal model: R2_6013A0023801_402_1%_2; room: Sheet108
R67093 = RSC_0402: part number: RSC_0402-61.9K_1%_2,6013A0018701,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-61.9K-1%-1/16W-0402-TAP; signal model: R2_6013A0018701_61_9K_1%_2; room: Sheet108
R67094 = RSC_0402: part number: RSC_0402-150_1%_2,60130B15009Y,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-150-1%-1/16W-0402-TAP; signal model: R2_60130B15009Y_150_1%_2; room: Sheet108
R67099 R67199 = RSC_1206_4PIN: part number: RSC_1206_4PIN-0.005_1%_6,6013B0240201,RSC_320X160X080_4_P2,0.9MM,RSC_1206_4PIN,RESISTOR-M/F,0.005,1%,1W,1206,TR; signal model: R4_6013B0240201_0_005_1%_6; room: Sheet109
R67200 R67203 = RSC_0402: part number: RSC_0402-100_5%_2,60130B1010ZT,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-100-5%-1/16W-0402-TAP; signal model: R2_60130B1010ZT_100_5%_2; room: Sheet112
R67201 R67202 R67211 R67219 R67220 = RSC_SHORT: part number: RSC_SHORT-SHORT_0402_5,SHORT_0402_5,RSC_100X050X040_2_SHORT,0.127MM,RSC_SHORT,SHORT_0402_5; signal model: R2_short_0402_5_short_0402_5; room: Sheet112
R67204 = RSC_0402: part number: RSC_0402-4.7K_1%_2,60130B47019Z,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-4.7K-1%-1/16W-0402-TAP; signal model: R2_60130B47019Z_4_7K_1%_2; room: Sheet112
R67205 = RSC_0402: part number: RSC_0402-7.87K_1%_2,6013A008830B,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-7.87K-1%-1/16W-0402-TAP; signal model: R2_6013A008830B_7_87K_1%_2; room: Sheet112
R67206 = RSC_0402: part number: RSC_0402-25.5K_1%_2,6013A0088504,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP,25.5KOHM,1%,1/16W,0402,TAP; signal model: R2_6013A0088504_25_5K_1%_2; room: Sheet112
R67207 = RSC_0402: part number: RSC_0402-60.4K_1%_2,6013A0073401,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-60.4K-1%-1/16W-0402-TAP; signal model: R2_6013A0073401_60_4K_1%_2; room: Sheet112
R67208 = RSC_SHORT: part number: RSC_SHORT-SHORT_0402_15,SHORT_0402_15,RSC_100X050X040_2_15_SHORT,0.127MM,RSC_SHORT,SHORT_0402_15; signal model: R2_short_0402_15_short_0402_15; room: Sheet112
R67209 = RSC_0603: part number: RSC_0603-10_5%_3,60130B10000Z,RSC_160X080X080_2,0.95MM,RSC_0603,0603,RES-CHIP-10-5%-1/10W-0603-TAP; signal model: R2_60130B10000Z_10_5%_3; room: Sheet112
R67212 = RSC_0402: part number: RSC_0402-0_5%_2,60130B0000ZT,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-0OHM-5%-1/16W-0402-TAP; signal model: R2_60130B0000ZT_0_5%_2; room: Sheet112
R67215 R67225 = RSC_0603: part number: RSC_0603-2.2_5%_3,60130B2R200T,RSC_160X080X080_2,0.95MM,RSC_0603,0603,RES-CHIP-2.2-5%-1/10W-0603-TAP; signal model: R2_60130B2R200T_2_2_5%_3; room: Sheet112
R67216 R67226 = RSC_0603: part number: RSC_0603-RSC_0603,RSC_0603,RSC_160X080X080_2,0.95MM,RSC_0603,0603,RSC_0603; signal model: R2_RSC_0603_RSC_0603; room: Sheet112
R67217 = RSC_0402: part number: RSC_0402-432K_1%_2,6013A0013901,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-432K-1%-1/16W-0402-TAP; signal model: R2_6013A0013901_432K_1%_2; room: Sheet112
R67218 = RSC_0402: part number: RSC_0402-2.2_5%_2,6013B0137701,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP,2.2,5%,1/16W,0402,TR; signal model: R2_6013B0137701_2_2_5%_2; room: Sheet112
R67230 R67231 = RSC_0402: part number: RSC_0402-RSC_0402,RSC_0402,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RSC_0402; signal model: R2_RSC_0402_RSC_0402; room: Sheet112
R67233 = RSC_0402: part number: RSC_0402-137K_1%_2,6013A0019401,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-137K-1%-1/16W-0402-TAP; signal model: R2_6013A0019401_137K_1%_2; room: Sheet112
R67400 = RSC_0402: part number: RSC_0402-20.5K_1%_2,6013A008840P,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-20.5K-1%-1/16W-0402-TAP; signal model: R2_6013A008840P_20_5K_1%_2; room: Sheet114
R67401 = RSC_0402: part number: RSC_0402-10K_1%_2,60130B10029Z,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-10K-1%-1/16W-0402-TAP; signal model: R2_60130B10029Z_10K_1%_2; room: Sheet114
R67405 = RSC_0402: part number: RSC_0402-10K_5%_2,60130B1030ZT,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP,10K,5%,1/16W,0402,TR; signal model: R2_60130B1030ZT_10K_5%_2; room: Sheet114
R67415 = RSC_0603: part number: RSC_0603-0_5%_3,60130B00000Z,RSC_160X080X055_2,0.7MM,RSC_0603,0603,RES-CHIP-0-5%-1/10W-TAP; signal model: R2_60130B00000Z_0_5%_3; room: Sheet114
R67416 = RSC_0603: part number: RSC_0603-RSC_0603,RSC_0603,RSC_160X080X080_2,0.95MM,RSC_0603,0603,RSC_0603; signal model: R2_RSC_0603_RSC_0603; room: Sheet114
R67420 = RSC_0402: part number: RSC_0402-1K_1%_2,60130B10019Z,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-1K-1%-1/16W-0402-TAP; signal model: R2_60130B10019Z_1K_1%_2; room: Sheet114
R67600 = RSC_0402: part number: RSC_0402-68K_1%_2,6013B0095701,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP,68K,1%,1/16W,0402,TAP; signal model: R2_6013B0095701_68K_1%_2; room: Sheet113
R67601 = RSC_0402: part number: RSC_0402-100K_1%_2,6013A0014701,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-100K-1%-1/16W-0402-TAP; signal model: R2_6013A0014701_100K_1%_2; room: Sheet113
S2-S7 S9 = SCREW_1: part number: SCREW_1-SCREW420_700_1P,SCREW420_700_1P,SCREW420_700_1P,0.127MM,SCREW_1,SCREW420_700_1P; room: Sheet25
S10 S16 = SCREW_1: part number: SCREW_1-SCREW280_850_700_1P,SCREW280_850_700_1P,SCREW280_850_700_1P,0.0003MM,SCREW_1,SCREW280_850_700_1P; room: Sheet25
S11 = SCREW_1: part number: SCREW_1-SCREW280_900_550_NP_1P,SCREW280_900_550_NP_1P,SCREW280_900_550_NP_1P,0.0003MM,SCREW_1,SCREW280_900_550_NP_1P; room: Sheet25
S12 = SCREW_1: part number: SCREW_1-SCREW390_700_1P,SCREW390_700_1P,SCREW390_700_1P,0.127MM,SCREW_1,SCREW390_700_1P; room: Sheet127
S13-S15 = SCREW_1: part number: SCREW_1-SCREW280_700_1P,SCREW280_700_1P,SCREW280_700_1P,0.127MM,SCREW_1,SCREW280_700_1P; room: Sheet127
S17-S24 = SCREW_1: part number: SCREW_1-SCREW280_700_1P,SCREW280_700_1P,SCREW280_700_1P,0.127MM,SCREW_1,SCREW280_700_1P; room: Sheet25
S25 S27 = SCREW_1: part number: SCREW_1-SCREW390_850_700_1P,SCREW390_850_700_1P,SCREW390_850_700_1P,0.0003MM,SCREW_1,SCREW390_850_700_1P; room: Sheet25
S26 = SCREW_1: part number: SCREW_1-SCREW390_1160_850_1P,SCREW390_1160_850_1P,SCREW390_1160_850_1P,0.0003MM,SCREW_1,SCREW390_1160_850_1P; room: Sheet25
S28 = SCREW_1: part number: SCREW_1-SCREW500_800_NP_1P,SCREW500_800_NP_1P,SCREW500_800_NP_1P,0.0003MM,SCREW_1,SCREW500_800_NP_1P; room: Sheet120
S33 S34 = SCREW_1: part number: SCREW_1-SCREW500_900_NP_1P,SCREW500_900_NP_1P,SCREW500_900_NP_1P,0.0003MM,SCREW_1,SCREW500_900_NP_1P; room: Sheet120
S35 = SCREW_1: part number: SCREW_1-SCREW280_900_700_1P,SCREW280_900_700_1P,SCREW280_900_700_1P,0.0003MM,SCREW_1,SCREW280_900_700_1P; room: Sheet25
ST1300 = STDPAD_1: part number: STDPAD_1-STANDOFF_3.2_6.0,6052B0407801,STD_R_FF45031_D30007_M20375_SN,3.33MM,STDPAD_1,STANDOFF,FF,M2.0,3.75MM,4.5MM,RND,SN,3.1MM; room: Sheet57
ST1900 = STDPAD_1: part number: STDPAD_1-STANDOFF_3.2_6.0,6052B0407801,STD_R_FF45031_D30007_M20375_SN,3.33MM,STDPAD_1,STANDOFF,FF,M2.0,3.75MM,4.5MM,RND,SN,3.1MM; room: Sheet121
ST1901 ST1903 = STDPAD_1: part number: STDPAD_1-STANDOFF_3.2_6.0,6052B0407801,STD_R_FF45031_D30007_M20375_SN,3.33MM,STDPAD_1,STANDOFF,FF,M2.0,3.75MM,4.5MM,RND,SN,3.1MM; room: Sheet59
ST1902 = STDPAD_1: part number: STDPAD_1-STANDOFF_3.2_6.0,6052B0407801,STD_R_FF45031_D30007_M20375_SN,3.33MM,STDPAD_1,STANDOFF,FF,M2.0,3.75MM,4.5MM,RND,SN,3.1MM; room: Sheet58
SW1 = T1A2QR: part number: T1A2QR-DIPTRONICS_T1A2QR_4P,6026B0421001,SWCH-TACT_DIP_4_SMD_V_060,0.85MM,,SWITCH,TACT,4P,STR,SMD,TR; room: Sheet120
TP16 = TPX_1: part number: TPX_1-TP24,TPX24,TP24,0.127MM,TPX_1,TP24; room: Sheet42
TP306 TP307 = TPX_1: part number: TPX_1-TP24,TPX24,TP24,0.127MM,TPX_1,TP24; room: Sheet51
TP400-TP403 = TPX_1: part number: TPX_1-TP26,TPX26,SMDTEST26,0.127MM,TPX_1,TP26; room: Sheet124
TP1300 TP1307 = TPX_1: part number: TPX_1-TP26,TPX26,SMDTEST26,0.127MM,TPX_1,TP26; room: Sheet57
TP1700 = TPX_1: part number: TPX_1-TP26,TPX26,SMDTEST26,0.127MM,TPX_1,TP26; room: Sheet65
TP1900 TP1901 = TPX_1: part number: TPX_1-TP26,TPX26,SMDTEST26,0.127MM,TPX_1,TP26; room: Sheet58
TP1902 TP1903 = TPX_1: part number: TPX_1-TP26,TPX26,SMDTEST26,0.127MM,TPX_1,TP26; room: Sheet59
TP2400 = TPX_1: part number: TPX_1-TP26,TPX26,SMDTEST26,0.127MM,TPX_1,TP26; room: Sheet60
TP4300-TP4303 = TPX_1: part number: TPX_1-TP24,TPX24,TP24,0.127MM,TPX_1,TP24; room: Sheet24
TP4450 = TPX_1: part number: TPX_1-TP24,TPX24,TP24,0.127MM,TPX_1,TP24; room: Sheet49
TP4500 = TPX_1: part number: TPX_1-TP24,TPX24,TP24,0.127MM,TPX_1,TP24; room: Sheet27
TP4501-TP4513 = TPX_1: part number: TPX_1-TP24,TPX24,TP24,0.127MM,TPX_1,TP24; room: Sheet30
TP4523 TP4526-TP4528 = TPX_1: part number: TPX_1-TP24,TPX24,TP24,0.127MM,TPX_1,TP24; room: Sheet32
TP4524 = TPX_1: part number: TPX_1-TP24,TPX24,TP24,0.127MM,TPX_1,TP24; room: Sheet29
TP4525 = TPX_1: part number: TPX_1-TP24,TPX24,TP24,0.127MM,TPX_1,TP24; room: Sheet35
TP4600 TP4601 = TPX_1: part number: TPX_1-TP24,TPX24,TP24,0.127MM,TPX_1,TP24; room: Sheet46
TP4700 TP4701 TP4703 TP4705 = TPX_1: part number: TPX_1-TP24,TPX24,TP24,0.127MM,TPX_1,TP24; room: Sheet39
TP4702 TP4713 TP4714 = TPX_1: part number: TPX_1-TP24,TPX24,TP24,0.127MM,TPX_1,TP24; room: Sheet36
TP4704 = TPX_1: part number: TPX_1-TP24,TPX24,TP24,0.127MM,TPX_1,TP24; room: Sheet38
TP4708-TP4711 = TPX_1: part number: TPX_1-TP24,TPX24,TP24,0.127MM,TPX_1,TP24; room: Sheet43
TP4800-TP4803 TP4807 = TPX_1: part number: TPX_1-TP24,TPX24,TP24,0.127MM,TPX_1,TP24; room: Sheet44
TP4804-TP4806 = TPX_1: part number: TPX_1-TP24,TPX24,TP24,0.127MM,TPX_1,TP24; room: Sheet40
TP5631 TP51300 = TPX_1: part number: TPX_1-TP24,TPX24,TP24,0.127MM,TPX_1,TP24; room: Sheet87
TP50010 TP50021 TP50022 = TPX_1: part number: TPX_1-TP24,TPX24,TP24,0.127MM,TPX_1,TP24; room: Sheet74
TP50100 = TPX_1: part number: TPX_1-TP24,TPX24,TP24,0.127MM,TPX_1,TP24; room: Sheet75
TP50200 = TPX_1: part number: TPX_1-TP24,TPX24,TP24,0.127MM,TPX_1,TP24; room: Sheet76
TP50300 = TPX_1: part number: TPX_1-TP24,TPX24,TP24,0.127MM,TPX_1,TP24; room: Sheet77
TP50400 = TPX_1: part number: TPX_1-TP24,TPX24,TP24,0.127MM,TPX_1,TP24; room: Sheet78
TP51511 TP51521 TP51522 TP51531 TP51532 TP51545 TP51550 TP53930 = TPX_1: part number: TPX_1-TP24,TPX24,TP24,0.127MM,TPX_1,TP24; room: Sheet89
TP52120 TP52121 = TPX_1: part number: TPX_1-TP24,TPX24,TP24,0.127MM,TPX_1,TP24; room: Sheet99
TP52200 TP52230 TP52231 = TPX_1: part number: TPX_1-TP24,TPX24,TP24,0.127MM,TPX_1,TP24; room: Sheet100
TP53500-TP53502 TP53510 TP53540 TP53551 TP53572 TP53582 TP53590 TP53592 = TPX_1: part number: TPX_1-TP24,TPX24,TP24,0.127MM,TPX_1,TP24; room: Sheet105
TP56630 TP56631 = TPX_1: part number: TPX_1-TP24,TPX24,TP24,0.127MM,TPX_1,TP24; room: Sheet96
TP60000 TP60002 = TPX_1: part number: TPX_1-TP24,TPX24,TP24,0.127MM,TPX_1,TP24; room: Sheet8
TP60100-TP60102 TP60191 = TPX_1: part number: TPX_1-TP24,TPX24,TP24,0.127MM,TPX_1,TP24; room: Sheet12
TP60200 TP60201 = TPX_1: part number: TPX_1-TP24,TPX24,TP24,0.127MM,TPX_1,TP24; room: Sheet10
TP60250 TP60251 = TPX_1: part number: TPX_1-TP24,TPX24,TP24,0.127MM,TPX_1,TP24; room: Sheet11
TP60300 TP60301 TP60350 TP60351 = TPX_1: part number: TPX_1-TP24,TPX24,TP24,0.127MM,TPX_1,TP24; room: Sheet13
TP60400 TP60401 = TPX_1: part number: TPX_1-TP24,TPX24,TP24,0.127MM,TPX_1,TP24; room: Sheet15
TP60500 TP60501 = TPX_1: part number: TPX_1-TP24,TPX24,TP24,0.127MM,TPX_1,TP24; room: Sheet17
TP60600 TP60601 = TPX_1: part number: TPX_1-TP24,TPX24,TP24,0.127MM,TPX_1,TP24; room: Sheet14
TP60900 TP60901 = TPX_1: part number: TPX_1-TP24,TPX24,TP24,0.127MM,TPX_1,TP24; room: Sheet16
TP66000 = TPX_1: part number: TPX_1-TP24,TPX24,TP24,0.127MM,TPX_1,TP24; room: Sheet19
TP66001 = TPX_1: part number: TPX_1-TP24,TPX24,TP24,0.127MM,TPX_1,TP24; room: Sheet18
TP66300 = TPX_1: part number: TPX_1-TP24,TPX24,TP24,0.127MM,TPX_1,TP24; room: Sheet20
TP66600 = TPX_1: part number: TPX_1-TP24,TPX24,TP24,0.127MM,TPX_1,TP24; room: Sheet21
TP67000 = TPX_1: part number: TPX_1-TP24,TPX24,TP24,0.127MM,TPX_1,TP24; room: Sheet109
TP67001 = TPX_1: part number: TPX_1-TP24,TPX24,TP24,0.127MM,TPX_1,TP24; room: Sheet108
TP67200 TP67201 = TPX_1: part number: TPX_1-TP24,TPX24,TP24,0.127MM,TPX_1,TP24; room: Sheet112
TP67400 TP67401 = TPX_1: part number: TPX_1-TP24,TPX24,TP24,0.127MM,TPX_1,TP24; room: Sheet114
TP67600 TP67601 = TPX_1: part number: TPX_1-TP24,TPX24,TP24,0.127MM,TPX_1,TP24; room: Sheet113
U1 = IT8987E_CX: part number: IT8987E_CX-ITE_IT8987E_CX_LQFP_128P_HP,6019B1650401,LQFP_1400X1400X160_128_040,1.7MM,,IC,EMBEDDED CONTROLLER,LQFP,128P,TR; room: Sheet51
U2 U7002 U7003 = APL3523A: part number: APL3523A-ANPEC_APL3523A_TDFN_14P,6019B1184301-001,KK-6019B1184301-001,0.95MM,,IC,LOAD SWITCH,WSON,14P,TR; room: Sheet22
U8 = VP225: part number: VP225-VIA_VP225_DFN_10P,6019B1742501,DFN_300X300X080_10_050_T6,0.9MM,,IC,USB CONTROLLER,3A,DFN,10P,TR; room: Sheet60
U50 = MH255EST: part number: MH255EST-MST_MH255ESP_PSOT23_3P,6019B1548301,IC-HALL_MST_3_SMD_105,1.22MM,,IC,MICROPOWER HALL SWITCH,PSOT-23,3P,TR; room: Sheet120
U250 = MH255EST: part number: MH255EST-MST_MH255ESP_PSOT23_3P,6019B1548301,IC-HALL_MST_3_SMD_105,1.22MM,,IC,MICROPOWER HALL SWITCH,PSOT-23,3P,TR; room: Sheet118
U300 = W25Q64FVSSIG: part number: W25Q64FVSSIG-WINB_W25Q128JVSIQ_SOIC_8P,6019B1604101,SOP_528X528X216_8_127,2.26MM,,IC,FLASH MEMORY,128M,-40~+85C,2.7~3.6V,104MHZ,4KBYTE,SOIC-8 (208MIL),8P,TR; room: Sheet50
U400 = E2500_RIV1_RL: part number: E2500_RIV1_RL-RIVET_E2500_RIV1_RL_QFN_40P,6019B1848201,QFN_500X500X090_40_040_T2,1MM,,IC,ETHERNET CONTROLLER,10/100/1000M,PCI-EXPRESS,QFN,40P,TR; room: Sheet124
U401 = NA0069RLF: part number: NA0069RLF-BOTH_NA0069RLF_SMD_24P,6016B0013101,SOP_1560X850X240_24_127,2.55MM,,TRANSFORMER,1000,SMD,24P,TR; room: Sheet125
U500 = ALC255_CG: part number: ALC255_CG-REA_ALC255_CG_MQFN_48P,6019B1330401,MQFN_600X600X100_48_040_T1,1.15MM,,IC,AUDIO CODEC,4 CHANNEL,CLASS D,MQFN,48; room: Sheet54
U702 = TLC59116: part number: TLC59116-TI_TLC59116_VQFN_32P,6019B1560201,VQFN_500X500X100_32_050_T2,1.15MM,,IC,LED DRIVER,QFN,32P,TR; room: Sheet118
U1300 = TPS22965DSGR: part number: TPS22965DSGR-ANPEC_APL3526QBI_TRG_TDFN_8P,6019B1195501,TDFN_200X200X080_8_050_T6,0.95MM,,IC,LOAD SWITCH,WSON,8P,TR; room: Sheet57
U1700 = PI3EQX12902A: part number: PI3EQX12902A-PERICOM_PI3EQX12902A_TQFN_30P,6019B1760401,TQFN_450X250X080_30_040_T1,0.9MM,,IC,REPEATER/REDRIVER,PCIE3.0/SATA3.0,TQFN,30P,TR; room: Sheet65
U2400 = G524B1T11U: part number: G524B1T11U-GMT_G524B1T11U_SOT23_5P,6019B1124501,TSOT23_290X160X125_5_095,1.40MM,,IC,POWER SWITCH,SOT-23-5,5P,TR; room: Sheet121
