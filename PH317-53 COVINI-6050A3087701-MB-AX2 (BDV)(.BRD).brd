# Allegro board PH317-53 COVINI-6050A3087701-MB-AX2 (BDV)(.BRD).brd (continued)
## Library data of the parts (continued)
C67200 C67201 = CAP_AL_SP: part number: CAP_AL_SP-330UF_2V_9MR_PANA_-35%,6010B0136301,CS_730X430X210_2,2.25MM,CAP_AL_SP,7.3X4.3,,CAPACITOR-AL-SP,330UF,2V,-35%/+10%,105C,DX1.9,SMD,TR,9MOHM; signal model: C2_6010B0136301_330uF_2V_9mR_Pana_-35%; room: Sheet112
C67202-C67204 = CSC0603: part number: CSC0603-22UF_6.3V_3,6010B0219001,CSC_160X080X090_2,1.05MM,CSC0603,0603,,CAPACITOR-CHIP,22UF,6.3V,R6,0603,TR; signal model: C2_6010B0219001_22UF_6_3V_3; room: Sheet112
C67209 = CSC0603: part number: CSC0603-2.2UF_6.3V_3,6010B0392401,CSC_160X080X090_2,1.00MM,CSC0603,0603,,CAPACITOR-CHIP,2.2UF,6.3V,K,X5R,0603,TR,0.8MM; signal model: C2_6010B0392401_2_2UF_6_3V_3; room: Sheet112
C67210 C67211 C67220 C67221 = CSC0805: part number: CSC0805-10UF_25V_5,6010B0150801,CSC_200X125X140_2,1.55MM,CSC0805,0805,X5R,CAP-CHIP,10UF,25V,K,X5R,0805,TR,1.25MM; signal model: C2_6010B0150801_10UF_25V_5; room: Sheet112
C67212 = CSC0603: part number: CSC0603-0.1UF_25V_3,6010A0057701-003,RANGER11-6010A0057701-003,0.95MM,CSC0603,0603,X7R,CAP-CHIP,0.1UF,25V,K,X7R,0603,TR; signal model: C2_6010A0057701-003_0_1uF_25V_3; room: Sheet112
C67215 C67225 C67234 = CSC0402: part number: CSC0402-0.1UF_16V_2,6010A0036403,CSC_100X050X040_2,0.55MM,CSC0402,0402,X7R,CAP-CHIP,0.1UF,16V,K,X7R,0402,TAP; signal model: C2_6010A0036403_0_1uF_16V_2; room: Sheet112
C67216 C67226 C67230-C67233 C67236 = CSC0402: part number: CSC0402-CSC0402,CSC0402,CSC_100X050X040_2,0.55MM,CSC0402,0402,,CSC0402; signal model: C2_CSC0402_CSC0402; room: Sheet112
C67218 = CSC0603: part number: CSC0603-1UF_25V_3,6010B0067602,CSC_160X080X080_2,0.90MM,CSC0603,0603,,CAPACITOR-CHIP,1UF,25V,K,X5R,0603,TR; signal model: C2_6010B0067602_1uF_25V_3; room: Sheet112
C67219 = CSC0402: part number: CSC0402-CSC0402_DY,CSC0402_DY,CSC_100X050X040_2,0.55MM,CSC0402,0402,,CSC0402_OPEN; signal model: C2_CSC0402_DY_CSC0402_DY; room: Sheet112
C67222 = CSC0603: part number: CSC0603-0.1UF_25V_3,6010A0057701,CSC_160X080X080_2,0.95MM,CSC0603,0603,X7R,CAP-CHIP,0.1UF,25V,K,X7R,0603,TR; signal model: C2_6010A0057701_0_1uF_25V_3; room: Sheet112
C67235 = CSC0402: part number: CSC0402-4700PF_50V_2,6010A0029301,CSC_100X050X040_2,0.55MM,CSC0402,0402,X7R,CAP-CHIP-472-K,50V-X7R-0402-TAP; signal model: C2_6010A0029301_4700pF_50V_2; room: Sheet112
C67298 C67299 = CAP_AL_SP: part number: CAP_AL_SP-15UF_25V,6010B0185101,CS_350X280X200_2,2.15MM,CAP_AL_SP,,,CAPACITOR-TA-SP,15UF,25V,M,105C,BX1.9,SM; signal model: C2_6010B0185101_15uF_25V; room: Sheet112
C67400-C67403 = CSC0603: part number: CSC0603-22UF_6.3V_3,6010B0219001,CSC_160X080X090_2,1.05MM,CSC0603,0603,,CAPACITOR-CHIP,22UF,6.3V,R6,0603,TR; signal model: C2_6010B0219001_22UF_6_3V_3; room: Sheet114
C67404 = CSC0603: part number: CSC0603-CSC0603,CSC0603,CSC_160X080X080_2,0.95MM,CSC0603,0603,,CSC0603; signal model: C2_CSC0603_CSC0603; room: Sheet114
C67409 = CSC0402: part number: CSC0402-4.7UF_6.3V_2,6010B0164602,CSC_100X050X065_2,0.75MM,CSC0402,0402,X5R,CAPACITOR-CHIP,4.7UF,6.3V,M,X5R,0402,TR,0.5MM; signal model: C2_6010B0164602_4_7UF_6_3V_2; room: Sheet114
C67410 C67411 = CSC0805: part number: CSC0805-10UF_25V_5,6010B0150801,CSC_200X125X140_2,1.55MM,CSC0805,0805,X5R,CAP-CHIP,10UF,25V,K,X5R,0805,TR,1.25MM; signal model: C2_6010B0150801_10UF_25V_5; room: Sheet114
C67412 C67415 = CSC0402: part number: CSC0402-0.1UF_25V_2,6010B0087101,CSC_100X050X040_2,0.55MM,CSC0402,0402,X5R,CAP-CHIP,0.1UF,25V,K,X5R,0402,TR; signal model: C2_6010B0087101_0_1uF_25V_2; room: Sheet114
C67416 = CSC0402: part number: CSC0402-CSC0402,CSC0402,CSC_100X050X040_2,0.55MM,CSC0402,0402,,CSC0402; signal model: C2_CSC0402_CSC0402; room: Sheet114
C67420 = CSC0402: part number: CSC0402-220PF_50V_2,6010B0076701,CSC_100X050X040_2,0.55MM,CSC0402,0402,C0G,CAP-CHIP,220PF,50V,J,C0G,0402,TR; signal model: C2_6010B0076701_220pF_50V_2; room: Sheet114
C67430 = CSC0402: part number: CSC0402-1UF_10V_2,6010B0055001,CSC_100X050X040_2,0.55MM,CSC0402,0402,X5R,CAP-CHIP,1UF,10V,K,X5R,0402,TR; signal model: C2_6010B0055001_1uF_10V_2; room: Sheet114
C67600 = CSC0603: part number: CSC0603-22UF_6.3V_3,6010B0219001,CSC_160X080X090_2,1.05MM,CSC0603,0603,,CAPACITOR-CHIP,22UF,6.3V,R6,0603,TR; signal model: C2_6010B0219001_22UF_6_3V_3; room: Sheet113
C67601 = CSC0402: part number: CSC0402-CSC0402_DY,CSC0402_DY,CSC_100X050X040_2,0.55MM,CSC0402,0402,,CSC0402_OPEN; signal model: C2_CSC0402_DY_CSC0402_DY; room: Sheet113
C67609 = CSC0402: part number: CSC0402-0.1UF_16V_2,6010A0036403,CSC_100X050X040_2,0.55MM,CSC0402,0402,X7R,CAP-CHIP,0.1UF,16V,K,X7R,0402,TAP; signal model: C2_6010A0036403_0_1uF_16V_2; room: Sheet113
C67610 = CSC0603: part number: CSC0603-10UF_6.3V_3,6010B0044902,CSC_160X080X095_2,1.05MM,CSC0603,0603,,CAPACITOR-CHIP,10UF,6.3V,M,X5R,0603,TR; signal model: C2_6010B0044902_10uF_6_3V_3; room: Sheet113
CN1 CN2 = CN_04_2G: part number: CN_04_2G-ACES_50505_00401_001_4P,6012B0317706,FPC_ACES_4_100_R_160,1.85MM,,CONNECTOR,FPC,1.5MM,FL,BLK,1X4,1.0MM,90D; room: Sheet120
CN5 = CN_40_5G: part number: CN_40_5G-ACES_51398_0407T_001_40P,6012B0773101,WTB_ACES_40_050_SMD_V_F_140_2,1.75MM,,CONNECTOR,W TO B,FL,BLK,1X40,0.5MM,STR,SMD,TR; room: Sheet62
CN8 = CN_08: part number: CN_08-ACES_50290_00801_001_8P,6012B1061701,WTB_ACES_8_150_SMD_R_M_445,4.75MM,,CONNECTOR,W TO B,1X8,1.5MM,90D,LCP,TR; room: Sheet7
CN250 = CN_28_2G: part number: CN_28_2G-ENTERY_6905K_E28N_00R_28P,6012B1002701,FPC_ENTRY_28_100_R_200,2.35MM,,CONNECTOR,FPC,2.0MM,FL,1X28,1.0MM,90D,SMD,TR,TIN; room: Sheet52
CN251 = CN_04_2G: part number: CN_04_2G-ACES_50505_00401_001_4P,6012B0317706,FPC_ACES_4_100_R_160,1.85MM,,CONNECTOR,FPC,1.5MM,FL,BLK,1X4,1.0MM,90D; room: Sheet52
CN252 = 51619_01401_001: part number: 51619_01401_001-ACES_51619_01401_001_14P,6012B0899601,FPC_ACES_14_050_R_200_4,2.4MM,,ACES_51619-01401-001; room: Sheet118
CN253 CN254 = CN_04_2G: part number: CN_04_2G-ACES_50505_00401_001_4P,6012B0317706,FPC_ACES_4_100_R_160,1.85MM,,CONNECTOR,FPC,1.5MM,FL,BLK,1X4,1.0MM,90D; room: Sheet118
CN280 = CN_08_2G: part number: CN_08_2G-ENTERY_6916K_Q08N_08L_8P,6012B0245916,FPC_ENTRY_8_100_R_205,2.35MM,,CONNECTOR,FPC,2.0MM,FL,BLK,1X8,1.0MM,90D,SMD,TR; room: Sheet53
CN301 = CN_10_2G: part number: CN_10_2G-ACES_50696_0100M_001_10P,6012B0430403,FPC_ACES_10_050_R_105,1.15MM,,CONNECTOR,FPC,1.0MM,FL,1X10,0.5MM,90D,SMD,TR,GOLD,3U; room: Sheet51
CN600 = CN_04_2G: part number: CN_04_2G-ACES_50224_00401_001_4P,6012B0069910,WTB_ACES_4_100_SMD_R_M_295,3.1MM,,CONNECTOR,W TO B,ML,1X4,90D,SMD,TR; room: Sheet126
CN601 = CN_50_2G: part number: CN_50_2G-ACES_51540_05001_001_50P,6012B0541005,FPC_ACES_50_050_R_180,2.20MM,,CONNECTOR,FPC,H 1.8MM,0.5MM,SMD; room: Sheet127
CN602 = CN_04_2G: part number: CN_04_2G-ACES_50224_00401_001_4P,6012B0069910,WTB_ACES_4_100_SMD_R_M_295,3.1MM,,CONNECTOR,W TO B,ML,1X4,90D,SMD,TR; room: Sheet127
CN603 = CN_50_2G: part number: CN_50_2G-ACES_51540_05001_001_50P,6012B0541005,FPC_ACES_50_050_R_180,2.20MM,,CONNECTOR,FPC,H 1.8MM,0.5MM,SMD; room: Sheet64
CN604 = CN_04_2G: part number: CN_04_2G-ACES_50224_00401_001_4P,6012B0069910,WTB_ACES_4_100_SMD_R_M_295,3.1MM,,CONNECTOR,W TO B,ML,1X4,90D,SMD,TR; room: Sheet64
CN1300 = APCI0062_P001A: part number: APCI0062_P001A-LOTES_APCI0062_P001A_NGFF_E_KEY_75P,6026B0276201-002,COVINI-6026B0276201-002,2.13MM,,SOCKET,PCIEX KEY E NGFF,75P,0.5MM,GOLD FLASH,20D,SMD,TR; room: Sheet57
CN1700 = CN_10_2G: part number: CN_10_2G-ACES_51540_01041_Q01_10P,6012B0541002,FPC_ACES_10_050_R_180_1,1.95MM,,ACES_51540-01041-Q01_10P; room: Sheet56
CN1900 = APCI0020_P003A: part number: APCI0020_P003A-LOTUS_APCI0107_P001H_75P,6026B0436901-001,COVINI-6026B0436901-001,4.35MM,,SOCKET,PCIEX KEY M NGFF,75P,0.5MM,GOLD FLASH,20D,SMD,TR; room: Sheet59
CN1901 = APCI0020_P003A: part number: APCI0020_P003A-LOTUS_APCI0107_P001H_75P,6026B0436901-001,COVINI-6026B0436901-001,4.35MM,,SOCKET,PCIEX KEY M NGFF,75P,0.5MM,GOLD FLASH,20D,SMD,TR; room: Sheet58
CN2400 = CN_09_4G_USB30: part number: CN_09_4G_USB30-TCONN_18_35690_1A63_0_9P,6012B1062301,USB3_TCONN_9_DIP_RS_S_040_326_1,3.61MM,,CONNECTOR,USB3.0,9P,90D,DIP,TR; room: Sheet121
CN2401 = CN_09_4G_USB30: part number: CN_09_4G_USB30-TCONN_18_35690_1A63_0_9P,6012B1062301,USB3_TCONN_9_DIP_RS_S_040_326_1,3.61MM,,CONNECTOR,USB3.0,9P,90D,DIP,TR; room: Sheet122
CN2500 = AUSB0152_P402A: part number: AUSB0152_P402A-SINGATRON_2UB3C02_101211F_24P,6012B0909301,USB31_SIGAT_24_DIP_S_060_193_1,2.28MM,,SINGATRON_2UB3C02_101211F_24P; room: Sheet60
CN2501 = CN_09_4G_USB30: part number: CN_09_4G_USB30-TCONN_18_35690_1A63_0_9P,6012B1062301,USB3_TCONN_9_DIP_RS_S_040_326_1,3.61MM,,CONNECTOR,USB3.0,9P,90D,DIP,TR; room: Sheet61
CN4100 = AS0A821_H2SB_7H: part number: AS0A821_H2SB_7H-ARGOSY_D4AR0_26010_1P52_260P,6026B0375701-001,COVINI-6026B0375701-001,5.85MM,,SOCKET,DDR4,260P,0.5MM,GOLD,10U,5.2MM,30D,SMD,REVERSE,TR; room: Sheet47
CN4125 = AS0A821_H2SB_7H: part number: AS0A821_H2SB_7H-ARGOSY_D4AS0_26001_1P52_260P,6026B0363901-001,COVINI-6026B0363901-001,5.6MM,,SOCKET,DDR4,260P,5.2MM,SMD,STANDARD,TR; room: Sheet48
CN4300 CN4301 = CN_04_2G: part number: CN_04_2G-ACES_50279_00401_Q01_4P,6012B0000520,WTB_ACES_4_125_SMD_R_M_215,2.35MM,,CONNECTOR\W TO B; room: Sheet24
CN4700 = 50224_0020N_001: part number: 50224_0020N_001-ACES_50224_0020N_001_2P,6012B1052801,WTB_ACES_2_100_SMD_R_M_295_4,3.45MM,,CONNECTOR,W TO B,1.0MM,MALE,1X2,90D,SMD,TR; room: Sheet42
CN6050 = CN_08_2G: part number: CN_08_2G-ACES_50458_00801_Q01_8P,6012B1061601,WTB_ACES_8_200_SMD_R_M_226_2,2.71MM,,CONNECTOR,W TO B,2.0MM,BLK,1X8,2.0MM,90D,SMD,TR,LCP,G/F; room: Sheet9
CN56200 = C17711_120A9_L: part number: C17711_120A9_L-TCONN_22_M0081_1003_0_20P,6012B0760101-001,COVINI-6012B0760101-001,2.72MM,,CONNECTOR,MINI DP,-0.33/2.37MM,ML,BLK,20P,90D,DIP,TR,LCP,G/F; room: Sheet93
CN56600 = CN_19_4G: part number: CN_19_4G-TCONN_116B_2D023_20N_19P,6012B0884601,HDMI_TCONN_19_RS_051_328,3.63MM,,CONN,HDMI,GLD,19P,0.5MM,90D,DIP,TR; room: Sheet96
D1 = SFI0402ML120C_LF: part number: SFI0402ML120C_LF-SFI_SFI0402ML120C_LF_SMD_2P_DY,6011B0130001_DY,DS_100X050X060_2_S2,0.75MM,,DIODE,TVS,12V,10A,SMD,TR; room: Sheet120
D101 = 12_22UYOSUBC_S530_A4_TR8: part number: 12_22UYOSUBC_S530_A4_TR8-EVL_12_22UYOSUBC_S530_A4_TR8_3P,6011B0102001,LED_EVERLI_R_D_300X200X100,1.15MM,,DIODE-LED,ORG/BLU,3010,52/20MCD,120D,SMD,3P,TR; room: Sheet123
D102 = LED_SINGLE: part number: LED_SINGLE-12_215_BHC_ZLMRY_3C,6011A0029102-004,PUMBAA-6011A0029102-004,0.6MM,LED_SINGLE,,,DIODE-LED-BLU-2106-17MCD-130D-5MA-SMD-2P-TR; room: Sheet123
D250-D258 = SFI0402ML120C_LF: part number: SFI0402ML120C_LF-SFI_SFI0402ML120C_LF_SMD_2P_DY,6011B0130001_DY,DS_100X050X060_2_S2,0.75MM,,DIODE,TVS,12V,10A,SMD,TR; room: Sheet52
D281-D283 = PESD5V2S2UT: part number: PESD5V2S2UT-LITEON_L30ESDXVC3_2_DSOT23_3P_DY,6011B0136901_DY,DSOT23_290X130X150_3_095,1.65MM,DIODE,ESD,5V,17A,300W,SMD,SOT23,TR; room: Sheet53
D300 = SCH_SINGLE_B: part number: SCH_SINGLE_B-DIODE-BAT54-TAP-PHP,60110GA0367T,DSOT23_290X130X110_3_095_P3,1.2MM,SCH_SINGLE_B,DIODE-BAT54-TAP-PHP; room: Sheet51
D402 D403 = AZ1045_04F_R7G: part number: AZ1045_04F_R7G-AMAZING_AZ1045_04F_R7G_10P,6011B0172501,DS_250X100X065_10_050,0.8MM,,DIODE-ESD,12V,0.5PF,15K/10K,DFN2510P10E,SMD,TR; signal model: D10_6011B0172501_AMAZING_AZ1045_04F_R7G_10P; room: Sheet125
D501 = AZ2015_01H: part number: AZ2015_01H-AMC_AZ2015_01H_SOD523_2P_DY,6011B0082901_DY,DSSOD523_120X080X070_2_150,0.85MM,,DIODE,ESD,6V,8.5A,SMD,SOD523,TR; room: Sheet54
D608-D611 = AZ5125_01H: part number: AZ5125_01H-AMC_AZ5125_01H_SOD523_2P,6011B0131701,DSOD523_120X080X070_2_150_P2,0.8MM,,DIODE,ESD,5V,SMD,SOD523,TR; room: Sheet126
D2400 = AZC099_04S_R7G: part number: AZC099_04S_R7G-AMC_AZC099_04S_R7G_SOT23_6P,6011B0158001,DSSOT23_290X160X145_6_095,1.6MM,,IC,ESD PROTECTION,SOT23,6P,TR; room: Sheet121
D2401 = AZ1045_04F_R7G: part number: AZ1045_04F_R7G-AMAZING_AZ1045_04F_R7G_10P,6011B0172501,DS_250X100X065_10_050,0.8MM,,DIODE-ESD,12V,0.5PF,15K/10K,DFN2510P10E,SMD,TR; signal model: D10_6011B0172501_AMAZING_AZ1045_04F_R7G_10P; room: Sheet121
D2402 = AZC099_04S_R7G: part number: AZC099_04S_R7G-AMC_AZC099_04S_R7G_SOT23_6P,6011B0158001,DSSOT23_290X160X145_6_095,1.6MM,,IC,ESD PROTECTION,SOT23,6P,TR; room: Sheet122
D2403 = AZ1045_04F_R7G: part number: AZ1045_04F_R7G-AMAZING_AZ1045_04F_R7G_10P,6011B0172501,DS_250X100X065_10_050,0.8MM,,DIODE-ESD,12V,0.5PF,15K/10K,DFN2510P10E,SMD,TR; signal model: D10_6011B0172501_AMAZING_AZ1045_04F_R7G_10P; room: Sheet122
D3000 = SWCH_SINGLE: part number: SWCH_SINGLE-1N4148WS_DY,6011B0157401_DY,DSOD323_185X125X095_2_231,1.05MM,SWCH_SINGLE,,,DIODE,SWCH,100V,200MA,250MW,4NS,SMD,SOD323,TR; room: Sheet62
D4700 = SCH_DUAL_2IN_1OUT_A: part number: SCH_DUAL_2IN_1OUT_A-BAT54C_30V_0_6A,6011B0155101,DS_292X130X110_3_190,1.25MM,SCH_DUAL_2IN_1OUT_A,,,DIODE,SCH,30V,0.6A,225MW,DIP,SOT-23,TR; room: Sheet42
D4711 = SCH_SINGLE_B: part number: SCH_SINGLE_B-DIODE-BAT54-TAP-PHP,60110GA0367T,DSOT23_290X130X110_3_095_P3,1.2MM,SCH_SINGLE_B,DIODE-BAT54-TAP-PHP; room: Sheet42
D4801 = SCH_SINGLE_B: part number: SCH_SINGLE_B-DIODE-BAT54-TAP-PHP,60110GA0367T,DSOT23_290X130X110_3_095_P3,1.2MM,SCH_SINGLE_B,DIODE-BAT54-TAP-PHP; room: Sheet39
D6035 = SM24: part number: SM24-SEM_SM24_SOT23_3P_DY,6011B0102101_DY,DSSOT23_290X130X112_3_095,1.27MM,,DIODE,TVS,24V,5A,300W,SMD,SOT23,TR; room: Sheet7
D6098 = D_DUAL_SERIES_A: part number: D_DUAL_SERIES_A-BAV99,60110GA0450T,DSSOT23_290X130X110_3_095-2,1.25MM,D_DUAL_SERIES_A,DIODE-BAV99-3P-SOT23-TAP-PHP CPQ; room: Sheet9
D7000 = SCH_SINGLE_B: part number: SCH_SINGLE_B-BAT54_30V_0.2A_DY,6011A0026801_DY,TSOT23_290X130X110_3_096_P1,1.25MM,SCH_SINGLE_B,DIODE-SCH-30V-200MA-200MW-5NS-SMD-SOT23-TR; room: Sheet23
D7001 D7002 D7004 D7005 = SCH_SINGLE_B: part number: SCH_SINGLE_B-DIODE-BAT54-TAP-PHP,60110GA0367T,DSOT23_290X130X110_3_095_P3,1.2MM,SCH_SINGLE_B,DIODE-BAT54-TAP-PHP; room: Sheet23
D7500 = AZ1065_06F: part number: AZ1065_06F-AMAZING_AZ1065_06F_10P,6011B0131301,DESD_410X200X055_10_080_T1,0.70MM,,DIODE,ESD; room: Sheet61
D7503-D7505 = AZ1045_04F_R7G: part number: AZ1045_04F_R7G-AMAZING_AZ1045_04F_R7G_10P,6011B0172501,DS_250X100X065_10_050,0.8MM,,DIODE-ESD,12V,0.5PF,15K/10K,DFN2510P10E,SMD,TR; signal model: D10_6011B0172501_AMAZING_AZ1045_04F_R7G_10P; room: Sheet60
D7521-D7523 D7533 D7534 = ESD: part number: ESD-AMAZING_AZ5525_01F_R7G_DFN1006P2X_2P_DY,6011B0227601_DY,DESD_100X060X050_2_085,0.60MM,,DIODE,ESD,5V,80A,DFN1006P2X,TR; room: Sheet126
D7600 = AZ5125_01H: part number: AZ5125_01H-AMC_AZ5125_01H_SOD523_2P_DY,6011B0131701_DY,DSOD523_120X080X070_2_150_P2,0.8MM,,DIODE,ESD,5V,SMD,SOD523,TR; room: Sheet9
D7601 D7602 = AZ5125_01H: part number: AZ5125_01H-AMC_AZ5125_01H_SOD523_2P,6011B0131701,DSOD523_120X080X070_2_150_P2,0.8MM,,DIODE,ESD,5V,SMD,SOD523,TR; room: Sheet9
D51510 = SCH_SINGLE_B: part number: SCH_SINGLE_B-DIODE-BAT54-TAP-PHP,60110GA0367T,DSOT23_290X130X110_3_095_P3,1.2MM,SCH_SINGLE_B,DIODE-BAT54-TAP-PHP; room: Sheet89
D53552 D53571 = SCH_SINGLE_B: part number: SCH_SINGLE_B-DIODE-BAT54-TAP-PHP,60110GA0367T,DSOT23_290X130X110_3_095_P3,1.2MM,SCH_SINGLE_B,DIODE-BAT54-TAP-PHP; room: Sheet105
D53581 = SCH_SINGLE_B: part number: SCH_SINGLE_B-DIODE-BAT54-TAP-PHP_DY,60110GA0367T_DY,DSOT23_290X130X110_3_095_P3,1.2MM,SCH_SINGLE_B,DIODE-BAT54-TAP-PHP; room: Sheet105
D56220 D56225 D56230 = AZ1045_04F_R7G: part number: AZ1045_04F_R7G-AMAZING_AZ1045_04F_R7G_10P,6011B0172501,DS_250X100X065_10_050,0.8MM,,DIODE-ESD,12V,0.5PF,15K/10K,DFN2510P10E,SMD,TR; signal model: D10_6011B0172501_AMAZING_AZ1045_04F_R7G_10P; room: Sheet93
D56222 = SFI0402ML120C_LF: part number: SFI0402ML120C_LF-SFI_SFI0402ML120C_LF_SMD_2P,6011B0130001,DS_100X050X060_2_S2,0.75MM,,DIODE,TVS,12V,10A,SMD,TR; room: Sheet93
D56610 = SFI0402ML120C_LF: part number: SFI0402ML120C_LF-SFI_SFI0402ML120C_LF_SMD_2P,6011B0130001,DS_100X050X060_2_S2,0.75MM,,DIODE,TVS,12V,10A,SMD,TR; room: Sheet96
D56650-D56652 = AZ1045_04F_R7G: part number: AZ1045_04F_R7G-AMAZING_AZ1045_04F_R7G_10P,6011B0172501,DS_250X100X065_10_050,0.8MM,,DIODE-ESD,12V,0.5PF,15K/10K,DFN2510P10E,SMD,TR; signal model: D10_6011B0172501_AMAZING_AZ1045_04F_R7G_10P; room: Sheet96
D60000 = SCH_DUAL_2IN_1OUT_A: part number: SCH_DUAL_2IN_1OUT_A-BAT54C_30V_0_6A,6011B0155101,DS_292X130X110_3_190,1.25MM,SCH_DUAL_2IN_1OUT_A,,,DIODE,SCH,30V,0.6A,225MW,DIP,SOT-23,TR; room: Sheet8
D60001 = SCH_DUAL_2IN_1OUT_A: part number: SCH_DUAL_2IN_1OUT_A-BAT54C_30V_0_6A_DY,6011B0155101_DY,DS_292X130X110_3_190,1.25MM,SCH_DUAL_2IN_1OUT_A,,,DIODE,SCH,30V,0.6A,225MW,DIP,SOT-23,TR; room: Sheet8
D60002 = SCH_DUAL_2IN_1OUT_A: part number: SCH_DUAL_2IN_1OUT_A-BAT54C_30V_0_6A,6011B0155101,DS_292X130X110_3_190,1.25MM,SCH_DUAL_2IN_1OUT_A,,,DIODE,SCH,30V,0.6A,225MW,DIP,SOT-23,TR; room: Sheet9
FIX1-FIX8 = FIX_MASK: part number: FIX_MASK-FIX_MASK,FIX_MASK,FIX_MASK,0.127MM,FIX_MASK,FIX_MASK; room: Sheet25
FIX9-FIX12 = FIX_MASK: part number: FIX_MASK-FIX_MASK,FIX_MASK,FIX_MASK,0.127MM,FIX_MASK,FIX_MASK; room: Sheet120
FIX13-FIX16 = FIX_MASK: part number: FIX_MASK-FIX_MASK,FIX_MASK,FIX_MASK,0.127MM,FIX_MASK,FIX_MASK; room: Sheet127
FUSE3000 = FUSE: part number: FUSE-1.5A_24V,6036B0093201-003,ASHMORE-6036B0093201-003,1.95MM,FUSE,FUSE,POLYMER,1.5A,24V,SMD,4.55X3.24,TR; room: Sheet62
FUSE3001 = POLY_SWCH: part number: POLY_SWCH-LITTELFUSE_0805L110ULYR,6036B0139401,FUSE_210X135X075_2_220,0.85MM,POLY_SWCH,FUSE,POLYMER,1.1A,6V,SMD,2.2X1.50,TR; room: Sheet62
JACK400 = 2RJ3076_058211F: part number: 2RJ3076_058211F-SINGATRON_2RJ3104_038211F_8P,6026B0455901,RJ45_SIGAT_8_SS_N_470,5.05MM,,JACK,RJ45,8P,GOLD FLASH,DOWN,DIP,TR; room: Sheet125
JACK600 = 2SJ3095_123111F: part number: 2SJ3095_123111F-SINGA_2SJ3095_123111F_7P,6026B0379501,AUDIO_SIGAT_6_R_050_200_1,2.45MM,,SINGA_2SJ3095_123111F_7P; room: Sheet126
L1 = BEAD_SINGLE: part number: BEAD_SINGLE-BLM15AG121SN1D_500MA,6014B0098001,LS_100X050X055_2,0.7MM,BEAD_SINGLE,,,,BEAD,120OHM,25%,500MA,0.25OHM,0402INCH,100MHZ,C,TR; signal model: L2_6014B0098001_BLM15AG121SN1D_500mA; room: Sheet51
L400 = IDUT_SINGLE: part number: IDUT_SINGLE-4.7UH_20%,6014B0206501,LS_250X200X120_2_170,1.35MM,IDUT_SINGLE,,,,INDUCTOR,4.7UH,20%,1MHZ,1.2A,2.5X2X1.2MM,SMD,TR; signal model: L2_6014B0206501_4_7uH_20%; room: Sheet124
L401 L402 = BEAD_SINGLE: part number: BEAD_SINGLE-HCB1608KF_221T20,6014B0157601,LS_160X080X095_2,1.1MM,BEAD_SINGLE,,,,BEAD,220OHM,25%,2A,0.1OHM,0603INCH,100MHZ,B,TR; signal model: L2_6014B0157601_HCB1608KF_221T20; room: Sheet124
L600 L601 = BEAD_SINGLE: part number: BEAD_SINGLE-BLM15AG121SN1D_500MA,6014B0098001,LS_100X050X055_2,0.7MM,BEAD_SINGLE,,,,BEAD,120OHM,25%,500MA,0.25OHM,0402INCH,100MHZ,C,TR; signal model: L2_6014B0098001_BLM15AG121SN1D_500mA; room: Sheet126
L1300 = CHOKE_4PIN_C: part number: CHOKE_4PIN_C-MCF12102G900-T_DY,6014B0247601_DY,LS_125X100X065_4_055,0.8MM,CHOKE_4PIN_C,CHOKE,90OHM,25%,100MA,185X70X190,0.25OHM,100MHZ,4P,TR; signal model: L4_6014B0247601_DY_MCF12102G900-T_DY; room: Sheet57
L2400 = CHOKE_4PIN_C: part number: CHOKE_4PIN_C-MCF12102G900-T,6014B0247601-001,CAESAR-6014B0247601-001,0.8MM,CHOKE_4PIN_C,CHOKE,90OHM,25%,100MA,185X70X190,0.25OHM,100MHZ,4P,TR; signal model: L4_6014B0247601-001_MCF12102G900-T; room: Sheet121
L2401 L2402 = CHOKE_4PIN_C: part number: CHOKE_4PIN_C-WCM_2012SHS_850T,6014B0219101,LS_200X120X140_4_080,1.55MM,CHOKE_4PIN_C,CHOKE,85OHM,25%,400MA,0805,0.3OHM,100MHZ; signal model: L4_6014B0219101_WCM_2012SHS_850T; room: Sheet121
L2403 = CHOKE_4PIN_C: part number: CHOKE_4PIN_C-MCF12102G900-T,6014B0247601-001,CAESAR-6014B0247601-001,0.8MM,CHOKE_4PIN_C,CHOKE,90OHM,25%,100MA,185X70X190,0.25OHM,100MHZ,4P,TR; signal model: L4_6014B0247601-001_MCF12102G900-T; room: Sheet122
L2404 L2405 = CHOKE_4PIN_C: part number: CHOKE_4PIN_C-WCM_2012SHS_850T,6014B0219101,LS_200X120X140_4_080,1.55MM,CHOKE_4PIN_C,CHOKE,85OHM,25%,400MA,0805,0.3OHM,100MHZ; signal model: L4_6014B0219101_WCM_2012SHS_850T; room: Sheet122
L2500 = CHOKE_4PIN_C: part number: CHOKE_4PIN_C-MCF12102G900-T,6014B0247601,LS_125X100X065_4_055,0.8MM,CHOKE_4PIN_C,CHOKE,90OHM,25%,100MA,185X70X190,0.25OHM,100MHZ,4P,TR; signal model: L4_6014B0247601_MCF12102G900-T; room: Sheet60
L2501 = CHOKE_4PIN_C: part number: CHOKE_4PIN_C-MCF12102G900-T,6014B0247601,LS_125X100X065_4_055,0.8MM,CHOKE_4PIN_C,CHOKE,90OHM,25%,100MA,185X70X190,0.25OHM,100MHZ,4P,TR; signal model: L4_6014B0247601_MCF12102G900-T; room: Sheet61
L3001 L3002 = CHOKE_4PIN_C: part number: CHOKE_4PIN_C-LS_SHORT_0504,LS_SHORT_0504,LS_SHORT_0504,0.127MM,CHOKE_4PIN_C,LS_SHORT_0504; signal model: L4_LS_Short_0504_LS_Short_0504; room: Sheet62
L4700 = CHOKE_4PIN_C: part number: CHOKE_4PIN_C-MCF12102G900-T,6014B0247601,LS_125X100X065_4_055,0.8MM,CHOKE_4PIN_C,CHOKE,90OHM,25%,100MA,185X70X190,0.25OHM,100MHZ,4P,TR; signal model: L4_6014B0247601_MCF12102G900-T; room: Sheet45
L6035 L6036 = BEAD_SINGLE: part number: BEAD_SINGLE-120OHM_25%_6A,6014B0225501,LS_200X125X110_2,1.25MM,BEAD_SINGLE,,,,BEAD,120OHM,25%,6A,0.02OHM,0805INCH,100M; signal model: L2_6014B0225501_120OHM_25%_6A; room: Sheet7
L50100 = BEAD_SINGLE: part number: BEAD_SINGLE-FBMA_11_160808_300A25T,6014B0049101,EMIS_BLM11,1.02MM,BEAD_SINGLE,,,,BEAD,30OHM,25%,1A,0.05OHM,0603INCH,100MHZ,C,TR; signal model: L2_6014B0049101_FBMA_11_160808_300A25T; room: Sheet75
L51300 = BEAD_SINGLE: part number: BEAD_SINGLE-FBMA_11_160808_300A25T,6014B0049101,EMIS_BLM11,1.02MM,BEAD_SINGLE,,,,BEAD,30OHM,25%,1A,0.05OHM,0603INCH,100MHZ,C,TR; signal model: L2_6014B0049101_FBMA_11_160808_300A25T; room: Sheet87
L52110 = BEAD_SINGLE: part number: BEAD_SINGLE-FBMA_11_160808_300A25T,6014B0049101,EMIS_BLM11,1.02MM,BEAD_SINGLE,,,,BEAD,30OHM,25%,1A,0.05OHM,0603INCH,100MHZ,C,TR; signal model: L2_6014B0049101_FBMA_11_160808_300A25T; room: Sheet99
L56220 L56221 L56225 L56226 = CHOKE_4PIN_C: part number: CHOKE_4PIN_C-WCM_2012SHS_850T,6014B0219101,LS_200X120X140_4_080,1.55MM,CHOKE_4PIN_C,CHOKE,85OHM,25%,400MA,0805,0.3OHM,100MHZ; signal model: L4_6014B0219101_WCM_2012SHS_850T; room: Sheet93
L56400-L56402 L56405 L56407 L56408 = BEAD_SINGLE: part number: BEAD_SINGLE-BLM15PD600SN1D,6014B0157701,LS_100X050X055_2,0.7MM,BEAD_SINGLE,,,,BEAD,60OHM,25%,1.7A,0.06OHM,0402INCH,100; signal model: L2_6014B0157701_BLM15PD600SN1D; room: Sheet95
L60000 = IDUT_SINGLE: part number: IDUT_SINGLE-PCMC063T_3R3MN,6014B0026103,LS_700X660X300_2_555,3.1MM,IDUT_SINGLE,,,,INDUCTOR,3.3UH,20%,100KHZ,6A,7.3X6.6X3.0MM,SMD,TR; signal model: L2_6014B0026103_PCMC063T_3R3MN; room: Sheet8
L60100 = IDUT_SINGLE: part number: IDUT_SINGLE-CYNTEC_PCMB062D_1R5MS,6014B0270201,LS_660X660X240_2_555,2.55MM,IDUT_SINGLE,,,,INDUCTOR,1.5UH,+/-20%,100KHZ,9A,6.95X6.6; signal model: L2_6014B0270201_CYNTEC_PCMB062D_1R5MS; room: Sheet12
L60200 = IDUT_SINGLE: part number: IDUT_SINGLE-PCMC063T_2R2MN,6014B0026106,LS_700X660X300_2_555,3.1MM,IDUT_SINGLE,,,,INDUCTOR,2.2UH,20%,100KHZ,8A,7.3X6.6X3.0MM,SMD,TR; signal model: L2_6014B0026106_PCMC063T_2R2MN; room: Sheet10
L60250 = CHOKE_4PIN_2PIN: part number: CHOKE_4PIN_2PIN-CYNTEC_PCMB051H_3R3MS,6014B0368601,LS_540X520X180_4_P2,1.9MM,CHOKE_4PIN_2PIN,,,,INDUCTOR,3.3UH,+/- 20%,100KHZ,4.5A,5.75X5.4X1.8MM,SMD,TR; signal model: L4_6014B0368601_CYNTEC_PCMB051H_3R3MS; room: Sheet11
L60300 = IDUT_4PIN: part number: IDUT_4PIN-CYN_PCMC063T_R68MN_4P,6014B0026107,LS_660X660X300_4_P3,3.1MM,IDUT_4PIN,,,,INDUCTOR,0.68UH,20%,100KHZ,15.5A,7.3X6.6X3.0MM,SMD,TR; signal model: L4_6014B0026107_CYN_PCMC063T_R68MN_4P; room: Sheet13
L60400 = INDUCTOR: part number: INDUCTOR-TAI_TECH_HPC4018B_2R2M,6014B0271901,LS_400X400X180_2_280,1.95MM,,,,,INDUCTOR,2.2UH,+/-20%,100KHZ,2.2A,4.0X4.0X1.8MM,SMD,TR; signal model: L2_6014B0271901_TAI_TECH_HPC4018B_2R2M; room: Sheet15
L60500 = IDUT_4PIN: part number: IDUT_4PIN-CYN_PCMC063T_R68MN_4P,6014B0026107,LS_660X660X300_4_P3,3.1MM,IDUT_4PIN,,,,INDUCTOR,0.68UH,20%,100KHZ,15.5A,7.3X6.6X3.0MM,SMD,TR; signal model: L4_6014B0026107_CYN_PCMC063T_R68MN_4P; room: Sheet17
L60600 = INDUCTOR: part number: INDUCTOR-TAI_TECH_HPC4018B_2R2M,6014B0271901,LS_400X400X180_2_280,1.95MM,,,,,INDUCTOR,2.2UH,+/-20%,100KHZ,2.2A,4.0X4.0X1.8MM,SMD,TR; signal model: L2_6014B0271901_TAI_TECH_HPC4018B_2R2M; room: Sheet14
L60900 = IDUT_4PIN: part number: IDUT_4PIN-CYN_PCMC063T_R68MN_4P,6014B0026107,LS_660X660X300_4_P3,3.1MM,IDUT_4PIN,,,,INDUCTOR,0.68UH,20%,100KHZ,15.5A,7.3X6.6X3.0MM,SMD,TR; signal model: L4_6014B0026107_CYN_PCMC063T_R68MN_4P; room: Sheet16
L66010 L66020 L66030 L66040 = CHOKE_4PIN_2PIN: part number: CHOKE_4PIN_2PIN-MAGLAYERS_MMD_10CZ_R15MGX2I,6014B0296001-003,SNAPE-6014B0296001-003,3.1MM,CHOKE_4PIN_2PIN,,,,INDUCTOR,0.15UH,+/- 20%,100KHZ,39A,11.15X10X3MM,SMD,TR; signal model: L4_6014B0296001-003_MAGLAYERS_MMD_10CZ_R15MGX2I; room: Sheet19
L66310 = CHOKE_4PIN_2PIN: part number: CHOKE_4PIN_2PIN-TRIO_EM_15BM66V03,6014B0446001,LS_1120X720X400_4,4.1MM,CHOKE_4PIN_2PIN,,,,INDUCTOR,0.15UH,+-20%,100KHZ,40A,11.5X7.5X4.0MM,SMD,TR; signal model: L4_6014B0446001_TRIO_EM_15BM66V03; room: Sheet20
L66610 = CHOKE_4PIN_2PIN: part number: CHOKE_4PIN_2PIN-PCME064T_R42MS1R557,6014B0284601,LS_660X660X400_4_P2,4.1MM,CHOKE_4PIN_2PIN,,,,INDUCTOR,0.42UH,20%,100KHZ,20A,6.95X6.6X3.8MM,TR; signal model: L4_6014B0284601_PCME064T_R42MS1R557; room: Sheet21
L67010 L67020 = CHOKE_4PIN_2PIN: part number: CHOKE_4PIN_2PIN-TRIO_EM_22BM66V04,6014B0445101,LS_1100X720X390_4,4MM,CHOKE_4PIN_2PIN,,,,INDUCTOR,0.22UH,+/- 20%,100KHZ,29A,7.2X11.0X3.9MM,SMD,TR; signal model: L4_6014B0445101_TRIO_EM_22BM66V04; room: Sheet109
L67030 L67040 = CHOKE_4PIN_2PIN: part number: CHOKE_4PIN_2PIN-TRIO_EM_22BM66V04,6014B0445101,LS_1100X720X390_4,4MM,CHOKE_4PIN_2PIN,,,,INDUCTOR,0.22UH,+/- 20%,100KHZ,29A,7.2X11.0X3.9MM,SMD,TR; signal model: L4_6014B0445101_TRIO_EM_22BM66V04; room: Sheet110
L67050 L67060 = CHOKE_4PIN_2PIN: part number: CHOKE_4PIN_2PIN-TRIO_EM_22BM66V04,6014B0445101,LS_1100X720X390_4,4MM,CHOKE_4PIN_2PIN,,,,INDUCTOR,0.22UH,+/- 20%,100KHZ,29A,7.2X11.0X3.9MM,SMD,TR; signal model: L4_6014B0445101_TRIO_EM_22BM66V04; room: Sheet111
L67210 L67220 = CHOKE_4PIN_2PIN: part number: CHOKE_4PIN_2PIN-PCME063T-R24MS1R195,6014B0228601,LS_660X660X300_4_P4,3.1MM,CHOKE_4PIN_2PIN,,,,INDUCTOR,0.24UH,+/- 20%,1MHZ,35A,6.6X7.05X3MM,SMD,TR; signal model: L4_6014B0228601_PCME063T-R24MS1R195; room: Sheet112
L67400 = CHOKE_2PIN: part number: CHOKE_2PIN-CYNTEC_PCMB053T_2R2MS,6014B0262601,LS_485X470X300_2_500,3.15MM,CHOKE_2PIN,,,,INDUCTOR,2.2UH,+/-20%,100KHZ,5.5A,4.85*4.7*2.8MM,SMD,TR; signal model: L2_6014B0262601_CYNTEC_PCMB053T_2R2MS; room: Sheet114
L67600 = IDUT_SINGLE: part number: IDUT_SINGLE-NRS5020T1R0N,6014B0186903,LS_500X500X200_2_340_P2,2.1MM,IDUT_SINGLE,,,,INDUCTOR,1.0UH,30%,100KHZ,3.5A,4.9X4.9X2MM,SMD,TR; signal model: L2_6014B0186903_NRS5020T1R0N; room: Sheet113
PAD1 PAD7002 PAD7003 = POWERPAD_2: part number: POWERPAD_2-POWERPAD_2_0610,POWERPAD_2_0610,POWERPAD_2_0610,0.559MM,POWERPAD_2,POWERPAD_2_0610; room: Sheet22
PAD282 = POWERPAD_2: part number: POWERPAD_2-POWERPAD1X1M,POWERPAD1X1M,POWERPAD1X1M,0.559MM,POWERPAD_2,POWERPAD1X1M; room: Sheet53
PAD500-PAD502 = POWERPAD_2: part number: POWERPAD_2-POWERPAD1X1M,POWERPAD1X1M,POWERPAD1X1M,0.559MM,POWERPAD_2,POWERPAD1X1M; room: Sheet54
PAD1700 = POWERPAD_2: part number: POWERPAD_2-POWERPAD1X1M,POWERPAD1X1M,POWERPAD1X1M,0.559MM,POWERPAD_2,POWERPAD1X1M; room: Sheet56
PAD1901 = POWERPAD_2: part number: POWERPAD_2-POWERPAD1X1M,POWERPAD1X1M,POWERPAD1X1M,0.559MM,POWERPAD_2,POWERPAD1X1M; room: Sheet58
PAD1902 = POWERPAD_2: part number: POWERPAD_2-POWERPAD1X1M,POWERPAD1X1M,POWERPAD1X1M,0.559MM,POWERPAD_2,POWERPAD1X1M; room: Sheet59
PAD3000 PAD3001 = POWERPAD_2: part number: POWERPAD_2-POWERPAD1X1M,POWERPAD1X1M,POWERPAD1X1M,0.559MM,POWERPAD_2,POWERPAD1X1M; room: Sheet62
PAD3500 = POWERPAD_2: part number: POWERPAD_2-POWERPAD1X1M,POWERPAD1X1M,POWERPAD1X1M,0.559MM,POWERPAD_2,POWERPAD1X1M; room: Sheet63
PAD4300 PAD4301 = POWERPAD_2: part number: POWERPAD_2-POWERPAD1X1M,POWERPAD1X1M,POWERPAD1X1M,0.559MM,POWERPAD_2,POWERPAD1X1M; room: Sheet24
PAD55300 = POWERPAD_2: part number: POWERPAD_2-POWERPAD_2_0610,POWERPAD_2_0610,POWERPAD_2_0610,0.559MM,POWERPAD_2,POWERPAD_2_0610; room: Sheet107
PAD56250 = POWERPAD_2: part number: POWERPAD_2-POWERPAD_2_0610,POWERPAD_2_0610,POWERPAD_2_0610,0.559MM,POWERPAD_2,POWERPAD_2_0610; room: Sheet93
PAD60000 = POWERPAD_2: part number: POWERPAD_2-POWERPAD1X1M,POWERPAD1X1M,POWERPAD1X1M,0.559MM,POWERPAD_2,POWERPAD1X1M; room: Sheet8
PAD60100 = POWERPAD_4_0610: part number: POWERPAD_4_0610-POWERPAD_4_0610,POWERPAD_4_0610,POWERPAD_4_0610_SHORT,0.127MM,POWERPAD_4,POWERPAD_4_0610; room: Sheet12
PAD60110 = POWERPAD_2: part number: POWERPAD_2-POWERPAD_2_0610,POWERPAD_2_0610,POWERPAD_2_0610,0.559MM,POWERPAD_2,POWERPAD_2_0610; room: Sheet12
PAD60191 = POWERPAD_2: part number: POWERPAD_2-POWERPAD1X1M,POWERPAD1X1M,POWERPAD1X1M,0.559MM,POWERPAD_2,POWERPAD1X1M; room: Sheet12
PAD60200 = POWERPAD_4_0610: part number: POWERPAD_4_0610-POWERPAD_4_0610,POWERPAD_4_0610,POWERPAD_4_0610_SHORT,0.127MM,POWERPAD_4,POWERPAD_4_0610; room: Sheet10
PAD60210 = POWERPAD_2: part number: POWERPAD_2-POWERPAD_2_0610,POWERPAD_2_0610,POWERPAD_2_0610,0.559MM,POWERPAD_2,POWERPAD_2_0610; room: Sheet10
PAD60250 = POWERPAD_4_0610: part number: POWERPAD_4_0610-POWERPAD_4_0610,POWERPAD_4_0610,POWERPAD_4_0610_SHORT,0.127MM,POWERPAD_4,POWERPAD_4_0610; room: Sheet11
PAD60260 = POWERPAD_2: part number: POWERPAD_2-POWERPAD_2_0610,POWERPAD_2_0610,POWERPAD_2_0610,0.559MM,POWERPAD_2,POWERPAD_2_0610; room: Sheet11
PAD60300 = POWERPAD_4_0610: part number: POWERPAD_4_0610-POWERPAD_4_0610,POWERPAD_4_0610,POWERPAD_4_0610_SHORT,0.127MM,POWERPAD_4,POWERPAD_4_0610; room: Sheet13
PAD60310 = POWERPAD_2: part number: POWERPAD_2-POWERPAD_2_0610,POWERPAD_2_0610,POWERPAD_2_0610,0.559MM,POWERPAD_2,POWERPAD_2_0610; room: Sheet13
PAD60350 = POWERPAD_2: part number: POWERPAD_2-POWERPAD1X1M,POWERPAD1X1M,POWERPAD1X1M,0.559MM,POWERPAD_2,POWERPAD1X1M; room: Sheet13
PAD60400 PAD60410 = POWERPAD_2: part number: POWERPAD_2-POWERPAD1X1M,POWERPAD1X1M,POWERPAD1X1M,0.559MM,POWERPAD_2,POWERPAD1X1M; room: Sheet15
PAD60500 = POWERPAD_2: part number: POWERPAD_2-POWERPAD_2_0610,POWERPAD_2_0610,POWERPAD_2_0610,0.559MM,POWERPAD_2,POWERPAD_2_0610; room: Sheet17
PAD60510 = POWERPAD_2: part number: POWERPAD_2-POWERPAD1X1M,POWERPAD1X1M,POWERPAD1X1M,0.559MM,POWERPAD_2,POWERPAD1X1M; room: Sheet17
PAD60600 PAD60610 = POWERPAD_2: part number: POWERPAD_2-POWERPAD1X1M,POWERPAD1X1M,POWERPAD1X1M,0.559MM,POWERPAD_2,POWERPAD1X1M; room: Sheet14
PAD60900 = POWERPAD_4_0610: part number: POWERPAD_4_0610-POWERPAD_4_0610,POWERPAD_4_0610,POWERPAD_4_0610_SHORT,0.127MM,POWERPAD_4,POWERPAD_4_0610; room: Sheet16
PAD60910 = POWERPAD_2: part number: POWERPAD_2-POWERPAD_2_0610,POWERPAD_2_0610,POWERPAD_2_0610,0.559MM,POWERPAD_2,POWERPAD_2_0610; room: Sheet16
PAD66010 = POWERPAD_2: part number: POWERPAD_2-POWERPAD_2_0610,POWERPAD_2_0610,POWERPAD_2_0610,0.559MM,POWERPAD_2,POWERPAD_2_0610; room: Sheet19
PAD66310 = POWERPAD_2: part number: POWERPAD_2-POWERPAD_2_0610,POWERPAD_2_0610,POWERPAD_2_0610,0.559MM,POWERPAD_2,POWERPAD_2_0610; room: Sheet20
PAD66610 = POWERPAD_2: part number: POWERPAD_2-POWERPAD_2_0610,POWERPAD_2_0610,POWERPAD_2_0610,0.559MM,POWERPAD_2,POWERPAD_2_0610; room: Sheet21
PAD67210 = POWERPAD_2: part number: POWERPAD_2-POWERPAD_2_0610,POWERPAD_2_0610,POWERPAD_2_0610,0.559MM,POWERPAD_2,POWERPAD_2_0610; room: Sheet112
PAD67400 = POWERPAD_4_0610: part number: POWERPAD_4_0610-POWERPAD_4_0610,POWERPAD_4_0610,POWERPAD_4_0610_SHORT,0.127MM,POWERPAD_4,POWERPAD_4_0610; room: Sheet114
PAD67410 = POWERPAD_2: part number: POWERPAD_2-POWERPAD_2_0610,POWERPAD_2_0610,POWERPAD_2_0610,0.559MM,POWERPAD_2,POWERPAD_2_0610; room: Sheet114
PAD67600 PAD67610 = POWERPAD_2: part number: POWERPAD_2-POWERPAD1X1M,POWERPAD1X1M,POWERPAD1X1M,0.559MM,POWERPAD_2,POWERPAD1X1M; room: Sheet113
Q1 = NPN_B: part number: NPN_B-MMBT4401,6015B0037801,TSOT23_290X130X110_3_096,1.25MM,NPN_B,TRANSISTOR NPN 40V 600MA SOT23 3P TR; room: Sheet47
Q2 = NMOS: part number: NMOS-L2N7002WT1G,6015B0104301,TSSOT323_200X125X100_3_065,1.15MM,NMOS,,,TRANSISTOR-FET,NEMOS,60V,115MA,SC-70,3P,TR; room: Sheet47
Q4 = NMOS: part number: NMOS-L2N7002WT1G,6015B0104301,TSSOT323_200X125X100_3_065,1.15MM,NMOS,,,TRANSISTOR-FET,NEMOS,60V,115MA,SC-70,3P,TR; room: Sheet44
Q5 Q6 = NMOS_C: part number: NMOS_C-PANJIT_2N7002KW_3P,6015B0167001,SOT323_200X125X110_3_065_P3,1.20MM,NMOS_C,PANJIT_2N7002KW_3P; room: Sheet60
Q9 Q10 Q7006 = NMOS_DUAL_C: part number: NMOS_DUAL_C-2N7002KDW,6015B0153201,SOT363_205X125X110_6_065_P3,1.2MM,NMOS_DUAL_C,,TRANSISTOR-FET,NEMOS,60V,115MA,SOT363,6P,TR; room: Sheet22
Q101 = NMOS_DUAL_C: part number: NMOS_DUAL_C-2N7002KDW,6015B0153201-001,APUS-6015B0153201-001,1.25MM,NMOS_DUAL_C,,TRANSISTOR-FET,NEMOS,60V,115MA,SOT363,6P,TR; room: Sheet123
Q102 = NMOS_C: part number: NMOS_C-PANJIT_2N7002KW_3P,6015B0167001,SOT323_200X125X110_3_065_P3,1.20MM,NMOS_C,PANJIT_2N7002KW_3P; room: Sheet123
Q250 = PMOS_A: part number: PMOS_A-PM513BA,6015B0145801,TSOT23_292X130X120_3_095,1.35MM,,TRANSISTOR-FET,PEMOS,20V,3A,SOT23,3P,TR; room: Sheet52
Q251 = NMOS_C: part number: NMOS_C-PANJIT_2N7002KW_3P,6015B0167001,SOT323_200X125X110_3_065_P3,1.20MM,NMOS_C,PANJIT_2N7002KW_3P; room: Sheet52
Q281 = NMOS_DUAL_C: part number: NMOS_DUAL_C-2N7002KDW,6015B0153201-001,APUS-6015B0153201-001,1.25MM,NMOS_DUAL_C,,TRANSISTOR-FET,NEMOS,60V,115MA,SOT363,6P,TR; room: Sheet53
Q300 = NMOS_DUAL_C: part number: NMOS_DUAL_C-2N7002KDW,6015B0153201-001,APUS-6015B0153201-001,1.25MM,NMOS_DUAL_C,,TRANSISTOR-FET,NEMOS,60V,115MA,SOT363,6P,TR; room: Sheet42
Q303 = NMOS_DUAL_C: part number: NMOS_DUAL_C-2N7002KDW,6015B0153201,SOT363_205X125X110_6_065_P3,1.2MM,NMOS_DUAL_C,,TRANSISTOR-FET,NEMOS,60V,115MA,SOT363,6P,TR; room: Sheet50
Q400 = PMOS_A: part number: PMOS_A-PM513BA,6015B0145801-003,HL10BM-6015B0145801-003,1.35MM,,TRANSISTOR-FET,PEMOS,20V,3A,SOT23,3P,TR; room: Sheet124
Q401 = NMOS_C: part number: NMOS_C-PANJIT_2N7002KW_3P,6015B0167001,SOT323_200X125X110_3_065_P3,1.20MM,NMOS_C,PANJIT_2N7002KW_3P; room: Sheet124
Q402 = NPN_D: part number: NPN_D-LMBT3904LT1G,6015B0048201,TSSOT23_292X130X111_3_096,1.26MM,NPN_D,SOT23,0.2A,TRANSISTOR,NPN,40V,200MA,SOT23,3P,TR; room: Sheet124
Q700 = NMOS_DUAL_C: part number: NMOS_DUAL_C-2N7002KDW,6015B0153201,SOT363_205X125X110_6_065_P3,1.2MM,NMOS_DUAL_C,,TRANSISTOR-FET,NEMOS,60V,115MA,SOT363,6P,TR; room: Sheet118
Q701 = PMOS_A: part number: PMOS_A-PM513BA,6015B0145801,TSOT23_292X130X120_3_095,1.35MM,,TRANSISTOR-FET,PEMOS,20V,3A,SOT23,3P,TR; room: Sheet118
Q702 = NMOS_C: part number: NMOS_C-PANJIT_2N7002KW_3P,6015B0167001,SOT323_200X125X110_3_065_P3,1.20MM,NMOS_C,PANJIT_2N7002KW_3P; room: Sheet118
Q1300 Q1312 Q1313 = NMOS: part number: NMOS-L2N7002WT1G,6015B0104301,TSSOT323_200X125X100_3_065,1.15MM,NMOS,,,TRANSISTOR-FET,NEMOS,60V,115MA,SC-70,3P,TR; room: Sheet57
Q1314 = NPN_D: part number: NPN_D-LMBT3904LT1G,6015B0048201,TSSOT23_292X130X111_3_096,1.26MM,NPN_D,SOT23,0.2A,TRANSISTOR,NPN,40V,200MA,SOT23,3P,TR; room: Sheet57
Q1900 = NMOS: part number: NMOS-L2N7002WT1G,6015B0104301,TSSOT323_200X125X100_3_065,1.15MM,NMOS,,,TRANSISTOR-FET,NEMOS,60V,115MA,SC-70,3P,TR; room: Sheet58
Q3000 = NMOS: part number: NMOS-L2N7002WT1G,6015B0104301,TSSOT323_200X125X100_3_065,1.15MM,NMOS,,,TRANSISTOR-FET,NEMOS,60V,115MA,SC-70,3P,TR; room: Sheet62
Q4450 = NPN_D: part number: NPN_D-LMBT3904LT1G,6015B0048201,TSSOT23_292X130X111_3_096,1.26MM,NPN_D,SOT23,0.2A,TRANSISTOR,NPN,40V,200MA,SOT23,3P,TR; room: Sheet49
Q4702 = NMOS_DUAL_C: part number: NMOS_DUAL_C-2N7002KDW,6015B0153201,SOT363_205X125X110_6_065_P3,1.2MM,NMOS_DUAL_C,,TRANSISTOR-FET,NEMOS,60V,115MA,SOT363,6P,TR; room: Sheet39
Q4751 = NMOS_DUAL_C: part number: NMOS_DUAL_C-2N7002KDW,6015B0153201,SOT363_205X125X110_6_065_P3,1.2MM,NMOS_DUAL_C,,TRANSISTOR-FET,NEMOS,60V,115MA,SOT363,6P,TR; room: Sheet30
Q4758 = NPN_D: part number: NPN_D-LMBT3904LT1G,6015B0048201,TSSOT23_292X130X111_3_096,1.26MM,NPN_D,SOT23,0.2A,TRANSISTOR,NPN,40V,200MA,SOT23,3P,TR; room: Sheet30
Q5000 = PMOS_4D3S: part number: PMOS_4D3S-SYNNEX_SM3303PSQG,6015B0205301,MOSFET_300X300X100_8_065,1.1MM,PMOS_4D3S,,,TRANSISTOR-FET,PEMOS,-30V,-17.1A,DFN,8P,TR; room: Sheet109
Q5001 = NMOS: part number: NMOS-L2N7002WT1G,6015B0104301,TSSOT323_200X125X100_3_065,1.15MM,NMOS,,,TRANSISTOR-FET,NEMOS,60V,115MA,SC-70,3P,TR; room: Sheet109
Q7003 = NMOS_C: part number: NMOS_C-PANJIT_2N7002KW_3P,6015B0167001,SOT323_200X125X110_3_065_P3,1.20MM,NMOS_C,PANJIT_2N7002KW_3P; room: Sheet23
Q7007 = NMOS_C: part number: NMOS_C-PM514BA,6015B0145601,TSOT23_292X130X120_3_095_P2,1.30MM,NMOS_C,TRANSISTOR-FET,NEMOS,20V,3A,SOT23,3P,TR; room: Sheet22
Q7010 = NPN_D: part number: NPN_D-LMBT3904LT1G,6015B0048201,TSSOT23_292X130X111_3_096,1.26MM,NPN_D,SOT23,0.2A,TRANSISTOR,NPN,40V,200MA,SOT23,3P,TR; room: Sheet22
Q50010 = NMOS_C: part number: NMOS_C-PJA138K,6015B0164101,SOT23_292X130X110_3_095,1.20MM,NMOS_C,TRANSISTOR-FET,NEMOS,55V,335MA,SOT-23,3P,TR; room: Sheet74
Q51510 Q51545 Q51550 = NMOS_C: part number: NMOS_C-PJA138K,6015B0164101,SOT23_292X130X110_3_095,1.20MM,NMOS_C,TRANSISTOR-FET,NEMOS,55V,335MA,SOT-23,3P,TR; room: Sheet89
Q51520 Q51530 Q51592 Q51595 = NMOS_2D2S_DIODE: part number: NMOS_2D2S_DIODE-EM6K1GT2R,6015B0155001,TSEMT6_160X120X050_6_050_2,0.65MM,,TRANSISTOR-FET,NEMOS,30V,100MA,6P,TR; room: Sheet89
Q51630 Q51640 Q51641 Q51650 Q51660 Q51661 = NMOS: part number: NMOS-L2N7002WT1G,6015B0104301,TSSOT323_200X125X100_3_065,1.15MM,NMOS,,,TRANSISTOR-FET,NEMOS,60V,115MA,SC-70,3P,TR; room: Sheet91
Q51670 Q51680 = NMOS_2D2S_DIODE: part number: NMOS_2D2S_DIODE-EM6K1GT2R,6015B0155001,TSEMT6_160X120X050_6_050_2,0.65MM,,TRANSISTOR-FET,NEMOS,30V,100MA,6P,TR; room: Sheet91
Q52060 = NPN_D: part number: NPN_D-LMBT3904LT1G,6015B0048201,TSSOT23_292X130X111_3_096,1.26MM,NPN_D,SOT23,0.2A,TRANSISTOR,NPN,40V,200MA,SOT23,3P,TR; room: Sheet98
Q52070 = NMOS_C: part number: NMOS_C-PJA138K,6015B0164101,SOT23_292X130X110_3_095,1.20MM,NMOS_C,TRANSISTOR-FET,NEMOS,55V,335MA,SOT-23,3P,TR; room: Sheet98
Q53510 = NMOS_2D2S_DIODE: part number: NMOS_2D2S_DIODE-EM6K1GT2R,6015B0155001,TSEMT6_160X120X050_6_050_2,0.65MM,,TRANSISTOR-FET,NEMOS,30V,100MA,6P,TR; room: Sheet105
Q55210 Q55220 Q55230 = NMOS_C: part number: NMOS_C-PJA138K,6015B0164101,SOT23_292X130X110_3_095,1.20MM,NMOS_C,TRANSISTOR-FET,NEMOS,55V,335MA,SOT-23,3P,TR; room: Sheet106
Q55215 Q55225 Q55235 = NMOS_C: part number: NMOS_C-PM514BA,6015B0145601,TSOT23_292X130X120_3_095_P2,1.30MM,NMOS_C,TRANSISTOR-FET,NEMOS,20V,3A,SOT23,3P,TR; room: Sheet106
Q56260 Q56270 Q56280 = NPN_D: part number: NPN_D-LMBT3904LT1G,6015B0048201,TSSOT23_292X130X111_3_096,1.26MM,NPN_D,SOT23,0.2A,TRANSISTOR,NPN,40V,200MA,SOT23,3P,TR; room: Sheet93
Q56470 = NMOS_2D2S_DIODE: part number: NMOS_2D2S_DIODE-EM6K1GT2R,6015B0155001,TSEMT6_160X120X050_6_050_2,0.65MM,,TRANSISTOR-FET,NEMOS,30V,100MA,6P,TR; room: Sheet95
Q56670 Q56690 = NMOS_2D2S_DIODE: part number: NMOS_2D2S_DIODE-EM6K1GT2R,6015B0155001,TSEMT6_160X120X050_6_050_2,0.65MM,,TRANSISTOR-FET,NEMOS,30V,100MA,6P,TR; room: Sheet96
Q60000 = NMOS_4D3S: part number: NMOS_4D3S-AOS_AON7506_TRANSISTOR,6015B0194401,MOSFET_300X300X090_8_065,1MM,NMOS_4D3S,TRANSISTOR-FET,NEMOS,30V,12A,DFN3X3,8P,TR; room: Sheet8
Q60001 = NMOS_4D3S_SCH: part number: NMOS_4D3S_SCH-AON7752,6015B0142401,MOSFET_300X300X112_8_065,1.27MM,NMOS_4D3S_SCH,,,TRANSISTOR-FET,NEMOS,30V,15A,DFN,8P,TR; room: Sheet8
Q60002 Q60003 = NMOS_DUAL_C: part number: NMOS_DUAL_C-2N7002KDW,6015B0153201-001,APUS-6015B0153201-001,1.25MM,NMOS_DUAL_C,,TRANSISTOR-FET,NEMOS,60V,115MA,SOT363,6P,TR; room: Sheet9
Q60010 Q60011 = NMOS_4D3S: part number: NMOS_4D3S-AOS_AONS32314,6015B0233301,MOSFET_500X600X100_8_127,1.1MM,NMOS_4D3S,TRANSISTOR-FET,NEMOS,30V,18.5A,DFN 5X6,8P,TR; room: Sheet8
Q60012 = NMOS_4D3S: part number: NMOS_4D3S-AOS_AON6368,6015B0247101,MOSFET_500X600X100_8_127,1.1MM,NMOS_4D3S,TRANSISTOR-FET,NEMOS,30V,25A,DFN 5X6,8P,TR; room: Sheet8
Q66310 Q66311 = FDMS3669S: part number: FDMS3669S-ALPHA_AON6994_8P,6015B0175001,DFN_500X600X080_8_127_T1,0.9MM,,TRANSISTOR-FET,NNEMOS,30V,19/26A,DFN5X6D; room: Sheet20
Q66610 = FDMS3669S: part number: FDMS3669S-AOS_AON6996,6015B0250201,TSMOS_530X555X100_8_127_T2,1.1MM,,TRANSISTOR-FET,NNEMOS,30/30V,19/23A,DFN 5X6D,8P,TR; room: Sheet21
Q67210 Q67220 = FDMS3669S: part number: FDMS3669S-AOS_AON6992_8P,6015B0211001,TSMOS_530X555X100_8_127_T2,1.1MM,,TRANSISTOR-FET,DUAL NNEMOSFET,30/30V,19/31A,POWER56,8P,TR; room: Sheet112
R7 = RSC_0402: part number: RSC_0402-10K_5%_2,60130B1030ZT,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP,10K,5%,1/16W,0402,TR; signal model: R2_60130B1030ZT_10K_5%_2; room: Sheet50
R11 R12 R311 = RSC_0402: part number: RSC_0402-33_5%_2,60130B3300ZT,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-33-5%-1/16W-0402-TAP; signal model: R2_60130B3300ZT_33_5%_2; room: Sheet50
R13 = RSC_SHORT: part number: RSC_SHORT-SHORT_0402_5,SHORT_0402_5,RSC_100X050X040_2_SHORT,0.127MM,RSC_SHORT,SHORT_0402_5; signal model: R2_short_0402_5_short_0402_5; room: Sheet50
R21 R4531 = RSC_0402: part number: RSC_0402-100_1%_2,6013A0016701,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-100OHM-1%-1/16W-0402-TAP; signal model: R2_6013A0016701_100_1%_2; room: Sheet31
R24 R331 R346 R347 R351 = RSC_SHORT: part number: RSC_SHORT-SHORT_0402_15,SHORT_0402_15,RSC_100X050X040_2_15_SHORT,0.127MM,RSC_SHORT,SHORT_0402_15; signal model: R2_short_0402_15_short_0402_15; room: Sheet51
R25 = RSC_0402: part number: RSC_0402-18.7K_1%_2,6013A0017101,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-18.7K-1%-1/16W-0402-TAP; signal model: R2_6013A0017101_18_7K_1%_2; room: Sheet51
R26 = RSC_THERMISTOR: part number: RSC_THERMISTOR-100K_1%_NTC,6013B0171701,RSC_100X050X055_2,0.7MM,RSC_THERMISTOR,,RESISTOR-THER,NTC,100K,0402,1%,0.1A,0.1W,SMD,TR; signal model: R2_6013B0171701_100K_1%_NTC; room: Sheet51
R28 R301 R314 R321 R348 R349 = RSC_0402: part number: RSC_0402-100K_5%_2,60130B1040ZT,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-100K-5%-1/16W-0402-TAP; signal model: R2_60130B1040ZT_100K_5%_2; room: Sheet51
R37 = RSC_0402: part number: RSC_0402-10K_5%_2,60130B1030ZT,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP,10K,5%,1/16W,0402,TR; signal model: R2_60130B1030ZT_10K_5%_2; room: Sheet22
R38 R7029 = RSC_0402: part number: RSC_0402-10K_1%_2,60130B10029Z,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-10K-1%-1/16W-0402-TAP; signal model: R2_60130B10029Z_10K_1%_2; room: Sheet22
R40 R3014 = RSC_0402: part number: RSC_0402-0_5%_2,60130B0000ZT,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-0OHM-5%-1/16W-0402-TAP; signal model: R2_60130B0000ZT_0_5%_2; room: Sheet62
R41 R44 R4116 = RSC_0402: part number: RSC_0402-10K_5%_2,60130B1030ZT,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP,10K,5%,1/16W,0402,TR; signal model: R2_60130B1030ZT_10K_5%_2; room: Sheet47
R42 = RSC_0402: part number: RSC_0402-330_5%_2,60130B3310ZT,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-330-5%-1/16W-0402-TAP; signal model: R2_60130B3310ZT_330_5%_2; room: Sheet47
R43 = RSC_0402: part number: RSC_0402-100K_5%_2,60130B1040ZT,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-100K-5%-1/16W-0402-TAP; signal model: R2_60130B1040ZT_100K_5%_2; room: Sheet47
R55 R56 R330 = RSC_0402: part number: RSC_0402-1K_5%_2,60130B1020ZT,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-1K-5%-1/16W-0402-TAP; signal model: R2_60130B1020ZT_1K_5%_2; room: Sheet50
R60 R4211 R4213 = RSC_SHORT: part number: RSC_SHORT-SHORT_0402_15,SHORT_0402_15,RSC_100X050X040_2_15_SHORT,0.127MM,RSC_SHORT,SHORT_0402_15; signal model: R2_short_0402_15_short_0402_15; room: Sheet47
R79 = RSC_0402: part number: RSC_0402-12.1_1%_2,6013A008730M,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-12.1-1%-1/16W-0402-TAP; signal model: R2_6013A008730M_12_1_1%_2; room: Sheet38
R100 = RSC_0402: part number: RSC_0402-120_5%_2,6013A0075601,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-120-5%-1/16W-0402-TAP; signal model: R2_6013A0075601_120_5%_2; room: Sheet123
R103 R105 = RSC_0402: part number: RSC_0402-300_5%_2,6013A0003401,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-300-5%-1/16W-0402-TAP; signal model: R2_6013A0003401_300_5%_2; room: Sheet123
R104 R107 R109 = RSC_0402: part number: RSC_0402-10K_5%_2,60130B1030ZT,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP,10K,5%,1/16W,0402,TR; signal model: R2_60130B1030ZT_10K_5%_2; room: Sheet123
R133-R136 R4701 R4721 = RSC_0402: part number: RSC_0402-33_5%_2,60130B3300ZT,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-33-5%-1/16W-0402-TAP; signal model: R2_60130B3300ZT_33_5%_2; room: Sheet36
R143 R145 = RSC_0402: part number: RSC_0402-1M_5%_2,60130B10500Y,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-1M-5%-1/16W-0402-TAP; signal model: R2_60130B10500Y_1M_5%_2; room: Sheet22
R144 R146 = RSC_0402: part number: RSC_0402-2M_5%_2_DY,6013A009000D_DY,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-2M-5%-1/16-0402-TAP; signal model: R2_6013A009000D_DY_2M_5%_2_DY; room: Sheet22
R148 R6901 R6988 R7001 R7002 R7004 R7009 R7018 R7019 R7021 R7033 = RSC_0402: part number: RSC_0402-0_5%_2,60130B0000ZT,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-0OHM-5%-1/16W-0402-TAP; signal model: R2_60130B0000ZT_0_5%_2; room: Sheet23
R149 R4836 R4838 R4841 R4843 R4853 R4854 R4858 R4859 = RSC_0402: part number: RSC_0402-100K_5%_2,60130B1040ZT,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-100K-5%-1/16W-0402-TAP; signal model: R2_60130B1040ZT_100K_5%_2; room: Sheet44
R251 R253 = RSC_0402: part number: RSC_0402-100K_5%_2,60130B1040ZT,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-100K-5%-1/16W-0402-TAP; signal model: R2_60130B1040ZT_100K_5%_2; room: Sheet52
R254 = RSC_0402: part number: RSC_0402-0_5%_2,60130B0000ZT,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-0OHM-5%-1/16W-0402-TAP; signal model: R2_60130B0000ZT_0_5%_2; room: Sheet52
R255 = RSC_0402: part number: RSC_0402-10K_5%_2,60130B1030ZT,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP,10K,5%,1/16W,0402,TR; signal model: R2_60130B1030ZT_10K_5%_2; room: Sheet52
R280 R281 = RSC_SHORT: part number: RSC_SHORT-SHORT_0402_5,SHORT_0402_5,RSC_100X050X040_2_SHORT,0.127MM,RSC_SHORT,SHORT_0402_5; signal model: R2_short_0402_5_short_0402_5; room: Sheet53
R282 = RSC_0402: part number: RSC_0402-10K_5%_2,60130B1030ZT,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP,10K,5%,1/16W,0402,TR; signal model: R2_60130B1030ZT_10K_5%_2; room: Sheet53
R285 = RSC_0402: part number: RSC_0402-10K_5%_2_DY,60130B1030ZT_DY,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP,10K,5%,1/16W,0402,TR; signal model: R2_60130B1030ZT_DY_10K_5%_2_DY; room: Sheet53
R286 = RSC_0402: part number: RSC_0402-0_5%_2,60130B0000ZT,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-0OHM-5%-1/16W-0402-TAP; signal model: R2_60130B0000ZT_0_5%_2; room: Sheet53
R287 R288 = RSC_0402: part number: RSC_0402-2.2K_5%_2,6013A0049601,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-2.2K-5%-1/16W-0402-TAP; signal model: R2_6013A0049601_2_2K_5%_2; room: Sheet53
R289 R290 = RSC_0402: part number: RSC_0402-0_5%_2_DY,60130B0000ZT_DY,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-0OHM-5%-1/16W-0402-TAP; signal model: R2_60130B0000ZT_DY_0_5%_2_DY; room: Sheet53
R300 = RSC_0402: part number: RSC_0402-43_5%_2,6013A008960C,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-43-5%-1/16W-0402-TAP; signal model: R2_6013A008960C_43_5%_2; room: Sheet51
R302 = RSC_0402: part number: RSC_0402-220_5%_2,60130B2210ZT,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-220-5%-1/16W-0402-TAP; signal model: R2_60130B2210ZT_220_5%_2; room: Sheet51
R303 R305 R307 R312 R323 R326 R345 = RSC_0402: part number: RSC_0402-0_5%_2,60130B0000ZT,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-0OHM-5%-1/16W-0402-TAP; signal model: R2_60130B0000ZT_0_5%_2; room: Sheet51
R304 R306 R316-R320 R322 R324 R336 R337 R341-R344 R392 = RSC_0402: part number: RSC_0402-10K_5%_2,60130B1030ZT,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP,10K,5%,1/16W,0402,TR; signal model: R2_60130B1030ZT_10K_5%_2; room: Sheet51
R315 = RSC_0402: part number: RSC_0402-330_5%_2,60130B3310ZT,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-330-5%-1/16W-0402-TAP; signal model: R2_60130B3310ZT_330_5%_2; room: Sheet51
R325 R327 = RSC_0402: part number: RSC_0402-2.2K_5%_2,6013A0049601,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-2.2K-5%-1/16W-0402-TAP; signal model: R2_6013A0049601_2_2K_5%_2; room: Sheet50
R328 R329 R359-R362 = RSC_0402: part number: RSC_0402-2.2K_5%_2,6013A0049601,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-2.2K-5%-1/16W-0402-TAP; signal model: R2_6013A0049601_2_2K_5%_2; room: Sheet51
R333 R350 R352 = RSC_0402: part number: RSC_0402-100_5%_2,60130B1010ZT,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-100-5%-1/16W-0402-TAP; signal model: R2_60130B1010ZT_100_5%_2; room: Sheet51
R334 R338 R393 = RSC_0402: part number: RSC_0402-10K_5%_2_DY,60130B1030ZT_DY,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP,10K,5%,1/16W,0402,TR; signal model: R2_60130B1030ZT_DY_10K_5%_2_DY; room: Sheet51
R339 = RSC_0402: part number: RSC_0402-75_5%_2,60130B7500ZT,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-75OHM-5%-1/16W-0402-TAP; signal model: R2_60130B7500ZT_75_5%_2; room: Sheet51
R354 = RSC_SHORT: part number: RSC_SHORT-SHORT_0603_25,SHORT_0603_25,RSC_160X080X080_2_25_SHORT,0.127MM,RSC_SHORT,SHORT_0603_25; signal model: R2_short_0603_25_short_0603_25; room: Sheet51
R367 R4713 R4804 R4805 = RSC_0402: part number: RSC_0402-10K_5%_2,60130B1030ZT,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP,10K,5%,1/16W,0402,TR; signal model: R2_60130B1030ZT_10K_5%_2; room: Sheet39
R400 R402 = RSC_0402: part number: RSC_0402-10K_5%_2,60130B1030ZT,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP,10K,5%,1/16W,0402,TR; signal model: R2_60130B1030ZT_10K_5%_2; room: Sheet124
R403 R404 R410 = RSC_0402: part number: RSC_0402-0_5%_2,60130B0000ZT,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-0OHM-5%-1/16W-0402-TAP; signal model: R2_60130B0000ZT_0_5%_2; room: Sheet124
R405 = RSC_0402: part number: RSC_0402-30.1K_1%_2,6013A0017501,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-30.1K-1%-1/16W-0402-TAP; signal model: R2_6013A0017501_30_1K_1%_2; room: Sheet124
R406 = RSC_0603: part number: RSC_0603-0_5%_3_DY,60130B00000Z_DY,RSC_160X080X055_2,0.7MM,RSC_0603,0603,RES-CHIP-0-5%-1/10W-TAP; signal model: R2_60130B00000Z_0_5%_3_DY; room: Sheet124
