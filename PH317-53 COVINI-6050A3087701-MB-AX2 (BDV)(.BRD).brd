# Allegro board PH317-53 COVINI-6050A3087701-MB-AX2 (BDV)(.BRD).brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
PCH_SPI_SO2: length 33.8
  TOP w0.109: U300.3 233.59,23.19 R330.2 235.16,24.37 235.61,24.82 v2(235.61,24.95) 235.58,24.97 v1(235.58,26.19)
  L3 w0.076: v1(256.23,31.65) 255.17,31.65 253,33.82 251.11,33.82 248.64,31.35 244.55,31.35 243.14,29.94 239.15,29.94 235.58,26.37 v1(235.58,26.19)
  BOTTOM w0.109: R4701.1 256.33,34.43 256.74,34.02 256.74,32.16 v1(256.23,31.65)
PCH_SPI_SO3: length 43.3
  TOP w0.109: U300.7 224.33,21.92 223.52,22.73 R55.1 ; v1(227.35,24.64) 227.35,23.64 225.63,21.92 XU300.7
  L3 w0.076: v1(227.35,24.64) 227.97,25.26 228.66,25.26 228.69,25.29 231.22,25.29 231.33,25.18 237.39,25.18 241.74,29.53 243.47,29.53 243.91,29.98 248.64,29.98 249.04,29.57 254.89,29.57 256.08,30.76 v1(256.08,30.76)
  BOTTOM w0.109: R4721.1 257.45,34.63 v2(257.45,33.99) 257.45,32.13 v1(256.08,30.76)
PCH_SPKR: length 284.9
  TOP w0.102: v1(15.85,61.37) 15.31,60.84 R521.2
  L8 w0.102: v1(256.71,52.07) 256.71,52.78 257.82,53.88 258.38,53.88 258.95,54.44 258.95,56.96 257.09,58.82 256.46,58.82 254,61.28 254,62.86 253.68,63.17 250.61,63.17 250.02,62.59 249.12,62.59 249.07,62.54 248.69,62.54 247.6,61.45 247.6,60.68 245.52,58.6 243.36,58.6 241.42,56.67 240.53,56.67 237.66,53.8 237.66,51.54 236.75,50.63 234.95,50.63 232.84,48.52 220.5,48.52 217.99,46.01 215.47,46.01 215.47,46.01 185.76,46.01 175.69,35.93 171.09,35.93 170.3,35.14 167.78,35.14 167.22,34.58 145.93,34.58 145.26,33.91 133.88,33.91 133.1,34.69 128.29,34.69 121.75,41.23 114.92,41.23 111.16,44.99 107.16,44.99 99.94,52.2 64.4,52.2 50.97,65.62 29.57,65.62 27.58,63.63 25.5,63.63 24.76,62.89 23.09,62.89 20.85,60.66 20.85,60.46 20.63,60.24 16.8,60.24 15.85,61.19 v1(15.85,61.37)
  BOTTOM w0.089: U4710.AW29 256.23,51.02 256.23,51.59 v1(256.71,52.07)
PCH_TCK: length 5.1
  TOP w0.109: R4881.1 250.95,65.52 v2(250.95,66.27) v1(250.95,67.01)
  BOTTOM w0.089: U4710.AJ3 251.16,63.87 251.16,66.29 250.95,66.5 v1(250.95,67.01)
PCH_TDI: length 8.5
  BOTTOM w0.089: 250.75,68.02 250.59,67.87 250.59,67.54 250.44,67.39 250.34,67.29 250.34,66.57 250.8,66.1 250.8,64.57 U4710.AH2
  BOTTOM w0.109: R4797.1 R4879.1 252.44,69.98 252.01,69.98 250.77,68.74 v2(250.77,68.41) 250.77,68.05 250.75,68.02
PCH_TDO: length 16.1
  BOTTOM w0.089: U4710.AH3 250.76,64.07 250.98,64.29 250.98,66.18 250.52,66.64 250.52,67.21 251.32,68.02
  BOTTOM w0.109: R4796.1 252.95,72.14 R4876.1 252.63,73.49 254.23,73.49 254.74,72.97 254.74,70.63 254.14,70.03 252.98,70.03 252.21,69.26 v2(252.06,69.26) 251.98,69.26 251.32,68.6 251.32,68.02
PCH_THERMTRIP#: length 5.8
  BOTTOM w0.109: R4785.2 248.48,69.11 R4786.1 248.48,69.52 248.87,69.9 248.87,71.83 248.76,71.93 v2(248.76,72.42) 249.19,72.84 Q4758.3
PCH_THERMTRIP#_R: length 5
  BOTTOM w0.109: U4710.AD3 248.58,64.26 248.58,64.42 248.43,64.57 248.15,64.57 247.99,64.73 247.99,65.72 247.65,66.07 247.65,68.21 R4785.1
PCH_TMS: length 15.2
  BOTTOM w0.089: 251.33,66.55 251.33,64.07 251.47,63.93 251.47,63.62 U4710.AJ4
  BOTTOM w0.102: 251.41,67.57 251.41,66.96 251.33,66.88 251.33,66.55
  BOTTOM w0.109: 251.41,67.57 251.56,67.72 251.56,68.43 251.81,68.69 252.24,68.69 252.66,69.1 252.66,69.3 253.15,69.8 254.23,69.8 255.01,70.57 255.01,73.26 254.56,73.71 R4794.1 v2(253.72,73.99) R4880.1
PCH_TP_I2C_INT#: length 149.1
  L10 w0.102: v1(237.74,26.93) 237.46,27.21 233.85,27.21 230.68,24.03 225.44,24.03 222.63,26.84 213.31,26.84 211.31,28.83 200.01,28.83 199.95,28.9 199.61,28.9 199.55,28.83 195.76,28.83 195.48,28.55 192.52,28.55 192.4,28.68 186.68,28.68 185.92,27.92 185.33,27.32 175.14,27.32 172.06,30.41 168.73,30.41 167.14,31.99 150.92,31.99 148.93,33.99 135.26,33.99 134.28,34.97 118.53,34.97 v1(117.8,34.24)
  BOTTOM w0.089: U4710.Y47 246.96,42.22 246.35,41.61 246.35,40.64 244.8,39.09
  BOTTOM w0.102: 244.8,39.09 244.67,38.97 244.67,38.81 244.09,38.23 244.09,37.19 243.68,36.78 243.68,35.06 242.44,33.81 240.03,33.81 238.43,32.21 238.43,31.45 237.82,30.84 237.82,27 v1(237.74,26.93) ; v1(117.8,34.24) R280.1
PCH_TRIGOUTGGER: length 7
  TOP w0.102: R4792.1 252.72,69.48 v3(253.07,69.13)
  BOTTOM w0.089: U4710.AK3 251.89,63.89 251.89,64.65 251.79,64.74 251.79,66.32
  BOTTOM w0.102: 251.79,66.32 251.79,67.3 253.04,68.56 253.04,69.11 v3(253.07,69.13)
PCH_TRST#: length 10.6
  BOTTOM w0.089: U4710.AM4 252.68,63.69 252.68,64.62 252.45,64.85 252.45,66.91 253.57,68.02
  BOTTOM w0.109: 253.57,68.02 254.12,68.58 255.65,68.58 v2(255.95,68.89) 257.07,70.01 257.07,70.57 R4801.1
PCH_VCCPRIM_1P8: length 2.9
  TOP w0.254: v3(249.27,55.9) 249.39,56.01 R4918.2 249.39,57.27 R4900.1
  BOTTOM w0.254: U4710.AF19 249.63,56.26 v3(249.27,55.9) 249.63,55.53 U4710.AF20
PCH_VCCPRIM_1P8_R: length 7.1
  TOP w0.254: R4920.2 250.59,57.53 250.24,57.18 R4918.1 250.16,56.68 250.16,56.04 v1(250.02,55.9)
  L8 w0.254: v1(250.02,55.9) 251,54.92 251.91,54.92 v3(252.45,54.38)
  BOTTOM w0.254: v3(252.45,54.38) 253.07,53.76 U4710.AN24 ; U4710.AG19 v1(250.02,55.9) U4710.AG20
PCH_W_DISABLE2#: length 43.4
  TOP w0.102: Q1313.3 v1(285.39,23.76)
  L10 w0.102: v1(285.39,23.76) 285.39,29 284.7,29.7 282.7,29.7 278.99,33.41 278.99,36.8 267.6,48.19 266.85,48.19 265.12,49.91 263.25,49.91 v3(263.22,49.88)
  BOTTOM w0.102: R4708.1 263.48,49.63 263.23,49.88 v3(263.22,49.88) 262.92,49.58 262.2,49.58 261.97,49.82 259.57,49.82 U4710.BF32
PCH_WAKE#: length 308.5
  TOP w0.102: R4747.1 259.18,33.25 v2(259.18,34.04) 258.67,34.04 257.71,35 257.71,40.69 v1(257.63,40.77) ; Q1314.3 283.02,22.19 282.5,22.19 v1(282.46,22.23)
  L3 w0.102: 277.9,22.63 280.57,22.63 280.63,22.58 280.69,22.58 281.05,22.23 v1(282.46,22.23) ; 277.9,22.63 271.85,22.63 269.72,20.5 259.14,20.5 258.25,19.61 256.1,19.61 254.66,18.16 248.13,18.16 246.68,19.61 240.41,19.61 239.04,20.98 230.65,20.98 229.6,19.93 223.58,19.93 223.26,19.61 215.16,19.61 214.84,19.93 208.39,19.93 207.85,19.39 203.23,19.39 202.31,18.47 196.8,18.47 195.55,19.71 195.14,19.71 194.76,20.09 194.76,21.26 191.11,24.92 184.53,24.92 182.72,23.12 174.52,23.12 172.72,24.92 127.07,24.92 122.61,29.39 87.44,29.39 87.42,29.37 84.28,29.37 83.93,29.72 60.17,29.72 50.1,39.79 36.95,39.79 34.54,42.21 v1(34.54,43.85) ; 277.9,22.63 277.9,25.99 276.46,27.42 276.46,29.59 266.65,39.4 259,39.4 v1(257.63,40.77)
  BOTTOM w0.102: CN603.17 v1(34.54,43.85) ; U4710.BB47 258.1,41.79 258.1,41.57 258.02,41.49 258.02,41.16 v1(257.63,40.77)
PCIE17_HDD_RX_C_DN: length 2.4
  BOTTOM w0.107: C1703.2 260.14,31.74 260.14,30.67 259.85,30.38 CN1700.6
PCIE17_HDD_RX_C_DP: length 2.4
  BOTTOM w0.107: C1702.2 260.35,31.51 CN1700.5
PCIE17_HDD_RX_DN: length 45.7
  L8 w0.084: v1(269.98,38.71) 269.98,38.61 269.78,38.42 262.35,38.42 261.25,39.51 249.61,39.51 246.88,42.24 244.85,42.24 243.47,43.62 243.35,43.74 242.77,43.74 242.65,43.87 v1(242.65,44.07)
  BOTTOM w0.107: U4710.K43 v1(242.65,44.07) ; C1703.1 260.24,33.14 260.24,33.44 260.53,33.73 262.68,33.73 262.97,34.02 269.24,34.02 269.98,34.75 v1(269.98,38.71)
PCIE17_HDD_RX_DP: length 45.7
  L8 w0.084: v1(242.29,43.59) 242.62,43.59 242.68,43.53 243.26,43.53 244.76,42.03 244.94,42.03 246.79,42.03 249.53,39.3 261.17,39.3 262.26,38.21 v1(270.41,38.21)
  BOTTOM w0.107: v1(242.29,43.59) 242.29,43.64 242.04,43.89 U4710.K44 ; C1702.1 260.45,33.17 260.45,33.36 260.62,33.53 262.77,33.53 263.05,33.81 269.33,33.81 270.18,34.66 270.18,38.09 270.3,38.21 v1(270.41,38.21)
PCIE17_HDD_TX_C_DN: length 33.3
  L8 w0.084: v1(258.9,30.92) 258.73,31.1 258.73,32.2 254.12,36.81 250.23,36.81 249.63,37.4 246.46,37.4 245.74,38.13 244.49,38.13 242.15,40.47 234.86,40.47 234.33,41.01 233.05,41.01 v1(232.84,41.22)
  BOTTOM w0.107: CN1700.8 258.85,30.31 258.73,30.43 258.73,30.74 v1(258.9,30.92) ; C4954.2 233.63,41.35 233.26,40.98 233.08,40.98 v1(232.84,41.22)
PCIE17_HDD_TX_C_DP: length 33.3
  L8 w0.084: v3(258.24,30.92) 258.37,30.92 258.52,31.07 258.52,32.12 254.04,36.6 250.14,36.6 249.55,37.19 246.38,37.19 245.65,37.92 244.4,37.92 242.06,40.26 234.78,40.26 234.24,40.8 233.04,40.8 v1(232.79,40.54)
  BOTTOM w0.107: C4955.2 233.63,40.47 233.33,40.77 233.02,40.77 v1(232.79,40.54) ; v3(258.24,30.92) 258.31,30.92 258.52,30.71 258.52,30.43 258.35,30.26 CN1700.9
PCIE17_SSD_TX_DN: length 6
  BOTTOM w0.107: C4954.1 234.48,41.26 234.77,40.97 235.41,40.97 235.91,41.47 235.91,42.88 237.66,44.62 237.66,44.78 237.55,44.89 U4710.A42
PCIE17_SSD_TX_DP: length 6.2
  BOTTOM w0.107: C4955.1 234.78,40.77 235.5,40.77 236.12,41.39 236.12,42.79 237.87,44.54 237.87,44.55 U4710.B42
PCIE_DGPU_RX0N: length 10.2
  TOP w0.076: v1(124.54,135.8) 124.54,135.75 124.78,135.51 124.96,135.51 125.27,135.82 125.74,135.82 125.77,135.84 125.79,135.84
  TOP w0.107: 125.79,135.84 132.66,135.84 132.94,136.12 133.55,136.12 C55731.1
  BOTTOM w0.076: U4555.D25 124.56,135.69 124.56,135.78 v1(124.54,135.8)
PCIE_DGPU_RX0P: length 10.3
  TOP w0.076: v1(124.54,135) 124.54,135.06 124.83,135.35 125.03,135.35 125.33,135.65 125.74,135.65 125.77,135.63 125.79,135.63
  TOP w0.107: C55730.1 133.56,135.91 133.02,135.91 132.74,135.63 125.79,135.63
  BOTTOM w0.076: U4555.E25 124.21,135.32 v1(124.54,135)
PCIE_DGPU_RX1N: length 9.3
  TOP w0.076: v1(123.89,134.23) 123.99,134.31 124.35,134.55 124.51,134.61 125.52,134.61 126.11,135.2 126.62,135.2 126.64,135.22 126.66,135.22
  TOP w0.107: 126.66,135.22 132.3,135.22 C55729.1
  BOTTOM w0.076: U4555.F24 v1(123.89,134.23)
PCIE_DGPU_RX1P: length 9.2
  TOP w0.076: 126.66,135.01 126.64,135.01 126.62,135.03 126.18,135.03 125.59,134.45 124.72,134.45 124.54,134.27 v1(124.54,134.21)
  TOP w0.107: 126.66,135.01 130.08,135.01 130.18,134.91 130.36,134.91 130.46,135.01 130.68,135.01 130.78,134.91 130.93,134.91 131.03,135.01 131.25,135.01 131.34,134.92 131.49,134.92 131.57,135.01 131.84,135.01 131.95,134.9 131.95,134.73 132.05,134.62 132.29,134.62 C55728.1
  BOTTOM w0.076: v1(124.54,134.21) 124.21,134.54 U4555.E24
PCIE_DGPU_RX2N: length 6
  TOP w0.076: v1(125.19,133.42) 125.07,133.42 124.85,133.64 124.85,133.74 124.97,133.85 125.9,133.85 126.05,134.01 126.5,134.01 126.52,133.99 126.53,133.99
  TOP w0.107: 126.53,133.99 128.42,133.99 128.6,134.16 129.23,134.16 129.41,133.98 C55727.1
  BOTTOM w0.076: U4555.D23 124.86,133.69 125.13,133.42 v1(125.19,133.42)
PCIE_DGPU_RX2P: length 6
  TOP w0.076: v1(124.54,133.42) 124.69,133.57 124.69,133.8 124.9,134.02 125.83,134.02 125.99,134.17 126.49,134.17 126.51,134.19 126.53,134.19
  TOP w0.107: 126.53,134.19 128.33,134.19 128.51,134.37 129.24,134.37 C55726.1
  BOTTOM w0.076: U4555.E23 v1(124.54,133.42)
PCIE_DGPU_RX3N: length 9.5
  TOP w0.076: v1(123.9,132.62) 124.15,132.83 124.37,132.98 124.47,133.02 124.65,133.04 126.16,133.04 126.32,133.21 126.32,133.24 126.34,133.25
  TOP w0.107: 126.34,133.25 126.65,133.57 132.38,133.57 C55725.1
  BOTTOM w0.076: U4555.F22 v1(123.9,132.62)
PCIE_DGPU_RX3P: length 9.5
  TOP w0.076: v1(124.56,132.64) 124.69,132.5 124.9,132.5 125,132.6 125,132.78 125.09,132.87 126.22,132.87 126.44,133.09 126.47,133.09 126.49,133.1
  TOP w0.107: 132.46,132.87 132.37,132.78 132.09,132.78 131.99,132.87 131.99,133.26 131.9,133.36 126.74,133.36 126.49,133.1
  BOTTOM w0.076: U4555.E22 124.21,132.9 124.47,132.64 v1(124.56,132.64)
PCIE_DGPU_RX4N: length 7.8
  TOP w0.076: 127.25,132.09 127.23,132.07 126.65,132.07 126.03,131.45 125.39,131.45 125.2,131.64 125.05,131.64 124.97,131.72 124.97,131.91 124.9,131.99 124.66,131.99 v1(124.53,131.86)
  TOP w0.107: 127.25,132.09 127.77,132.09 127.88,132.2 128.09,132.2 128.2,132.09 128.44,132.09 128.55,132.2 128.75,132.2 128.85,132.09 129.07,132.09 129.17,132.2 129.36,132.2 129.46,132.1 129.46,132.09 129.8,132.09 130.07,132.36 130.36,132.36 130.53,132.54 C55723.1
  BOTTOM w0.076: U4555.D21 124.78,132.24 124.53,131.99 v1(124.53,131.86)
PCIE_DGPU_RX4P: length 7.8
  TOP w0.076: v1(123.9,131.86) 124.03,131.74 124.35,131.51 124.43,131.48 125.13,131.48 125.32,131.29 126.1,131.29 126.72,131.91 127.22,131.91 127.24,131.89 127.25,131.89
  TOP w0.107: 127.25,131.89 129.89,131.89 130.16,132.15 130.41,132.15 C55722.1
  BOTTOM w0.076: U4555.E21 v1(123.9,131.86)
PCIE_DGPU_RX5N: length 9
  TOP w0.076: v1(123.9,131.07) 124.11,130.86 124.31,130.73 124.39,130.69 124.58,130.66 126.2,130.66 126.44,130.9 127.94,130.9 127.96,130.88 127.98,130.88
  TOP w0.107: C55721.1 129.77,131.19 129.45,130.88 127.98,130.88
  BOTTOM w0.076: v1(123.9,131.07) 123.9,131.09 123.85,131.14 123.85,131.17 U4555.F20
PCIE_DGPU_RX5P: length 8.9
  TOP w0.076: 127.98,131.09 127.96,131.09 127.94,131.07 126.38,131.07 126.13,130.82 125,130.82 124.94,130.88 124.94,131.13 124.86,131.21 124.66,131.21 v1(124.51,131.06)
  TOP w0.107: C55720.1 131.98,131.71 131.67,131.4 129.68,131.4 129.36,131.09 127.98,131.09
  BOTTOM w0.076: U4555.E20 124.32,131.34 124.32,131.17 124.44,131.06 v1(124.51,131.06)
PCIE_DGPU_RX6N: length 10.1
  TOP w0.076: 127.61,130.47 127.59,130.47 127.57,130.45 126.45,130.45 125.79,129.78 125.27,129.78 125.09,129.97 125.09,130.17 v1(125.19,130.27)
  TOP w0.107: 127.61,130.47 130.27,130.47 130.38,130.57 130.57,130.57 130.67,130.47 130.83,130.47 130.94,130.58 131.1,130.58 131.21,130.47 131.46,130.47 131.67,130.68 133.25,130.68 133.43,130.86 C55719.1
  BOTTOM w0.076: v1(125.19,130.27) 125.19,130.4 124.93,130.67 U4555.D19
PCIE_DGPU_RX6P: length 10.1
  TOP w0.076: 127.61,130.26 127.59,130.26 127.57,130.28 126.52,130.28 125.86,129.62 125.2,129.62 124.55,130.27 v1(124.54,130.27)
  TOP w0.107: 127.61,130.26 131.54,130.26 131.75,130.47 133.31,130.47 C55718.1
  BOTTOM w0.076: U4555.E19 v1(124.54,130.27)
PCIE_DGPU_RX7N: length 9.1
  TOP w0.076: v1(123.89,129.49) 124.11,129.34 124.32,129.16 124.46,129.1 126.17,129.1 126.38,129.32 127.67,129.32 127.69,129.3 127.71,129.3
  TOP w0.107: C55717.1 131.94,129.58 128.15,129.58 127.87,129.3 127.71,129.3
  BOTTOM w0.076: U4555.F18 v1(123.89,129.49)
PCIE_DGPU_RX7P: length 9
  TOP w0.076: v1(124.54,129.49) 124.54,129.57 124.61,129.65 124.85,129.65 125,129.5 125,129.35 125.07,129.27 126.1,129.27 126.32,129.48 127.67,129.48 127.69,129.51 127.71,129.51
  TOP w0.107: C55716.1 132.06,129.93 131.91,129.79 128.06,129.79 127.78,129.51 127.71,129.51
  BOTTOM w0.076: v1(124.54,129.49) 124.54,129.8 124.44,129.9 124.24,129.9 U4555.E18
PCIE_DGPU_RX8N: length 10.7
  TOP w0.076: 126.09,128.1 126.07,128.1 126.05,128.12 125.7,128.12 125.47,128.21 125.41,128.24 125.33,128.29 125.29,128.3 125.08,128.33 124.97,128.38 124.81,128.47 v1(124.54,128.7)
  TOP w0.107: 126.09,128.1 126.41,128.1 127.05,128.73 128.09,128.73 128.2,128.84 134.03,128.84 C55715.1
  BOTTOM w0.076: U4555.E17 v1(124.54,128.7)
PCIE_DGPU_RX8P: length 10.6
  TOP w0.076: v1(125.18,128.71) 125.32,128.71 125.48,128.55 125.48,128.42 125.54,128.36 125.73,128.28 126.05,128.28 126.07,128.3 126.09,128.3
  TOP w0.107: 126.09,128.3 126.33,128.3 126.96,128.94 128,128.94 128.12,129.05 129.46,129.05 129.57,129.16 129.79,129.16 129.9,129.05 130.1,129.05 130.2,129.15 130.35,129.15 130.45,129.05 130.66,129.05 130.76,129.15 130.93,129.15 131.03,129.05 131.24,129.05 131.34,129.15 131.5,129.15 131.6,129.05 134.08,129.05 134.19,129.16 C55714.1
  BOTTOM w0.076: v1(125.18,128.71) 125.17,128.72 125.17,128.72 124.86,129.02 U4555.D17
PCIE_DGPU_RX9N: length 9.7
  TOP w0.076: v1(124.54,127.91) 124.66,127.91 124.85,127.72 124.85,127.6 125.17,127.28 125.35,127.28 125.47,127.41 125.63,127.41 125.75,127.28 125.9,127.28 126.01,127.38 126.13,127.38 126.23,127.28 126.31,127.28 126.41,127.38 126.49,127.38 126.59,127.28 126.66,127.28 126.77,127.38 126.84,127.38 126.94,127.28 127.1,127.28 128.22,128.41 129.49,128.41 129.51,128.43 129.53,128.43
  TOP w0.107: C55713.1 132.01,128.2 131.24,128.2 131,128.43 129.53,128.43
  BOTTOM w0.076: v1(124.54,127.91) 124.63,128.01 124.63,128.11 124.43,128.32 124.23,128.32 U4555.E16
PCIE_DGPU_RX9P: length 9.8
  TOP w0.076: 129.53,128.22 129.51,128.22 129.49,128.24 128.29,128.24 127.17,127.12 125.1,127.12 124.71,127.51 124.43,127.51 v1(123.89,127.91)
  TOP w0.107: C55712.1 131.96,127.99 131.15,127.99 130.92,128.22 129.53,128.22
  BOTTOM w0.076: U4555.F16 v1(123.89,127.91)
PCIE_DGPU_RX10N: length 11.2
  TOP w0.076: v1(123.88,127.11) 123.88,127.11 124.06,126.92 124.06,126.71 124.26,126.51 126.8,126.51 126.93,126.38 127.88,126.38 128.14,126.65 129.96,126.65 130.21,126.89 130.36,126.89 130.38,126.87 130.39,126.87
  TOP w0.107: 130.39,126.87 131.5,126.87 131.74,127.11 133.62,127.11 C55711.1
  BOTTOM w0.076: U4555.E15 124.21,127.45 123.88,127.11 v1(123.88,127.11)
PCIE_DGPU_RX10P: length 11.2
  TOP w0.076: 130.39,127.08 130.38,127.08 130.36,127.06 130.14,127.06 129.89,126.81 128.08,126.81 127.81,126.55 127,126.55 126.87,126.67 124.33,126.67 124.23,126.78 124.23,126.91 124.42,127.11 v1(124.53,127.11)
  TOP w0.107: 130.39,127.08 131.42,127.08 131.66,127.32 133.52,127.32 133.73,127.53 C55710.1
  BOTTOM w0.076: U4555.D15 124.84,127.52 124.53,127.21 v1(124.53,127.11)
PCIE_DGPU_RX11N: length 9.8
  TOP w0.076: v1(123.89,126.34) 123.89,126.25 124.05,126.09 124.87,126.09 124.97,126.19 126.21,126.19 126.3,126.1 129.01,126.1 129.12,126.21 129.98,126.21 130,126.23 130.02,126.23
  TOP w0.107: 130.02,126.23 131.57,126.23 131.66,126.15 131.85,126.15 131.92,126.22 131.92,126.6 132.01,126.68 132.17,126.68 C55709.1
  BOTTOM w0.076: U4555.E14 124.16,126.73 123.89,126.46 v1(123.89,126.34)
PCIE_DGPU_RX11P: length 9.9
  TOP w0.076: 130.02,126.02 130,126.02 129.98,126.04 129.18,126.04 129.08,125.94 126.23,125.94 126.14,126.03 125.04,126.03 124.94,125.93 123.98,125.93 123.97,125.94 123.85,125.94 123.7,126 123.51,126.11 v1(123.24,126.34)
  TOP w0.107: C55708.1 131.57,125.94 131.48,126.02 130.02,126.02
  BOTTOM w0.076: U4555.F14 v1(123.24,126.34)
PCIE_DGPU_RX12N: length 10.8
  TOP w0.076: v1(124.54,125.55) 124.75,125.34 124.75,125.13 125,124.88 126.66,124.88 127.2,125.42 129.24,125.42 129.26,125.4 129.28,125.4
  TOP w0.107: 129.28,125.4 131.19,125.4 131.33,125.26 133.9,125.26 C55707.1
  BOTTOM w0.076: U4555.E13 124.21,125.87 v1(124.54,125.55)
PCIE_DGPU_RX12P: length 10.7
  TOP w0.076: v1(125.19,125.55) 125.12,125.55 124.92,125.35 124.92,125.2 125.07,125.05 126.59,125.05 127.13,125.59 129.24,125.59 129.26,125.61 129.28,125.61
  TOP w0.107: C55706.1 134.06,125.6 133.93,125.47 131.41,125.47 131.27,125.61 129.28,125.61
  BOTTOM w0.076: v1(125.19,125.55) 124.86,125.87 U4555.D13
PCIE_DGPU_RX13N: length 9.7
  TOP w0.076: v1(123.88,125.56) 124.22,125.22 124.34,125.22 124.91,124.64 128.88,124.64 129.18,124.95 129.57,124.95 129.59,124.97 129.61,124.97
  TOP w0.107: C55705.1 132.1,124.66 131.32,124.66 131.01,124.97 130.84,124.97 130.84,124.97 129.61,124.97
  BOTTOM w0.076: U4555.E12 123.88,125.48 v1(123.88,125.56)
PCIE_DGPU_RX13P: length 9.6
  TOP w0.076: v1(123.88,124.77) 124.16,125.05 124.27,125.05 124.85,124.48 128.95,124.48 129.25,124.78 129.57,124.78 129.59,124.76 129.61,124.76
  TOP w0.107: 129.61,124.76 130.92,124.76 130.92,124.76 131.23,124.45 132.12,124.45 C55704.1
  BOTTOM w0.076: v1(123.88,124.77) U4555.F12
PCIE_DGPU_RX14N: length 9.9
  TOP w0.076: 126.71,123.36 126.69,123.36 126.67,123.38 124.93,123.38 124.75,123.56 124.75,123.76 v1(124.54,123.97)
  TOP w0.107: 126.71,123.36 126.87,123.36 127.54,122.69 131.37,122.69 131.67,122.99 133.02,122.99 C55703.1
  BOTTOM w0.076: v1(124.54,123.97) 124.21,124.3 U4555.E11
PCIE_DGPU_RX14P: length 9.8
  TOP w0.076: v1(125.19,123.97) 125.12,123.97 124.92,123.77 124.92,123.63 125,123.55 126.67,123.55 126.69,123.57 126.71,123.57
  TOP w0.107: 126.71,123.57 126.95,123.57 127.63,122.89 131.28,122.89 131.58,123.2 132.72,123.2 C55702.1
  BOTTOM w0.076: v1(125.19,123.97) 124.86,124.3 U4555.D11
PCIE_DGPU_RX15N: length 12
  TOP w0.076: v1(123.88,123.96) 123.88,123.9 124.2,123.57 124.33,123.57 124.86,123.05 126.16,123.05 126.18,123.07 126.2,123.07
  TOP w0.107: 126.2,123.07 126.54,123.07 127.35,122.25 129.5,122.25 130.33,121.42 132.77,121.42 133.3,121.95 133.72,121.95 C55701.1
  BOTTOM w0.076: v1(123.88,123.96) 123.88,123.91 U4555.E10
PCIE_DGPU_RX15P: length 11.8
  TOP w0.076: v1(123.89,123.19) 124.11,123.41 124.26,123.41 124.79,122.88 126.16,122.88 126.18,122.86 126.2,122.86
  TOP w0.107: C55700.1 133.71,121.74 133.38,121.74 132.85,121.21 130.25,121.21 129.41,122.05 127.27,122.05 126.45,122.86 126.2,122.86
  BOTTOM w0.076: U4555.F10 v1(123.89,123.19)
PCIE_DGPU_TX0N: length 19.6
  BOTTOM w0.107: C4836.1 137.79,137.11 138.1,137.43 142.72,137.43 147.31,142.02 151.77,142.02 152,141.79 152.26,141.79 152.38,141.74 U50000.BK42
PCIE_DGPU_TX0P: length 19.4
  BOTTOM w0.107: U50000.BL42 152.2,141.4 152.09,141.29 151.94,141.29 151.82,141.4 151.82,141.68 151.68,141.81 147.4,141.81 142.8,137.22 138.19,137.22 137.87,136.9 135.83,136.9 135.53,136.6 C4835.1
PCIE_DGPU_TX1N: length 16.8
  BOTTOM w0.107: U50000.BM42 151.29,141.27 147.44,141.27 142.97,136.81 138.43,136.81 137.74,136.12 137.13,136.12 C4838.1
PCIE_DGPU_TX1P: length 16.9
  BOTTOM w0.107: U50000.BM41 151.22,141.06 147.52,141.06 143.06,136.6 138.51,136.6 137.83,135.91 137.17,135.91 C4837.1
PCIE_DGPU_TX2N: length 19.6
  BOTTOM w0.107: C4840.1 135.53,135.36 135.68,135.2 135.88,135.2 135.95,135.28 137.8,135.28 138.71,136.19 143.23,136.19 147.46,140.41 151.67,140.41 151.88,140.62 151.88,140.94 151.95,141.02 152.1,141.02 152.2,140.92 U50000.BL41
PCIE_DGPU_TX2P: length 19.7
  BOTTOM w0.107: U50000.BK41 152.35,140.51 152.28,140.48 151.96,140.42 151.75,140.21 147.55,140.21 143.32,135.98 138.8,135.98 137.89,135.07 136.04,135.07 135.96,134.99 135.64,134.99 C4839.1
PCIE_DGPU_TX3N: length 18.3
  BOTTOM w0.107: C4842.1 138.02,134.62 138.97,135.57 143.49,135.57 147.68,139.76 150.9,139.76 151.08,139.95 151.82,139.95 151.92,139.85 152.36,139.67 152.56,139.57 U50000.BK39
PCIE_DGPU_TX3P: length 18.2
  BOTTOM w0.107: U50000.BL39 152.1,139.28 151.95,139.28 151.84,139.38 151.84,139.63 151.73,139.74 151.17,139.74 150.98,139.55 147.77,139.55 143.57,135.36 139.05,135.36 138.11,134.42 137.44,134.42 137.34,134.32 137.34,134.05 137.25,133.96 137.01,133.96 C4841.1
PCIE_DGPU_TX4N: length 18.5
  BOTTOM w0.107: U50000.BM39 151.23,139.11 147.91,139.11 143.74,134.95 139.24,134.95 137.84,133.55 135.72,133.55 C4882.1
PCIE_DGPU_TX4P: length 18.5
  BOTTOM w0.107: C4883.1 135.69,133.34 137.92,133.34 139.32,134.74 143.83,134.74 148,138.9 151.28,138.9 U50000.BM38
PCIE_DGPU_TX5N: length 18.6
  BOTTOM w0.107: C4834.1 137.21,132.29 137.31,132.39 137.31,132.6 137.4,132.69 138.54,132.69 139.97,134.12 144.09,134.12 148.1,138.13 151.68,138.13 151.85,138.31 152.35,138.31 152.44,138.4 152.44,138.55 152.31,138.68 U50000.BL38
PCIE_DGPU_TX5P: length 18.6
  BOTTOM w0.107: U50000.BK38 152.86,138.7 152.4,138.94 152.28,138.99 152.15,138.99 152,138.93 151.91,138.8 151.81,138.55 151.59,138.34 148.01,138.34 144,134.33 139.88,134.33 138.45,132.9 C4879.1
PCIE_DGPU_TX6N: length 20.4
  BOTTOM w0.107: U50000.BK36 152.49,137.49 152.09,137.67 151.99,137.71 151.92,137.73 151.82,137.83 151.1,137.83 150.97,137.7 148.25,137.7 144.26,133.71 140.64,133.71 138.8,131.87 135.36,131.87 C4812.1
PCIE_DGPU_TX6P: length 20.3
  BOTTOM w0.107: C4831.1 135.4,131.63 135.55,131.63 135.63,131.55 135.73,131.55 135.84,131.66 135.93,131.66 136.05,131.55 136.14,131.55 136.25,131.66 136.35,131.66 136.46,131.55 136.56,131.55 136.67,131.66 138.89,131.66 140.73,133.5 144.35,133.5 148.34,137.49 151.06,137.49 151.19,137.62 151.74,137.62 151.84,137.52 151.84,137.25 151.94,137.15 152.13,137.15 152.2,137.22 U50000.BL36
PCIE_DGPU_TX7N: length 18.7
  BOTTOM w0.107: U50000.BM36 151.26,137.04 148.47,137.04 144.52,133.09 141.02,133.09 139.12,131.19 136.79,131.19 136.19,130.58 135.78,130.58 C4810.1
PCIE_DGPU_TX7P: length 18.8
  BOTTOM w0.107: U50000.BM35 151.25,136.83 148.55,136.83 144.6,132.88 141.11,132.88 139.21,130.98 136.88,130.98 136.27,130.37 135.82,130.37 C4811.1
PCIE_DGPU_TX8N: length 21.2
  BOTTOM w0.107: U50000.BL35 152.45,136.58 152.55,136.47 152.55,136.3 152.48,136.22 151.88,136.22 151.7,136.04 148.64,136.04 144.86,132.26 141.36,132.26 139.47,130.36 137.14,130.36 135.99,129.21 135.27,129.21 C4820.1
PCIE_DGPU_TX8P: length 21.2
  BOTTOM w0.107: C4818.1 135.12,129.42 135.9,129.42 137.05,130.57 139.38,130.57 141.28,132.47 144.77,132.47 148.56,136.25 151.61,136.25 151.89,136.53 151.89,136.64 151.93,136.75 152.03,136.84 152.13,136.89 152.41,136.89 152.72,136.76 U50000.BK35
PCIE_DGPU_TX9N: length 22.8
  BOTTOM w0.107: C4822.1 133.45,128.52 135.88,128.52 137.31,129.95 139.64,129.95 141.54,131.85 145.03,131.85 148.71,135.52 150.89,135.52 151.15,135.78 151.78,135.78 151.84,135.76 151.95,135.67 152.13,135.56 152.55,135.36 U50000.BK33
PCIE_DGPU_TX9P: length 22.8
  BOTTOM w0.107: C4819.1 133.29,128.14 133.46,128.31 135.96,128.31 136.06,128.41 136.26,128.41 136.37,128.52 136.37,128.71 136.51,128.86 136.68,128.86 136.81,128.99 136.81,129.15 137.01,129.36 137.16,129.36 137.34,129.53 137.34,129.68 137.4,129.74 139.73,129.74 141.62,131.64 145.12,131.64 148.79,135.32 150.98,135.32 151.23,135.57 151.73,135.57 151.84,135.46 151.84,135.18 151.95,135.08 152.1,135.08 U50000.BL33
PCIE_DGPU_TX10N: length 15.3
  BOTTOM w0.107: C4821.1 139.06,128.83 139.4,128.83 141.8,131.23 145.29,131.23 148.93,134.87 151.19,134.87 U50000.BM33
PCIE_DGPU_TX10P: length 15.3
  BOTTOM w0.107: C4823.1 139.15,128.62 139.48,128.62 141.88,131.02 145.37,131.02 149.01,134.66 151.32,134.66 U50000.BM32
PCIE_DGPU_TX11N: length 23.6
  BOTTOM w0.107: C4833.1 132.74,127.01 132.95,127.01 133.05,126.91 133.05,126.8 133.12,126.72 134.74,126.72 135.23,127.21 138.7,127.21 142.09,130.61 145.54,130.61 149.11,134.17 151.73,134.17 151.83,134.27 151.83,134.66 151.95,134.78 152.1,134.78 152.22,134.66 152.22,134.5 U50000.BL32
PCIE_DGPU_TX11P: length 23.6
  BOTTOM w0.107: U50000.BK32 152.33,134.15 152.01,134.15 151.82,133.96 149.19,133.96 145.63,130.4 142.18,130.4 138.78,127 135.31,127 134.83,126.52 132.85,126.52 C4832.1
PCIE_DGPU_TX12N: length 20.2
  BOTTOM w0.107: U50000.BK30 152.53,132.84 152.32,132.77 152.12,132.77 152.03,132.81 151.93,132.91 151.81,133.2 151.61,133.4 151.26,133.4 151.19,133.33 149.44,133.33 145.89,129.78 142.44,129.78 138.6,125.95 136.22,125.95 C4878.1
PCIE_DGPU_TX12P: length 20.1
  BOTTOM w0.107: U50000.BL30 152.31,133.08 152.42,133.19 152.42,133.32 152.31,133.43 151.88,133.43 151.7,133.61 151.17,133.61 151.1,133.54 149.35,133.54 145.8,129.99 142.35,129.99 138.52,126.16 136.68,126.16 136.58,126.26 136.58,126.42 136.48,126.52 C4880.1
PCIE_DGPU_TX13N: length 19.9
  BOTTOM w0.107: C4881.1 135.02,125.07 136.23,125.07 136.69,125.54 138.77,125.54 142.61,129.37 146.06,129.37 149.52,132.83 151.25,132.83 U50000.BM30
PCIE_DGPU_TX13P: length 20
  BOTTOM w0.107: C4884.1 135.22,124.86 136.32,124.86 136.78,125.33 138.86,125.33 142.69,129.16 146.14,129.16 149.61,132.63 151.25,132.63 U50000.BM29
PCIE_DGPU_TX14N: length 18.7
  BOTTOM w0.107: U50000.BL29 152.12,132.46 151.96,132.46 151.86,132.36 151.86,132.15 151.7,132.03 151.01,132.03 150.85,132.19 149.75,132.19 146.32,128.75 142.86,128.75 138.48,124.37 138.04,124.37 137.95,124.46 137.95,124.78 137.85,124.89 137.68,124.89 C4886.1
PCIE_DGPU_TX14P: length 18.8
  BOTTOM w0.107: C4885.1 138.57,124.16 142.95,128.54 146.4,128.54 149.84,131.98 150.77,131.98 150.92,131.82 151.77,131.82 152.09,132.07 152.36,132.07 U50000.BK29
PCIE_DGPU_TX15N: length 21.6
  BOTTOM w0.107: U50000.BK27 152.54,131.18 152.29,131.3 151.91,131.3 151.7,131.51 149.95,131.51 146.57,128.13 143.12,128.13 138.3,123.31 136.26,123.31 136.07,123.5 C4888.1
PCIE_DGPU_TX15P: length 21.6
  BOTTOM w0.107: C4887.1 134.92,122.97 135.24,123.29 135.99,123.29 136.17,123.1 138.39,123.1 143.21,127.92 146.66,127.92 150.04,131.3 151.62,131.3 151.85,131.07 151.85,130.8 151.94,130.71 152.06,130.71 152.15,130.8 152.15,130.93 U50000.BL27
PCIE_LAN_C_RX13N: length 1.7
  BOTTOM w0.107: U1700.8 97.55,38.09 97.44,37.99 97.44,37.3 C1710.2
PCIE_LAN_C_RX13P: length 1.7
  BOTTOM w0.107: C1706.2 97.23,37.44 97.23,37.97 97.15,38.05 U1700.9
PCIE_LAN_RX13N: length 150.3
  L10 w0.084: v1(238.77,43.71) 238.69,43.32 238.75,43.22 238.75,42.71 237.27,41.23 234.95,41.23 233.65,39.93 231.52,39.93 230.99,40.46 218.51,40.46 218.38,40.59 214.5,40.59 213.91,41.18 183.49,41.18 178.49,36.18 173.38,36.18 172.41,35.21 168.83,35.21 167.44,33.82 153.53,33.82 152.74,34.61 135.98,34.61 134.42,36.16 97.8,36.16 97.32,35.69 97.32,35.57 v1(97.52,35.37)
  BOTTOM w0.107: v1(97.52,35.37) 97.3,35.59 97.3,35.77 C1710.1 ; v1(238.77,43.71) 238.77,43.71 238.77,43.58 238.64,43.45 U4710.C45
PCIE_LAN_RX13P: length 150.3
  L10 w0.084: v1(238.12,43.29) 238.51,43.2 238.54,43.16 238.54,42.8 237.18,41.44 234.86,41.44 233.56,40.14 231.61,40.14 231.08,40.67 218.6,40.67 218.47,40.8 214.58,40.8 214,41.39 183.4,41.39 178.4,36.39 173.29,36.39 172.32,35.42 168.74,35.42 167.36,34.03 153.62,34.03 152.83,34.82 136.06,34.82 134.51,36.38 97.71,36.38 97.11,35.78 97.11,35.62 v3(96.86,35.37)
  BOTTOM w0.107: v3(96.86,35.37) 97.08,35.59 97.08,36.07 96.97,36.18 C1706.1 ; v1(238.12,43.29) 238.17,43.26 U4710.C46
PCIE_LAN_TX13N: length 144
  L10 w0.084: v1(232.18,42.45) 232.2,42.42 232.2,42.13 231.47,41.4 230.4,41.4 230.27,41.27 218.85,41.27 218.72,41.4 214.83,41.4 214.23,42.01 183.17,42.01 178.43,37.26 169.73,37.26 167.11,34.63 153.86,34.63 153.43,35.07 153.08,35.42 136.31,35.42 134.76,36.97 102.88,36.97 101.95,37.9 101.83,38.03 100.28,38.03 99.5,37.24 v1(99.41,37.24)
  BOTTOM w0.107: v1(99.41,37.24) 99.54,37.24 99.64,37.35 99.64,37.96 99.55,38.05 U1700.3 ; C4960.1 232.95,45.37 232.73,45.37 232.43,45.07 232.43,42.7 v1(232.18,42.45)
PCIE_LAN_TX13P: length 143.9
  L10 w0.084: v1(100.08,37.1) 99.97,37.21 99.97,37.42 100.37,37.82 101.74,37.82 102.79,36.76 134.67,36.76 136.22,35.21 152.99,35.21 153.22,34.98 153.78,34.42 167.19,34.42 169.82,37.05 178.51,37.05 183.26,41.8 214.14,41.8 214.75,41.19 218.63,41.19 218.76,41.06 230.36,41.06 230.49,41.19 231.56,41.19 232.82,42.44 v1(232.89,42.44)
  BOTTOM w0.107: v1(232.89,42.45) 232.89,42.45 232.64,42.71 232.64,44.98 232.82,45.16 232.97,45.16 C4961.1 ; v1(100.08,37.1) 99.85,37.33 99.85,37.96 99.95,38.06 U1700.2
PCIE_RCOMPN: length 2
  TOP w0.305: v3(237.28,58.75) 237.32,58.79 R4608.2
  BOTTOM w0.254: v3(237.28,58.75) 237.29,58.75 237.58,58.75 238.04,59.22 U4710.B12
PCIE_RCOMPP: length 2.2
  TOP w0.254: v1(237.08,59.38) 237.08,59.8 v2(237.31,60.02) 237.69,59.64 R4608.1
  BOTTOM w0.254: U4710.A13 237.42,59.38 v1(237.08,59.38)
PCIE_REP_EN#: length 3
  BOTTOM w0.102: U1700.11 96.3,38.5 v2(95.78,37.98) 95.53,38.22 R1701.2 R1700.2
PCIE_SSD_RX9N: length 187.2
  L3 w0.084: v1(70.48,41.88) 70.68,42.08 70.68,42.59 73.51,45.43 87.94,45.43 90.26,43.12 96.33,43.12 96.48,43.27 105.78,43.27 106.94,42.1 131.45,42.1 131.85,42.5 153.64,42.5 154.69,43.55 160.12,43.55 160.51,43.16 166.52,43.16 167.72,44.36 197.62,44.36 198.23,43.75 201.71,43.75 202.03,44.08 210.56,44.08 212.26,42.38 215.95,42.38 216.09,42.52 228.99,42.52 230.47,44 230.82,44.35 235.28,44.35 237.76,46.83 238.79,47.86 239.98,47.86 240.17,48.05 v1(240.19,48.05)
  BOTTOM w0.107: U4710.G36 v1(240.19,48.05) ; CN1901.5 75.21,36.05 75.07,36.2 74.64,36.2 70.68,40.15 70.68,41.68 v1(70.48,41.88)
PCIE_SSD_RX9P: length 187.2
  L3 w0.084: v1(71.14,41.88) 70.89,42.13 70.89,42.5 73.6,45.22 87.86,45.22 90.17,42.91 96.41,42.91 96.56,43.06 105.69,43.06 106.86,41.89 131.54,41.89 131.94,42.29 153.73,42.29 154.78,43.34 160.03,43.34 160.42,42.95 166.61,42.95 167.81,44.15 197.53,44.15 198.14,43.54 201.8,43.54 202.12,43.86 210.47,43.86 212.17,42.17 216.04,42.17 216.18,42.31 229.08,42.31 230.68,43.91 230.91,44.14 235.37,44.14 237.97,46.74 238.88,47.65 240.5,47.65 240.59,47.57 v3(240.59,47.45)
  BOTTOM w0.107: v3(240.59,47.45) 240.38,47.66 240.16,47.66 U4710.F36 ; v1(71.14,41.88) 70.89,41.63 70.89,40.24 74.72,36.4 75.07,36.4 75.21,36.55 CN1901.7
PCIE_SSD_RX10N: length 183.9
  L3 w0.084: v1(241.88,46.94) 241.59,46.94 241.49,47.05 238.83,47.05 238.35,46.58 235.53,43.75 231.07,43.75 229.1,41.79 219.53,41.79 219.22,41.48 211.93,41.48 211.63,41.79 192.67,41.79 190.7,43.76 167.97,43.76 166.77,42.56 160.26,42.56 159.87,42.95 156.28,42.95 153.84,40.52 135.72,40.52 135.1,39.89 133.19,39.89 131.99,41.08 105.15,41.08 104.38,41.85 89.84,41.85 86.94,44.75 74.81,44.75 74.64,44.75 72.79,42.9 72.79,41.73 v3(72.67,41.61)
  BOTTOM w0.107: CN1901.17 74.6,39.05 72.92,40.74 72.92,41.36 v3(72.67,41.61) ; U4710.K37 v1(241.88,46.94)
PCIE_SSD_RX10P: length 183.9
  L3 w0.084: v3(241.4,46.42) 241.47,46.42 241.56,46.5 241.56,46.68 241.4,46.84 238.92,46.84 238.57,46.49 238.57,46.49 235.62,43.54 231.15,43.54 229.19,41.58 219.62,41.58 219.31,41.27 211.85,41.27 211.54,41.58 192.59,41.58 190.62,43.55 168.05,43.55 166.86,42.35 160.17,42.35 159.78,42.74 156.36,42.74 153.93,40.31 135.81,40.31 135.18,39.68 133.1,39.68 131.91,40.87 105.06,40.87 104.29,41.64 89.75,41.64 86.85,44.54 74.72,44.54 73,42.81 73,42.04 73.08,41.96 73.27,41.96 v1(73.33,42.02)
  BOTTOM w0.107: v3(241.4,46.42) 241.37,46.45 U4710.J37 ; CN1901.19 75.31,39.55 75.02,39.26 74.69,39.26 73.12,40.82 73.12,41.81 v1(73.33,42.02)
PCIE_SSD_RX11N: length 172.9
  L3 w0.084: v1(240.66,46.18) 240.62,46.23 240.23,46.23 240.01,46.45 239.08,46.45 238.95,46.33 235.78,43.15 231.32,43.15 229.35,41.19 219.78,41.19 219.47,40.88 211.69,40.88 211.38,41.19 192.23,41.19 190.26,43.16 170.96,43.16 169.69,41.89 160.08,41.89 159.63,42.34 156.59,42.34 154.16,39.92 136.03,39.92 135.26,39.14 132.66,39.14 131.43,40.37 104.58,40.37 104.13,40.82 89.35,40.82 87.79,42.38 79.03,42.38 78.68,42.72 v3(78.68,43.08)
  BOTTOM w0.107: CN1901.29 78.02,42.05 78.51,42.54 78.51,42.91 v3(78.68,43.08) ; U4710.G38 240.72,46.24 v1(240.66,46.18)
PCIE_SSD_RX11P: length 173
  L3 w0.084: v1(240.14,45.83) 240.14,46.02 239.92,46.24 239.16,46.24 235.87,42.94 231.4,42.94 229.44,40.98 219.86,40.98 219.56,40.67 211.6,40.67 211.29,40.98 192.15,40.98 190.17,42.95 171.05,42.95 169.78,41.68 160,41.68 159.54,42.13 156.67,42.13 154.25,39.71 136.12,39.71 135.34,38.93 132.57,38.93 131.34,40.16 104.49,40.16 104.04,40.61 89.26,40.61 87.7,42.17 78.94,42.17 78.03,43.08 v1(78.02,43.08)
  BOTTOM w0.107: v1(78.02,43.08) 78.1,43.08 78.3,42.88 78.3,42.63 77.94,42.26 77.23,42.26 76.94,42.55 CN1901.31 ; U4710.F39 240.14,46.24 v1(240.14,45.83)
PCIE_SSD_RX12N: length 180.2
  L3 w0.084: v1(241.45,44.68) 241.19,44.68 240.81,44.3 238.22,44.3 235.68,41.76 232.15,41.76 230.75,40.36 220.1,40.36 219.81,40.07 211.35,40.07 211.06,40.36 197.3,40.36 196.31,39.37 171.08,39.37 167.35,35.64 160.73,35.64 159.19,37.18 135.84,37.18 135.04,37.98 102.18,37.98 101.24,38.92 87.58,38.92 85.8,40.69 74.75,40.69 74.16,41.29 74.16,41.73 v1(73.96,41.92)
  BOTTOM w0.107: CN1901.43 75.21,45.55 75.07,45.4 74.57,45.4 74.19,45.02 74.19,42.15 v1(73.96,41.92) ; U4710.H42 v1(241.45,44.68)
PCIE_SSD_RX12P: length 180.2
  L3 w0.084: v3(74.62,41.92) 74.5,41.92 74.37,41.79 74.37,41.37 74.84,40.91 85.89,40.91 87.66,39.13 101.33,39.13 102.27,38.19 135.13,38.19 135.92,37.39 159.27,37.39 160.82,35.85 167.26,35.85 170.99,39.58 196.22,39.58 197.22,40.57 211.15,40.57 211.44,40.28 219.72,40.28 220.01,40.57 230.66,40.57 232.06,41.97 235.59,41.97 238.13,44.51 240.72,44.51 241.29,45.08 241.55,45.08 v1(241.77,45.3)
  BOTTOM w0.089: U4710.J41 241.42,45.22 241.69,45.22 v1(241.77,45.3)
  BOTTOM w0.107: CN1901.41 75.21,45.05 75.07,45.2 74.65,45.2 74.39,44.94 74.39,42.15 v3(74.62,41.92)
PCIE_SSD_RX21N: length 86.9
  L10 w0.084: v1(244.4,44.56) 244.4,44.56 244.23,44.39 244.23,44.28 243.66,43.72 243.35,43.72 241.74,42.1 241.34,42.1 240.24,41.01 239.38,41.01 238.28,39.91 235.71,39.91 233.87,38.07 232.64,38.07 232.36,38.35 230.97,38.35 230.18,39.14 221.88,39.14 221.24,38.5 214.59,38.5 213.15,39.93 199.4,39.93 198.78,39.31 185.18,39.31 185.01,39.14 185.01,38.95 v1(185.09,38.87)
  BOTTOM w0.107: v1(244.4,44.56) 244.41,44.56 245.01,44.56 U4710.T43 ; v1(185.09,38.87) 184.79,39.17 184.79,42.76 184.06,43.49 173.33,43.49 169.74,39.9 169.53,39.9 169.39,40.05 CN1900.5
PCIE_SSD_RX21P: length 86.9
  L10 w0.084: v1(243.83,44.45) 243.83,44.19 243.57,43.93 243.27,43.93 241.65,42.31 241.25,42.31 240.15,41.22 239.29,41.22 238.2,40.12 235.62,40.12 233.78,38.28 232.73,38.28 232.45,38.56 231.06,38.56 230.27,39.35 221.79,39.35 221.15,38.71 214.67,38.71 213.24,40.14 199.32,40.14 198.7,39.52 185.09,39.52 v1(184.43,38.87)
  BOTTOM w0.107: CN1900.7 169.39,39.55 169.53,39.7 169.83,39.7 173.42,43.29 183.97,43.29 184.58,42.67 184.58,39.02 v1(184.43,38.87) ; v1(243.83,44.45) 243.83,44.26 243.94,44.15 244.37,44.15 U4710.R44
PCIE_SSD_RX22N: length 84.1
  L10 w0.084: v1(245.02,45.68) 244.89,45.55 243.63,45.55 242.77,44.68 242.39,44.68 242,44.29 241.29,44.29 241.26,44.32 238.29,44.32 237.7,43.73 231.88,43.73 230.18,42.02 230.02,41.87 219.96,41.87 218.41,43.42 214.51,43.42 213.7,42.61 200.27,42.61 199.73,43.14 196.73,43.14 196.58,43.29 183.37,43.29 179.18,39.1 171.9,39.1 171.52,38.72 171.52,38.01 v1(171.3,37.79)
  BOTTOM w0.107: CN1900.17 169.39,37.05 169.53,36.9 171.44,36.9 171.54,37.01 171.54,37.55 v1(171.3,37.79) ; v1(245.02,45.68) 245.12,45.77 245.16,45.77 245.39,46 U4710.U40
PCIE_SSD_RX22P: length 84
  L10 w0.084: v1(244.9,45.04) 244.73,45.3 244.72,45.3 244.56,45.3 244.53,45.33 243.72,45.33 242.86,44.47 242.48,44.47 242.09,44.08 241.2,44.08 241.17,44.11 238.38,44.11 237.79,43.52 231.97,43.52 230.26,41.81 230.11,41.66 219.87,41.66 218.32,43.21 214.6,43.21 213.79,42.4 200.18,42.4 199.65,42.93 196.65,42.93 196.49,43.08 183.46,43.08 179.39,39.02 179.27,38.89 171.99,38.89 171.73,38.63 171.73,38.02 v1(171.96,37.79)
  BOTTOM w0.107: CN1900.19 169.39,36.55 169.53,36.7 171.52,36.7 171.75,36.92 171.75,37.59 v1(171.96,37.79) ; U4710.U41 245.01,45.27 244.9,45.16 v1(244.9,45.04)
PCIE_SSD_RX23N: length 87.5
  L10 w0.084: v1(246.78,44.14) 246.38,43.75 246.38,42.86 245.89,42.36 245.71,42.36 245.07,42.36 242.48,39.77 239.84,39.77 238.78,38.71 238.11,38.71 238.11,38.71 236.22,38.71 234.15,36.64 232.69,36.64 232.07,36.02 224.31,36.02 223.21,37.13 212.07,37.13 211.79,36.85 205.44,36.85 204.88,36.29 197.07,36.29 196.48,35.71 190.43,35.71 189.14,34.42 175.16,34.42 173.13,32.39 173.13,31.86 v3(173.38,31.61)
  BOTTOM w0.107: v3(173.38,31.61) 173.13,31.87 173.13,32.23 171.46,33.9 169.53,33.9 169.39,34.05 CN1900.29 ; U4710.W43 246.46,44.46 v1(246.78,44.14)
PCIE_SSD_RX23P: length 87.5
  L10 w0.084: v1(172.7,31.59) 172.92,31.81 172.92,32.48 175.07,34.63 189.06,34.63 190.34,35.92 196.4,35.92 196.98,36.5 204.8,36.5 205.36,37.06 211.71,37.06 211.98,37.34 223.29,37.34 224.4,36.23 231.98,36.23 232.6,36.85 234.07,36.85 236.14,38.92 238.19,38.92 238.69,38.92 239.75,39.98 242.39,39.98 244.98,42.57 245.8,42.57 246.17,42.94 246.17,44.1 246.02,44.25 v1(245.94,44.25)
  BOTTOM w0.107: v1(172.7,31.59) 172.92,31.81 172.92,32.14 171.37,33.7 169.53,33.7 169.39,33.55 CN1900.31 ; v1(245.94,44.25) 246.16,44.25 246.27,44.14 U4710.W44
PCIE_SSD_RX24N: length 87.9
  L10 w0.084: v1(170.22,31.61) 170.45,31.84 170.45,32.27 173.85,35.67 186.21,35.67 188.65,38.11 210.29,38.11 210.9,38.72 211.85,38.72 212.46,38.11 222.87,38.11 223.48,38.72 229.76,38.72 231.02,37.45 233.82,37.45 235.89,39.52 238.44,39.52 239.54,40.62 241.37,40.62 242.73,41.98 243.51,41.98 245.3,43.77 245.3,44.88 245.92,45.49 v1(245.92,45.55)
  BOTTOM w0.107: v1(170.22,31.61) 170.45,31.39 170.45,30.99 170.34,30.88 169.56,30.88 169.39,31.05 CN1900.41 ; U4710.Y40 246.86,46 v1(245.92,45.55)
PCIE_SSD_RX24P: length 87.8
  L10 w0.084: v1(246.12,44.89) 246.12,44.99 246.03,45.08 245.8,45.08 245.51,44.79 245.51,43.68 243.6,41.77 242.82,41.77 241.58,40.53 241.46,40.41 239.63,40.41 238.53,39.31 235.98,39.31 233.91,37.24 230.94,37.24 229.67,38.51 223.57,38.51 222.96,37.9 212.37,37.9 211.77,38.51 210.99,38.51 210.38,37.9 188.74,37.9 186.3,35.46 173.94,35.46 170.66,32.19 170.66,31.84 v1(170.89,31.61)
  BOTTOM w0.107: CN1900.43 169.39,30.55 169.51,30.67 170.43,30.67 170.66,30.9 170.66,31.39 v1(170.89,31.61) ; v1(246.12,44.89) 246.12,45.14 246.25,45.27 U4710.Y41
PCIE_SSD_TX9N: length 167.1
  TOP w0.107: v1(78.84,48.51) 78.67,48.34 78.64,48.34 78.57,48.26 77.77,48.26 77.24,48.8 76.12,48.8 75.84,49.08 C1916.1
  L3 w0.084: v1(78.84,48.51) 78.84,48.41 79.02,48.24 79.14,48.24 80.79,49.89 112,49.89 112.3,49.59 129.75,49.59 130.67,48.68 139.46,48.68 139.95,48.19 152.33,48.19 153.43,49.29 222.26,49.29 222.75,48.8 234.25,48.8 234.48,48.57 235.49,48.57 235.58,48.66 235.58,48.93 235.43,49.08 v1(235.35,49.08)
  BOTTOM w0.089: U4710.C34 238.74,48.5 238.65,48.42 238.5,48.42 238.3,48.61 237.4,48.61 237.3,48.51 235.92,48.51 v1(235.35,49.08)
PCIE_SSD_TX9P: length 167.1
  TOP w0.107: v3(78.84,47.85) 78.64,48.06 77.69,48.06 77.15,48.59 76.11,48.59 C1919.1
  L3 w0.084: v1(236.01,49.08) 235.79,48.85 235.79,48.57 235.58,48.36 234.39,48.36 234.16,48.59 222.66,48.59 222.18,49.08 153.52,49.08 152.42,47.98 139.86,47.98 139.37,48.47 130.58,48.47 129.67,49.38 112.21,49.38 111.92,49.68 80.87,49.68 79.22,48.03 79.02,48.03 v3(78.84,47.85)
  BOTTOM w0.089: U4710.D34 238.81,48.87 238.69,48.87 238.41,48.79 237.33,48.79 237.23,48.69 235.99,48.69 235.87,48.81 235.87,48.93 v1(236.01,49.08)
PCIE_SSD_TX10N: length 157.2
  L3 w0.084: v1(233.27,46.7) 233.06,46.48 233.06,46.22 232.55,45.72 220.79,45.72 218.75,47.76 153.9,47.76 152.31,46.17 127.29,46.17 126.6,46.87 114.68,46.87 114.07,46.26 104.6,46.26 104.4,46.46 93.87,46.46 93.21,45.8 v3(93.21,45.54)
  BOTTOM w0.089: 235.06,48.14 235.08,48.14 235.09,48.16 237.92,48.16 238.07,48.01 238.38,48.01 238.71,48.01 U4710.C35
  BOTTOM w0.107: v3(93.21,45.54) 93.02,45.35 93.02,44.38 90.54,41.91 88.76,41.91 C1917.1 ; v1(233.27,46.7) 233.07,46.9 233.07,47.35 233.86,48.14 235.06,48.14
PCIE_SSD_TX10P: length 157.2
  L3 w0.084: v1(232.56,46.7) 232.65,46.7 232.85,46.5 232.85,46.31 232.46,45.93 220.88,45.93 218.84,47.97 153.81,47.97 152.23,46.38 127.38,46.38 126.68,47.08 114.59,47.08 113.98,46.47 104.69,46.47 104.48,46.67 93.78,46.67 92.65,45.54 v1(92.55,45.54)
  BOTTOM w0.089: U4710.B35 238.2,48.26 238.13,48.33 235.09,48.33 235.08,48.35 235.06,48.35
  BOTTOM w0.107: v1(232.56,46.7) 232.62,46.7 232.86,46.94 232.86,47.44 233.77,48.35 235.06,48.35 ; v1(92.55,45.54) 92.69,45.54 92.81,45.42 92.81,44.47 90.46,42.12 88.62,42.12 88.41,42.33 C1918.1
PCIE_SSD_TX11N: length 153.8
  L3 w0.084: v1(234.77,46.67) 234.59,46.49 234.59,46.23 233.47,45.11 220.54,45.11 218.5,47.16 154.18,47.16 152.57,45.54 132.25,45.54 131.42,44.71 96.59,44.71 96.39,44.5 91.54,44.5 91.33,44.72 v1(90.86,44.72)
  BOTTOM w0.089: U4710.B36 238.11,47.65 237.92,47.65 237.79,47.78 235.96,47.78 235.76,47.58 234.99,47.58 234.57,47.15 234.57,46.88 v1(234.77,46.67)
  BOTTOM w0.107: v1(90.86,44.72) 90.86,44.88 90.75,44.99 90.12,44.99 89.76,44.63 89.76,44.13 C1920.1
PCIE_SSD_TX11P: length 153.8
  L3 w0.084: v3(91.31,45.24) 91.31,45.04 91.63,44.72 96.3,44.72 96.51,44.92 131.33,44.92 132.16,45.75 152.48,45.75 154.1,47.37 218.59,47.37 220.63,45.32 233.39,45.32 234.37,46.31 234.37,46.5 v1(234.19,46.69)
  BOTTOM w0.089: v1(234.19,46.69) 234.39,46.89 234.39,47.22 234.92,47.76 235.68,47.76 235.89,47.96 237.87,47.96 237.99,47.83 238.03,47.83 238.03,47.83 238.31,47.83 238.32,47.83 238.55,47.6 U4710.C36
  BOTTOM w0.107: C1921.1 89.43,44.58 89.43,44.6 90.03,45.2 90.65,45.2 90.66,45.2 91.27,45.2 v3(91.31,45.24)
PCIE_SSD_TX12N: length 154.7
  L3 w0.084: v1(236.47,46.66) 236.26,46.88 236.26,47.13 235.42,47.97 229.44,47.97 228.05,46.57 221.08,46.57 219.15,48.5 218.98,48.68 153.67,48.68 153.56,48.57 152.58,47.59 152.26,47.59 141.31,47.59 140.94,47.22 132.83,47.22 132.21,47.84 90.95,47.84 90.74,47.63 v1(90.47,47.63)
  BOTTOM w0.089: v1(236.47,46.66) 236.27,46.87 236.27,47.07 236.57,47.37 237.68,47.37 237.89,47.17 238.84,47.17 U4710.D38
  BOTTOM w0.107: C1922.1 89.63,46.64 90.12,46.64 90.47,46.99 v1(90.47,47.63)
PCIE_SSD_TX12P: length 154.8
  L3 w0.084: v1(235.84,46.66) 236.05,46.88 236.05,47.04 235.33,47.76 229.53,47.76 228.13,46.36 220.99,46.36 218.89,48.47 153.76,48.47 153.65,48.35 152.67,47.38 152.17,47.38 141.39,47.38 141.03,47.01 132.74,47.01 132.13,47.63 91.03,47.63 90.64,47.23 90.12,47.23 v3(90.03,47.13)
  BOTTOM w0.089: v1(235.84,46.66) 236.09,46.92 236.09,47.15 236.5,47.55 237.76,47.55 237.96,47.35 238.92,47.35 239.05,47.22 239.17,47.22 239.2,47.19 U4710.E37
  BOTTOM w0.107: v3(90.03,47.13) 90.03,46.96 89.92,46.85 89.55,46.85 89.3,47.1 C1923.1
PCIE_SSD_TX21N: length 63.8
  L10 w0.084: v1(240.13,43.31) 240.13,43.06 240.29,42.89 240.29,42.36 239.54,41.61 239.13,41.61 238.03,40.51 235.08,40.51 233.9,39.33 230.98,39.33 230.57,39.74 221.63,39.74 221.06,39.17 217.58,39.17 216.77,39.98 214.26,39.98 214.25,39.99 213.67,40.57 191.61,40.57 190.96,39.91 183.94,39.91 183.17,39.14 v1(183.17,38.88)
  BOTTOM w0.089: v1(240.13,43.31) 240.12,43.3 240.12,42.52 U4710.G47
  BOTTOM w0.107: v1(183.17,38.88) 182.96,39.09 182.96,39.99 C1925.1
PCIE_SSD_TX21P: length 63.8
  L10 w0.084: v1(239.72,42.89) 239.8,42.96 239.92,42.96 240.08,42.8 240.08,42.45 239.45,41.82 239.04,41.82 237.95,40.72 234.99,40.72 233.81,39.54 231.06,39.54 230.66,39.95 221.54,39.95 220.97,39.38 217.67,39.38 216.86,40.19 214.35,40.19 214.34,40.2 213.76,40.78 191.53,40.78 190.87,40.12 183.85,40.12 183.01,39.28 183,39.28 182.77,39.05 182.77,39.04 182.61,38.88 v1(182.51,38.88)
  BOTTOM w0.089: U4710.F46 239.79,42.36 239.94,42.51 239.94,42.67 v1(239.72,42.89)
  BOTTOM w0.107: C1924.1 182.49,40.27 182.75,40.01 182.75,39.15 182.72,39.12 182.72,39.1 v1(182.51,38.88)
PCIE_SSD_TX22N: length 75.6
  L10 w0.084: v3(178.86,28.68) 178.87,28.68 179.42,28.13 184.99,28.13 185.12,28.25 185.12,28.25 186.84,29.97 192.04,29.97 192.63,30.56 194.58,30.56 194.77,30.75 198.03,30.75 199.62,32.34 202.99,32.34 203.98,33.33 206.71,33.33 206.97,33.06 210.28,33.06 211.38,34.16 213.55,34.16 214.98,32.73 222.28,32.73 222.8,33.24 232.16,33.24 232.99,32.41 235.56,32.41 238.43,35.28 239.87,35.28 241.98,37.4 v1(241.98,38.59)
  BOTTOM w0.089: U4710.H47 241.32,42.14 241.32,41.38 241.47,41.23 241.47,39.09 241.98,38.59 v1(241.98,38.59)
  BOTTOM w0.107: C1927.1 179.06,28.37 179.06,28.48 v3(178.86,28.68)
PCIE_SSD_TX22P: length 75.6
  L10 w0.084: v1(241.48,38.28) 241.65,38.28 241.77,38.16 241.77,37.48 239.78,35.49 238.35,35.49 235.48,32.62 233.08,32.62 232.25,33.45 222.71,33.45 222.2,32.94 215.07,32.94 213.64,34.37 211.29,34.37 210.2,33.27 207.06,33.27 206.79,33.54 203.9,33.54 202.91,32.55 199.53,32.55 197.94,30.96 194.69,30.96 194.49,30.77 192.54,30.77 191.95,30.18 186.75,30.18 184.91,28.34 179.51,28.34 179.26,28.59 179.26,28.75 v1(179.6,29.09)
  BOTTOM w0.089: U4710.H48 241.07,41.88 241.14,41.81 241.14,41.3 241.3,41.15 241.3,39.02 241.6,38.72 241.6,38.39 v1(241.48,38.28)
  BOTTOM w0.107: C1926.1 179.27,28.34 179.27,28.94 179.42,29.09 v1(179.6,29.09)
PCIE_SSD_TX23N: length 68.4
  L10 w0.084: v1(239.68,38.65) 239.51,38.48 239.2,38.48 239.01,38.29 237.15,38.29 236.97,38.12 236.97,38.12 236.5,37.64 234.48,35.63 222.97,35.63 222.53,36.07 217.9,36.07 217.4,35.57 210.71,35.57 210.18,35.05 199.71,35.05 199.03,34.37 193.09,34.37 191.43,32.7 183.6,32.7 180.84,29.94 180.84,29.52 180.7,29.38 v3(180.6,29.38)
  BOTTOM w0.089: 240.32,40.29 240.32,40.31 240.31,40.33 240.31,41.14 U4710.G49
  BOTTOM w0.107: v1(239.68,38.65) 239.57,38.76 239.57,39.26 240.32,40.01 240.32,40.29 ; v3(180.6,29.38) 180.6,29.35 180.87,29.08 180.87,28.33 180.56,28.01 C1928.1
PCIE_SSD_TX23P: length 68.5
  L10 w0.084: v1(181.26,29.38) 181.06,29.59 181.06,29.86 183.69,32.49 191.51,32.49 193.18,34.16 199.12,34.16 199.79,34.83 210.27,34.83 210.79,35.36 217.49,35.36 217.99,35.86 222.44,35.86 222.88,35.42 234.57,35.42 236.71,37.56 237.23,38.08 v1(239.37,38.08)
  BOTTOM w0.089: 240.11,40.29 240.11,40.31 240.13,40.33 240.13,41.21 240.29,41.37 240.29,41.52 240.33,41.56 U4710.G48
  BOTTOM w0.107: C1909.1 181.08,28.31 181.08,29.2 v1(181.26,29.38) ; v1(239.37,38.08) 239.37,38.39 239.27,38.48 239.27,38.82 239.37,38.91 239.37,39.35 240.11,40.09 240.11,40.29
PCIE_SSD_TX24N: length 70.2
  L10 w0.084: v3(182.33,29.4) 182.46,29.4 182.57,29.52 182.57,30.15 183.3,30.87 191.73,30.87 192.57,31.72 194.71,31.72 194.94,31.95 194.94,32.33 195.44,32.83 198.97,32.83 199.28,33.15 202.66,33.15 203.96,34.45 210.43,34.45 210.95,34.97 213.89,34.97 214.41,34.45 218.77,34.45 219.1,34.12 229.84,34.12 230.75,35.03 234.73,35.03 237.1,37.39 237.22,37.52 240.13,37.52 240.43,37.81 240.43,38.08 240.42,38.09 240.42,38.42 240.42,38.42 v1(240.42,38.72)
  BOTTOM w0.089: 240.58,40.89 240.58,41.04 240.79,41.24 240.79,41.5 240.78,41.5 240.78,41.54 240.64,41.69 240.64,42.7 240.46,42.88 U4710.G46
  BOTTOM w0.107: 240.58,40.89 240.57,40.87 240.57,39.64 240.69,39.52 240.69,38.83 240.58,38.72 v1(240.42,38.72) ; v3(182.33,29.4) 182.33,29.38 182.6,29.11 182.6,28.22 182.39,28.01 C1930.1
PCIE_SSD_TX24P: length 70.2
  L10 w0.084: v1(240.81,38.26) 240.64,38.08 240.64,37.72 240.22,37.31 237.31,37.31 234.82,34.82 230.84,34.82 229.93,33.9 219.01,33.9 218.68,34.24 214.33,34.24 213.8,34.76 211.04,34.76 210.52,34.24 204.04,34.24 202.75,32.94 199.37,32.94 199.05,32.62 195.53,32.62 195.15,32.25 195.15,31.86 194.79,31.51 192.66,31.51 191.82,30.66 183.38,30.66 182.78,30.06 182.78,29.61 v1(182.99,29.4)
  BOTTOM w0.089: U4710.G45 240.81,42.73 240.81,41.76 240.96,41.61 240.96,41.57 240.96,41.57 240.96,41.17 240.77,40.98 240.77,40.81 240.78,40.8
  BOTTOM w0.107: v1(182.99,29.4) 182.81,29.22 182.81,28.37 C1929.1 ; v1(240.81,38.26) 240.81,38.56 240.82,38.66 240.9,38.74 240.9,39.6 240.78,39.73 240.78,40.8
PCIE_WLAN_CTX6N: length 4.2
  TOP w0.107: C1322.2 279.55,22.6 279.55,22.28 v1(279.76,22.07)
  BOTTOM w0.107: CN1300.37 280.95,20.98 280.8,21.13 280.8,21.36 280.55,21.62 279.7,21.62 279.55,21.77 279.55,21.92 279.7,22.07 v1(279.76,22.07)
PCIE_WLAN_CTX6P: length 4.3
  TOP w0.107: v3(279.1,22.07) 279.35,22.31 279.35,22.57 279.02,22.9 C1323.2
  BOTTOM w0.107: CN1300.35 280.45,20.99 280.6,21.14 280.6,21.28 280.46,21.41 279.62,21.41 279.34,21.68 279.34,21.83 v3(279.1,22.07)
PCIE_WLAN_RX14N: length 57.7
  L8 w0.084: v1(281.83,23.98) 281.66,24.15 281.66,24.58 280.32,25.93 280.32,28.87 275.47,33.72 259.24,33.72 254.05,38.91 247.2,38.91 245.52,40.59 244.47,40.59 244.1,40.96 244.1,41.27 244.1,41.27 244.1,41.45 243.06,42.49 239.56,42.49 239.38,42.66 v1(239.19,43.16)
  BOTTOM w0.089: U4710.D46 v1(239.19,43.16)
  BOTTOM w0.107: v1(281.83,23.98) 281.83,22.1 282.3,21.63 282.3,21.19 282.45,21.05 282.45,20.08 CN1300.43
PCIE_WLAN_RX14P: length 57.6
  L8 w0.084: v1(239.09,42.24) 239.12,42.28 239.23,42.28 242.97,42.28 243.89,41.36 243.89,40.87 244.38,40.38 245.43,40.38 247.11,38.7 253.96,38.7 259.15,33.51 275.38,33.51 280.11,28.78 280.11,25.84 281.45,24.5 281.45,24.12 281.31,23.98 v3(281.12,23.98)
  BOTTOM w0.089: v1(239.09,42.24) 239.09,42.29 238.97,42.41 238.63,42.41 U4710.C47
  BOTTOM w0.107: v3(281.12,23.98) 281.25,23.98 281.62,23.61 281.62,22.02 282.1,21.55 282.1,21.19 281.95,21.05 CN1300.41
