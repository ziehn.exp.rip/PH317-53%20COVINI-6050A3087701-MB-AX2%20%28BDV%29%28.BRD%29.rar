# Allegro board PH317-53 COVINI-6050A3087701-MB-AX2 (BDV)(.BRD).brd (continued)
## Library data of the parts (continued)
C7545 C7548 C7549 C7560-C7568 C7570-C7572 = CSC0402: part number: CSC0402-0.1UF_25V_2,6010B0087101,CSC_100X050X040_2,0.55MM,CSC0402,0402,X5R,CAP-CHIP,0.1UF,25V,K,X5R,0402,TR; signal model: C2_6010B0087101_0_1uF_25V_2; room: Sheet117
C7579-C7582 = CSC0402: part number: CSC0402-0.1UF_16V_2,6010A0036403,CSC_100X050X040_2,0.55MM,CSC0402,0402,X7R,CAP-CHIP,0.1UF,16V,K,X7R,0402,TAP; signal model: C2_6010A0036403_0_1uF_16V_2; room: Sheet96
C7600-C7602 = CSC0402: part number: CSC0402-100PF_50V_2,6010071012AT,CSC_100X050X040_2,0.55MM,CSC0402,0402,NPO,CAP-CHIP-101-J,50V-NPO-0402; signal model: C2_6010071012AT_100pF_50V_2; room: Sheet9
C7689 = CSC0402: part number: CSC0402-0.1UF_25V_2_DY,6010B0087101_DY,CSC_100X050X040_2,0.55MM,CSC0402,0402,X5R,CAP-CHIP,0.1UF,25V,K,X5R,0402,TR; signal model: C2_6010B0087101_0_1uF_25V_2_DY; room: Sheet9
C7699 = CSC0402: part number: CSC0402-0.1UF_25V_2,6010B0087101,CSC_100X050X040_2,0.55MM,CSC0402,0402,X5R,CAP-CHIP,0.1UF,25V,K,X5R,0402,TR; signal model: C2_6010B0087101_0_1uF_25V_2; room: Sheet9
C50020 = CSC0402: part number: CSC0402-0.1UF_16V_2,6010A0036403,CSC_100X050X040_2,0.55MM,CSC0402,0402,X7R,CAP-CHIP,0.1UF,16V,K,X7R,0402,TAP; signal model: C2_6010A0036403_0_1uF_16V_2; room: Sheet74
C50030-C50037 C50050-C50057 C50070-C50074 C50080-C50084 C50090 C50091 = CSC0201: part number: CSC0201-1UF_6.3V_1,6010B0602301,CSC_060X030X039_2,0.49MM,CSC0201,CAPACITOR-CHIP,1UF,6.3V,M,X6S,0201,TR,0.3MM; signal model: C2_6010B0602301_1uF_6_3V_1; room: Sheet74
C50038 C50039 C50058 C50075 C50076 C50085 C50092 = CSC0402: part number: CSC0402-4.7UF_6.3V_2,6010B0608701,CSC_100X050X065_2,0.75MM,CSC0402,0402,X6S,CAPACITOR-CHIP,4.7UF,6.3V,M,X6S,0402,TR,0.5MM; signal model: C2_6010B0608701_4_7uF_6_3V_2; room: Sheet74
C50040 C50041 C50059 C50077 C50078 C50086 = CSC0805: part number: CSC0805-10UF_10V_5,6010B0598301,CSC_200X125X140_2,1.5MM,CSC0805,0805,X7R,CAPACITOR-CHIP,10UF,10V,K,X7R,0805,TR; signal model: C2_6010B0598301_10uF_10V_5; room: Sheet74
C50042 C50060 C50079 C50087 = CSC0603: part number: CSC0603-22UF_4V_3,6010B0609001,CSC_160X080X100_2,1.1MM,CSC0603,0603,,CAPACITOR-CHIP,22UF,4V,M,X6S,0603,TR,0.8MM; signal model: C2_6010B0609001_22uF_4V_3; room: Sheet74
C50100 C50110 C50111 = CSC0201: part number: CSC0201-1UF_6.3V_1,6010B0602301,CSC_060X030X039_2,0.49MM,CSC0201,CAPACITOR-CHIP,1UF,6.3V,M,X6S,0201,TR,0.3MM; signal model: C2_6010B0602301_1uF_6_3V_1; room: Sheet75
C50101 C50102 = CSC0402: part number: CSC0402-4.7UF_6.3V_2,6010B0608701,CSC_100X050X065_2,0.75MM,CSC0402,0402,X6S,CAPACITOR-CHIP,4.7UF,6.3V,M,X6S,0402,TR,0.5MM; signal model: C2_6010B0608701_4_7uF_6_3V_2; room: Sheet75
C50103 = CSC0603: part number: CSC0603-22UF_4V_3,6010B0609001,CSC_160X080X100_2,1.1MM,CSC0603,0603,,CAPACITOR-CHIP,22UF,4V,M,X6S,0603,TR,0.8MM; signal model: C2_6010B0609001_22uF_4V_3; room: Sheet75
C50200 = CSC0201: part number: CSC0201-1UF_6.3V_1,6010B0602301,CSC_060X030X039_2,0.49MM,CSC0201,CAPACITOR-CHIP,1UF,6.3V,M,X6S,0201,TR,0.3MM; signal model: C2_6010B0602301_1uF_6_3V_1; room: Sheet76
C50300 = CSC0201: part number: CSC0201-1UF_6.3V_1,6010B0602301,CSC_060X030X039_2,0.49MM,CSC0201,CAPACITOR-CHIP,1UF,6.3V,M,X6S,0201,TR,0.3MM; signal model: C2_6010B0602301_1uF_6_3V_1; room: Sheet77
C50400 = CSC0201: part number: CSC0201-1UF_6.3V_1,6010B0602301,CSC_060X030X039_2,0.49MM,CSC0201,CAPACITOR-CHIP,1UF,6.3V,M,X6S,0201,TR,0.3MM; signal model: C2_6010B0602301_1uF_6_3V_1; room: Sheet78
C50510-C50515 = CSC0603: part number: CSC0603-10UF_4V_3,6010B0608901,CSC_160X080X090_2,1MM,CSC0603,0603,,CAPACITOR-CHIP,10UF,4V,M,X6S,0603,TR,0.8MM; signal model: C2_6010B0608901_10uF_4V_3; room: Sheet79
C50516-C50521 = CSC0603: part number: CSC0603-22UF_4V_3,6010B0609001,CSC_160X080X100_2,1.1MM,CSC0603,0603,,CAPACITOR-CHIP,22UF,4V,M,X6S,0603,TR,0.8MM; signal model: C2_6010B0609001_22uF_4V_3; room: Sheet79
C50522-C50545 C50547-C50562 = CSC0201: part number: CSC0201-1UF_6.3V_1,6010B0602301,CSC_060X030X039_2,0.49MM,CSC0201,CAPACITOR-CHIP,1UF,6.3V,M,X6S,0201,TR,0.3MM; signal model: C2_6010B0602301_1uF_6_3V_1; room: Sheet79
C50546 = CSC0402: part number: CSC0402-4.7UF_6.3V_2,6010B0608701,CSC_100X050X065_2,0.75MM,CSC0402,0402,X6S,CAPACITOR-CHIP,4.7UF,6.3V,M,X6S,0402,TR,0.5MM; signal model: C2_6010B0608701_4_7uF_6_3V_2; room: Sheet79
C50610-C50615 = CSC0603: part number: CSC0603-10UF_4V_3,6010B0608901,CSC_160X080X090_2,1MM,CSC0603,0603,,CAPACITOR-CHIP,10UF,4V,M,X6S,0603,TR,0.8MM; signal model: C2_6010B0608901_10uF_4V_3; room: Sheet80
C50616-C50621 = CSC0603: part number: CSC0603-22UF_4V_3,6010B0609001,CSC_160X080X100_2,1.1MM,CSC0603,0603,,CAPACITOR-CHIP,22UF,4V,M,X6S,0603,TR,0.8MM; signal model: C2_6010B0609001_22uF_4V_3; room: Sheet80
C50622-C50645 C50647-C50662 = CSC0201: part number: CSC0201-1UF_6.3V_1,6010B0602301,CSC_060X030X039_2,0.49MM,CSC0201,CAPACITOR-CHIP,1UF,6.3V,M,X6S,0201,TR,0.3MM; signal model: C2_6010B0602301_1uF_6_3V_1; room: Sheet80
C50646 = CSC0402: part number: CSC0402-4.7UF_6.3V_2,6010B0608701,CSC_100X050X065_2,0.75MM,CSC0402,0402,X6S,CAPACITOR-CHIP,4.7UF,6.3V,M,X6S,0402,TR,0.5MM; signal model: C2_6010B0608701_4_7uF_6_3V_2; room: Sheet80
C50710-C50715 = CSC0603: part number: CSC0603-10UF_4V_3,6010B0608901,CSC_160X080X090_2,1MM,CSC0603,0603,,CAPACITOR-CHIP,10UF,4V,M,X6S,0603,TR,0.8MM; signal model: C2_6010B0608901_10uF_4V_3; room: Sheet81
C50716-C50721 = CSC0603: part number: CSC0603-22UF_4V_3,6010B0609001,CSC_160X080X100_2,1.1MM,CSC0603,0603,,CAPACITOR-CHIP,22UF,4V,M,X6S,0603,TR,0.8MM; signal model: C2_6010B0609001_22uF_4V_3; room: Sheet81
C50722-C50745 C50747-C50762 = CSC0201: part number: CSC0201-1UF_6.3V_1,6010B0602301,CSC_060X030X039_2,0.49MM,CSC0201,CAPACITOR-CHIP,1UF,6.3V,M,X6S,0201,TR,0.3MM; signal model: C2_6010B0602301_1uF_6_3V_1; room: Sheet81
C50746 = CSC0402: part number: CSC0402-4.7UF_6.3V_2,6010B0608701,CSC_100X050X065_2,0.75MM,CSC0402,0402,X6S,CAPACITOR-CHIP,4.7UF,6.3V,M,X6S,0402,TR,0.5MM; signal model: C2_6010B0608701_4_7uF_6_3V_2; room: Sheet81
C50810-C50815 = CSC0603: part number: CSC0603-10UF_4V_3,6010B0608901,CSC_160X080X090_2,1MM,CSC0603,0603,,CAPACITOR-CHIP,10UF,4V,M,X6S,0603,TR,0.8MM; signal model: C2_6010B0608901_10uF_4V_3; room: Sheet82
C50816-C50821 = CSC0603: part number: CSC0603-22UF_4V_3,6010B0609001,CSC_160X080X100_2,1.1MM,CSC0603,0603,,CAPACITOR-CHIP,22UF,4V,M,X6S,0603,TR,0.8MM; signal model: C2_6010B0609001_22uF_4V_3; room: Sheet82
C50822-C50845 C50847-C50862 = CSC0201: part number: CSC0201-1UF_6.3V_1,6010B0602301,CSC_060X030X039_2,0.49MM,CSC0201,CAPACITOR-CHIP,1UF,6.3V,M,X6S,0201,TR,0.3MM; signal model: C2_6010B0602301_1uF_6_3V_1; room: Sheet82
C50846 = CSC0402: part number: CSC0402-4.7UF_6.3V_2,6010B0608701,CSC_100X050X065_2,0.75MM,CSC0402,0402,X6S,CAPACITOR-CHIP,4.7UF,6.3V,M,X6S,0402,TR,0.5MM; signal model: C2_6010B0608701_4_7uF_6_3V_2; room: Sheet82
C50910-C50915 = CSC0603: part number: CSC0603-10UF_4V_3,6010B0608901,CSC_160X080X090_2,1MM,CSC0603,0603,,CAPACITOR-CHIP,10UF,4V,M,X6S,0603,TR,0.8MM; signal model: C2_6010B0608901_10uF_4V_3; room: Sheet83
C50916-C50921 = CSC0603: part number: CSC0603-22UF_4V_3,6010B0609001,CSC_160X080X100_2,1.1MM,CSC0603,0603,,CAPACITOR-CHIP,22UF,4V,M,X6S,0603,TR,0.8MM; signal model: C2_6010B0609001_22uF_4V_3; room: Sheet83
C50922-C50945 C50947-C50962 = CSC0201: part number: CSC0201-1UF_6.3V_1,6010B0602301,CSC_060X030X039_2,0.49MM,CSC0201,CAPACITOR-CHIP,1UF,6.3V,M,X6S,0201,TR,0.3MM; signal model: C2_6010B0602301_1uF_6_3V_1; room: Sheet83
C50946 = CSC0402: part number: CSC0402-4.7UF_6.3V_2,6010B0608701,CSC_100X050X065_2,0.75MM,CSC0402,0402,X6S,CAPACITOR-CHIP,4.7UF,6.3V,M,X6S,0402,TR,0.5MM; signal model: C2_6010B0608701_4_7uF_6_3V_2; room: Sheet83
C51000 C51600 C51610 = CSC0402: part number: CSC0402-4.7UF_6.3V_2,6010B0608701,CSC_100X050X065_2,0.75MM,CSC0402,0402,X6S,CAPACITOR-CHIP,4.7UF,6.3V,M,X6S,0402,TR,0.5MM; signal model: C2_6010B0608701_4_7uF_6_3V_2; room: Sheet91
C51010-C51015 = CSC0603: part number: CSC0603-10UF_4V_3,6010B0608901,CSC_160X080X090_2,1MM,CSC0603,0603,,CAPACITOR-CHIP,10UF,4V,M,X6S,0603,TR,0.8MM; signal model: C2_6010B0608901_10uF_4V_3; room: Sheet84
C51016-C51021 = CSC0603: part number: CSC0603-22UF_4V_3,6010B0609001,CSC_160X080X100_2,1.1MM,CSC0603,0603,,CAPACITOR-CHIP,22UF,4V,M,X6S,0603,TR,0.8MM; signal model: C2_6010B0609001_22uF_4V_3; room: Sheet84
C51022-C51045 C51047-C51062 = CSC0201: part number: CSC0201-1UF_6.3V_1,6010B0602301,CSC_060X030X039_2,0.49MM,CSC0201,CAPACITOR-CHIP,1UF,6.3V,M,X6S,0201,TR,0.3MM; signal model: C2_6010B0602301_1uF_6_3V_1; room: Sheet84
C51046 = CSC0402: part number: CSC0402-4.7UF_6.3V_2,6010B0608701,CSC_100X050X065_2,0.75MM,CSC0402,0402,X6S,CAPACITOR-CHIP,4.7UF,6.3V,M,X6S,0402,TR,0.5MM; signal model: C2_6010B0608701_4_7uF_6_3V_2; room: Sheet84
C51110-C51115 = CSC0603: part number: CSC0603-10UF_4V_3,6010B0608901,CSC_160X080X090_2,1MM,CSC0603,0603,,CAPACITOR-CHIP,10UF,4V,M,X6S,0603,TR,0.8MM; signal model: C2_6010B0608901_10uF_4V_3; room: Sheet85
C51116-C51121 = CSC0603: part number: CSC0603-22UF_4V_3,6010B0609001,CSC_160X080X100_2,1.1MM,CSC0603,0603,,CAPACITOR-CHIP,22UF,4V,M,X6S,0603,TR,0.8MM; signal model: C2_6010B0609001_22uF_4V_3; room: Sheet85
C51122-C51145 C51147-C51162 = CSC0201: part number: CSC0201-1UF_6.3V_1,6010B0602301,CSC_060X030X039_2,0.49MM,CSC0201,CAPACITOR-CHIP,1UF,6.3V,M,X6S,0201,TR,0.3MM; signal model: C2_6010B0602301_1uF_6_3V_1; room: Sheet85
C51146 = CSC0402: part number: CSC0402-4.7UF_6.3V_2,6010B0608701,CSC_100X050X065_2,0.75MM,CSC0402,0402,X6S,CAPACITOR-CHIP,4.7UF,6.3V,M,X6S,0402,TR,0.5MM; signal model: C2_6010B0608701_4_7uF_6_3V_2; room: Sheet85
C51210-C51215 = CSC0603: part number: CSC0603-10UF_4V_3,6010B0608901,CSC_160X080X090_2,1MM,CSC0603,0603,,CAPACITOR-CHIP,10UF,4V,M,X6S,0603,TR,0.8MM; signal model: C2_6010B0608901_10uF_4V_3; room: Sheet86
C51216-C51221 = CSC0603: part number: CSC0603-22UF_4V_3,6010B0609001,CSC_160X080X100_2,1.1MM,CSC0603,0603,,CAPACITOR-CHIP,22UF,4V,M,X6S,0603,TR,0.8MM; signal model: C2_6010B0609001_22uF_4V_3; room: Sheet86
C51222-C51245 C51247-C51262 = CSC0201: part number: CSC0201-1UF_6.3V_1,6010B0602301,CSC_060X030X039_2,0.49MM,CSC0201,CAPACITOR-CHIP,1UF,6.3V,M,X6S,0201,TR,0.3MM; signal model: C2_6010B0602301_1uF_6_3V_1; room: Sheet86
C51246 = CSC0402: part number: CSC0402-4.7UF_6.3V_2,6010B0608701,CSC_100X050X065_2,0.75MM,CSC0402,0402,X6S,CAPACITOR-CHIP,4.7UF,6.3V,M,X6S,0402,TR,0.5MM; signal model: C2_6010B0608701_4_7uF_6_3V_2; room: Sheet86
C51300 = CSC0603: part number: CSC0603-22UF_4V_3,6010B0609001,CSC_160X080X100_2,1.1MM,CSC0603,0603,,CAPACITOR-CHIP,22UF,4V,M,X6S,0603,TR,0.8MM; signal model: C2_6010B0609001_22uF_4V_3; room: Sheet87
C51301 = CSC0402: part number: CSC0402-4.7UF_6.3V_2,6010B0608701,CSC_100X050X065_2,0.75MM,CSC0402,0402,X6S,CAPACITOR-CHIP,4.7UF,6.3V,M,X6S,0402,TR,0.5MM; signal model: C2_6010B0608701_4_7uF_6_3V_2; room: Sheet87
C51302-C51306 = CSC0201: part number: CSC0201-1UF_6.3V_1,6010B0602301,CSC_060X030X039_2,0.49MM,CSC0201,CAPACITOR-CHIP,1UF,6.3V,M,X6S,0201,TR,0.3MM; signal model: C2_6010B0602301_1uF_6_3V_1; room: Sheet87
C51310 C51311 = CSC0402: part number: CSC0402-10PF_50V_2,6010A0025401,CSC_100X050X040_2,0.55MM,CSC0402,0402,NPO,CAP-CHIP-10PF-D,50V-NPO-0402-TAP; signal model: C2_6010A0025401_10pF_50V_2; room: Sheet87
C51400 = CSC0402: part number: CSC0402-0.1UF_16V_2,6010A0036403,CSC_100X050X040_2,0.55MM,CSC0402,0402,X7R,CAP-CHIP,0.1UF,16V,K,X7R,0402,TAP; signal model: C2_6010A0036403_0_1uF_16V_2; room: Sheet88
C51601 C51602 C51611 C51612 C51616 = CSC0201: part number: CSC0201-1UF_6.3V_1,6010B0602301,CSC_060X030X039_2,0.49MM,CSC0201,CAPACITOR-CHIP,1UF,6.3V,M,X6S,0201,TR,0.3MM; signal model: C2_6010B0602301_1uF_6_3V_1; room: Sheet91
C51620-C51627 C51630 C51631 C51671 C51681 = CSC0402: part number: CSC0402-0.1UF_16V_2,6010A0036403,CSC_100X050X040_2,0.55MM,CSC0402,0402,X7R,CAP-CHIP,0.1UF,16V,K,X7R,0402,TAP; signal model: C2_6010A0036403_0_1uF_16V_2; room: Sheet91
C51700-C51707 = CSC0402: part number: CSC0402-0.1UF_16V_2,6010A0036403,CSC_100X050X040_2,0.55MM,CSC0402,0402,X7R,CAP-CHIP,0.1UF,16V,K,X7R,0402,TAP; signal model: C2_6010A0036403_0_1uF_16V_2; room: Sheet94
C51720 C51731-C51733 C51752 = CSC0201: part number: CSC0201-1UF_6.3V_1,6010B0602301,CSC_060X030X039_2,0.49MM,CSC0201,CAPACITOR-CHIP,1UF,6.3V,M,X6S,0201,TR,0.3MM; signal model: C2_6010B0602301_1uF_6_3V_1; room: Sheet94
C51730 = CSC0402: part number: CSC0402-4.7UF_6.3V_2,6010B0608701,CSC_100X050X065_2,0.75MM,CSC0402,0402,X6S,CAPACITOR-CHIP,4.7UF,6.3V,M,X6S,0402,TR,0.5MM; signal model: C2_6010B0608701_4_7uF_6_3V_2; room: Sheet94
C51800 = CSC0402: part number: CSC0402-4.7UF_6.3V_2,6010B0608701,CSC_100X050X065_2,0.75MM,CSC0402,0402,X6S,CAPACITOR-CHIP,4.7UF,6.3V,M,X6S,0402,TR,0.5MM; signal model: C2_6010B0608701_4_7uF_6_3V_2; room: Sheet90
C51801-C51804 = CSC0201: part number: CSC0201-1UF_6.3V_1,6010B0602301,CSC_060X030X039_2,0.49MM,CSC0201,CAPACITOR-CHIP,1UF,6.3V,M,X6S,0201,TR,0.3MM; signal model: C2_6010B0602301_1uF_6_3V_1; room: Sheet90
C51900 C51901 = CSC0201: part number: CSC0201-1UF_6.3V_1,6010B0602301,CSC_060X030X039_2,0.49MM,CSC0201,CAPACITOR-CHIP,1UF,6.3V,M,X6S,0201,TR,0.3MM; signal model: C2_6010B0602301_1uF_6_3V_1; room: Sheet97
C52000 = CSC0201: part number: CSC0201-1UF_6.3V_1,6010B0602301,CSC_060X030X039_2,0.49MM,CSC0201,CAPACITOR-CHIP,1UF,6.3V,M,X6S,0201,TR,0.3MM; signal model: C2_6010B0602301_1uF_6_3V_1; room: Sheet98
C52001 C52310-C52312 = CSC0402: part number: CSC0402-4.7UF_6.3V_2,6010B0608701,CSC_100X050X065_2,0.75MM,CSC0402,0402,X6S,CAPACITOR-CHIP,4.7UF,6.3V,M,X6S,0402,TR,0.5MM; signal model: C2_6010B0608701_4_7uF_6_3V_2; room: Sheet101
C52002-C52005 = CSC0402: part number: CSC0402-4.7UF_6.3V_2,6010B0608701,CSC_100X050X065_2,0.75MM,CSC0402,0402,X6S,CAPACITOR-CHIP,4.7UF,6.3V,M,X6S,0402,TR,0.5MM; signal model: C2_6010B0608701_4_7uF_6_3V_2; room: Sheet102
C52008 C52009 = CSC0402: part number: CSC0402-CSC0402_DY,CSC0402_DY,CSC_100X050X040_2,0.55MM,CSC0402,0402,,CSC0402_OPEN; signal model: C2_CSC0402_DY_CSC0402_DY; room: Sheet98
C52010 C52020 = CSC0402: part number: CSC0402-0.015UF_50V_2,6010B0437601,CSC_100X050X055_2,0.65MM,CSC0402,0402,X7R,CAPACITOR-CHIP,0.015UF,50V,K,X7R,0402,TR; signal model: C2_6010B0437601_0_015uF_50V_2; room: Sheet98
C52014 C52024 = CSC0402: part number: CSC0402-1000PF_50V_2,6010071020AT,CSC_100X050X055_2,0.7MM,CSC0402,0402,X7R,CAPACITOR-CHIP,1000PF,50V,K,X7R,0402,TR; signal model: C2_6010071020AT_1000PF_50V_2; room: Sheet98
C52050 C52053 C52055 = CSC0402: part number: CSC0402-100PF_50V_2,6010071012AT,CSC_100X050X040_2,0.55MM,CSC0402,0402,NPO,CAP-CHIP-101-J,50V-NPO-0402; signal model: C2_6010071012AT_100pF_50V_2; room: Sheet98
C52100 C52102 = CSC0201: part number: CSC0201-1UF_6.3V_1,6010B0602301,CSC_060X030X039_2,0.49MM,CSC0201,CAPACITOR-CHIP,1UF,6.3V,M,X6S,0201,TR,0.3MM; signal model: C2_6010B0602301_1uF_6_3V_1; room: Sheet99
C52101 = CSC0402: part number: CSC0402-4.7UF_6.3V_2,6010B0608701,CSC_100X050X065_2,0.75MM,CSC0402,0402,X6S,CAPACITOR-CHIP,4.7UF,6.3V,M,X6S,0402,TR,0.5MM; signal model: C2_6010B0608701_4_7uF_6_3V_2; room: Sheet99
C52200 = CSC0402: part number: CSC0402-3.9PF_50V_2,6010B0055301,CSC_100X050X050_2,0.65MM,CSC0402,0402,C0G,CAPACITOR-CHIP,3.9PF,50V,C,C0G,0402,TR; signal model: C2_6010B0055301_3_9pF_50V_2; room: Sheet100
C52300-C52302 C52320-C52322 = CSC0201: part number: CSC0201-1UF_6.3V_1,6010B0602301,CSC_060X030X039_2,0.49MM,CSC0201,CAPACITOR-CHIP,1UF,6.3V,M,X6S,0201,TR,0.3MM; signal model: C2_6010B0602301_1uF_6_3V_1; room: Sheet101
C52400-C52584 = CSC0201: part number: CSC0201-1UF_6.3V_1,6010B0602301,CSC_060X030X039_2,0.49MM,CSC0201,CAPACITOR-CHIP,1UF,6.3V,M,X6S,0201,TR,0.3MM; signal model: C2_6010B0602301_1uF_6_3V_1; room: Sheet102
C52600-C52622 = CSC0603: part number: CSC0603-10UF_4V_3,6010B0608901,CSC_160X080X090_2,1MM,CSC0603,0603,,CAPACITOR-CHIP,10UF,4V,M,X6S,0603,TR,0.8MM; signal model: C2_6010B0608901_10uF_4V_3; room: Sheet102
C52630-C52633 = CSC0603: part number: CSC0603-22UF_4V_3,6010B0609001,CSC_160X080X100_2,1.1MM,CSC0603,0603,,CAPACITOR-CHIP,22UF,4V,M,X6S,0603,TR,0.8MM; signal model: C2_6010B0609001_22uF_4V_3; room: Sheet102
C52640-C52642 = CSC0805: part number: CSC0805-47UF_4V_5,6010B0608801,CSC_200X125X145_2,1.55MM,CSC0805,0805,X6S,CAPACITOR-CHIP,47UF,4V,M,X6S,0805,TR,1.25MM; signal model: C2_6010B0608801_47uF_4V_5; room: Sheet102
C52650 C52651 = CAP_AL_SP: part number: CAP_AL_SP-470UF_2V,6010B0107301,CS_730X430X190_2,2.05MM,CAP_AL_SP,,,CAPACITOR-AL-SP,470UF,2V,M,105C,DX1.9,SMD,TR,4.5MOHM; signal model: C2_6010B0107301_470uF_2V; room: Sheet102
C53000-C53047 = CSC0201: part number: CSC0201-1UF_6.3V_1,6010B0602301,CSC_060X030X039_2,0.49MM,CSC0201,CAPACITOR-CHIP,1UF,6.3V,M,X6S,0201,TR,0.3MM; signal model: C2_6010B0602301_1uF_6_3V_1; room: Sheet103
C53050-C53057 C53060-C53063 = CSC0603: part number: CSC0603-10UF_4V_3,6010B0608901,CSC_160X080X090_2,1MM,CSC0603,0603,,CAPACITOR-CHIP,10UF,4V,M,X6S,0603,TR,0.8MM; signal model: C2_6010B0608901_10uF_4V_3; room: Sheet103
C53070-C53078 = CSC0603: part number: CSC0603-22UF_4V_3,6010B0609001,CSC_160X080X100_2,1.1MM,CSC0603,0603,,CAPACITOR-CHIP,22UF,4V,M,X6S,0603,TR,0.8MM; signal model: C2_6010B0609001_22uF_4V_3; room: Sheet103
C53500 C53520 C53540 C53550 C53570 C53580 C53590 = CSC0402: part number: CSC0402-0.1UF_16V_2,6010A0036403,CSC_100X050X040_2,0.55MM,CSC0402,0402,X7R,CAP-CHIP,0.1UF,16V,K,X7R,0402,TAP; signal model: C2_6010A0036403_0_1uF_16V_2; room: Sheet105
C53501 = CSC0603: part number: CSC0603-0.1UF_25V_3_DY,6010A0057701_DY,CSC_160X080X080_2,0.95MM,CSC0603,0603,X7R,CAP-CHIP,0.1UF,25V,K,X7R,0603,TR; signal model: C2_6010A0057701_0_1uF_25V_3_DY; room: Sheet105
C53510 C53582 = CSC0603: part number: CSC0603-CSC0603_DY,CSC0603_DY,CSC_160X080X080_2,0.95MM,CSC0603,0603,,CSC0603_OPEN; signal model: C2_CSC0603_DY_CSC0603_DY; room: Sheet105
C53530 C53552 C53572 C53592 = CSC0603: part number: CSC0603-0.1UF_25V_3,6010A0057701,CSC_160X080X080_2,0.95MM,CSC0603,0603,X7R,CAP-CHIP,0.1UF,25V,K,X7R,0603,TR; signal model: C2_6010A0057701_0_1uF_25V_3; room: Sheet105
C55300 C55301 = CSC0201: part number: CSC0201-1UF_6.3V_1,6010B0602301,CSC_060X030X039_2,0.49MM,CSC0201,CAPACITOR-CHIP,1UF,6.3V,M,X6S,0201,TR,0.3MM; signal model: C2_6010B0602301_1uF_6_3V_1; room: Sheet107
C55302 = CSC0402: part number: CSC0402-220PF_50V_2,6010B0076701,CSC_100X050X040_2,0.55MM,CSC0402,0402,C0G,CAP-CHIP,220PF,50V,J,C0G,0402,TR; signal model: C2_6010B0076701_220pF_50V_2; room: Sheet107
C55303 C55304 = CSC0805: part number: CSC0805-10UF_10V_5,6010B0598301,CSC_200X125X140_2,1.5MM,CSC0805,0805,X7R,CAPACITOR-CHIP,10UF,10V,K,X7R,0805,TR; signal model: C2_6010B0598301_10uF_10V_5; room: Sheet107
C55700-C55731 = CSC0201: part number: CSC0201-0.22UF_6.3V_1,6010B0617601,CSC_060X030X033_2,0.43MM,CSC0201,CAPACITOR-CHIP,0.22UF,6.3V,M,X6S,0201,TR,0.3MM; signal model: C2_6010B0617601_0_22uF_6_3V_1; room: Sheet74
C55800-C55807 C55821-C55827 = CSC0402: part number: CSC0402-0.1UF_16V_2,6010A0036403,CSC_100X050X040_2,0.55MM,CSC0402,0402,X7R,CAP-CHIP,0.1UF,16V,K,X7R,0402,TAP; signal model: C2_6010A0036403_0_1uF_16V_2; room: Sheet92
C55820 = CSC0402: part number: CSC0402-4.7UF_6.3V_2,6010B0608701,CSC_100X050X065_2,0.75MM,CSC0402,0402,X6S,CAPACITOR-CHIP,4.7UF,6.3V,M,X6S,0402,TR,0.5MM; signal model: C2_6010B0608701_4_7uF_6_3V_2; room: Sheet92
C56200 C56252 = CSC0402: part number: CSC0402-0.1UF_16V_2,6010A0036403,CSC_100X050X040_2,0.55MM,CSC0402,0402,X7R,CAP-CHIP,0.1UF,16V,K,X7R,0402,TAP; signal model: C2_6010A0036403_0_1uF_16V_2; room: Sheet93
C56201 C56251 = CSC0402: part number: CSC0402-0.01UF_50V_2,6010B0058401,CSC_100X050X040_2,0.55MM,CSC0402,0402,X7R,CAP-CHIP,0.01UF,50V,K,X7R,0402,TAP; signal model: C2_6010B0058401_0_01uF_50V_2; room: Sheet93
C56202 = CSC0402: part number: CSC0402-4.7UF_6.3V_2,6010B0608701,CSC_100X050X065_2,0.75MM,CSC0402,0402,X6S,CAPACITOR-CHIP,4.7UF,6.3V,M,X6S,0402,TR,0.5MM; signal model: C2_6010B0608701_4_7uF_6_3V_2; room: Sheet93
C56250 = CSC0201: part number: CSC0201-1UF_6.3V_1,6010B0602301,CSC_060X030X039_2,0.49MM,CSC0201,CAPACITOR-CHIP,1UF,6.3V,M,X6S,0201,TR,0.3MM; signal model: C2_6010B0602301_1uF_6_3V_1; room: Sheet93
C56261 = CSC0402: part number: CSC0402-220PF_50V_2,6010B0076701,CSC_100X050X040_2,0.55MM,CSC0402,0402,C0G,CAP-CHIP,220PF,50V,J,C0G,0402,TR; signal model: C2_6010B0076701_220pF_50V_2; room: Sheet93
C56400 C56402 C56406 C56407 C56409 C56420-C56422 C56442 C56443 C564001 = CSC0402: part number: CSC0402-0.1UF_16V_2,6010A0036403,CSC_100X050X040_2,0.55MM,CSC0402,0402,X7R,CAP-CHIP,0.1UF,16V,K,X7R,0402,TAP; signal model: C2_6010A0036403_0_1uF_16V_2; room: Sheet95
C56404 C56452 = CSC0603: part number: CSC0603-10UF_6.3V_3,6010B0044902,CSC_160X080X095_2,1.05MM,CSC0603,0603,,CAPACITOR-CHIP,10UF,6.3V,M,X5R,0603,TR; signal model: C2_6010B0044902_10uF_6_3V_3; room: Sheet95
C56405 C56408 C56441 = CSC0402: part number: CSC0402-4.7UF_6.3V_2,6010B0608701,CSC_100X050X065_2,0.75MM,CSC0402,0402,X6S,CAPACITOR-CHIP,4.7UF,6.3V,M,X6S,0402,TR,0.5MM; signal model: C2_6010B0608701_4_7uF_6_3V_2; room: Sheet95
C56610 = CSC0402: part number: CSC0402-100PF_50V_2,6010071012AT,CSC_100X050X040_2,0.55MM,CSC0402,0402,NPO,CAP-CHIP-101-J,50V-NPO-0402; signal model: C2_6010071012AT_100pF_50V_2; room: Sheet96
C56631 = CSC0402: part number: CSC0402-220PF_50V_2_DY,6010B0076701_DY,CSC_100X050X040_2,0.55MM,CSC0402,0402,C0G,CAP-CHIP,220PF,50V,J,C0G,0402,TR; signal model: C2_6010B0076701_220pF_50V_2_DY; room: Sheet96
C60000 C60001 C60010 C60011 C60025 = CSC0805: part number: CSC0805-10UF_25V_5,6010B0150801,CSC_200X125X140_2,1.55MM,CSC0805,0805,X5R,CAP-CHIP,10UF,25V,K,X5R,0805,TR,1.25MM; signal model: C2_6010B0150801_10UF_25V_5; room: Sheet8
C60002 = CSC0402: part number: CSC0402-470PF_50V_2,6010A0025101,CSC_100X050X040_2,0.55MM,CSC0402,0402,X7R,CAP-CHIP-471-K,50V-X7R-0402-TAP; signal model: C2_6010A0025101_470pF_50V_2; room: Sheet8
C60003 C60014 C60017 C60020 C60022 = CSC0603: part number: CSC0603-0.1UF_25V_3,6010A0057701,CSC_160X080X080_2,0.95MM,CSC0603,0603,X7R,CAP-CHIP,0.1UF,25V,K,X7R,0603,TR; signal model: C2_6010A0057701_0_1uF_25V_3; room: Sheet8
C60005 C60007 C60008 = CSC0402: part number: CSC0402-100PF_50V_2,6010071012AT,CSC_100X050X040_2,0.55MM,CSC0402,0402,NPO,CAP-CHIP-101-J,50V-NPO-0402; signal model: C2_6010071012AT_100pF_50V_2; room: Sheet8
C60009 = CSC0603: part number: CSC0603-1UF_25V_3,6010B0067602,CSC_160X080X080_2,0.90MM,CSC0603,0603,,CAPACITOR-CHIP,1UF,25V,K,X5R,0603,TR; signal model: C2_6010B0067602_1uF_25V_3; room: Sheet8
C60012 = CSC0402: part number: CSC0402-0.01UF_50V_2,6010B0058401,CSC_100X050X040_2,0.55MM,CSC0402,0402,X7R,CAP-CHIP,0.01UF,50V,K,X7R,0402,TAP; signal model: C2_6010B0058401_0_01uF_50V_2; room: Sheet8
C60013 = CSC0603: part number: CSC0603-0.1UF_25V_3,6010A0057701,CSC_160X080X080_2,0.95MM,CSC0603,0603,X7R,CAP-CHIP,0.1UF,25V,K,X7R,0603,TR; signal model: C2_6010A0057701_0_1uF_25V_3; room: Sheet9
C60015 = CSC0402: part number: CSC0402-0.047UF_16V_2,6010B0046101,CSC_100X050X040_2,0.55MM,CSC0402,0402,X7R,CAP-CHIP,0.047UF,16V,K,X7R,0402,TAP; signal model: C2_6010B0046101_0_047uF_16V_2; room: Sheet8
C60016 = CSC0402: part number: CSC0402-2200PF_50V_2,6010A0010701,CSC_100X050X040_2,0.55MM,CSC0402,0402,X7R,CAP-CHIP-222-J,50V-X7R-0402-TAP; signal model: C2_6010A0010701_2200pF_50V_2; room: Sheet8
C60018 C60021 C60024 = CSC0402: part number: CSC0402-0.1UF_16V_2,6010A0036403,CSC_100X050X040_2,0.55MM,CSC0402,0402,X7R,CAP-CHIP,0.1UF,16V,K,X7R,0402,TAP; signal model: C2_6010A0036403_0_1uF_16V_2; room: Sheet8
C60019 = CSC0603: part number: CSC0603-CSC0603,CSC0603,CSC_160X080X080_2,0.95MM,CSC0603,0603,,CSC0603; signal model: C2_CSC0603_CSC0603; room: Sheet8
C60023 = CSC0603: part number: CSC0603-2.2UF_10V_3,6010B0011501,CSC_160X080X080_2,0.95MM,CSC0603,0603,X5R,CAP-CHIP,2.2UF,10V,K,X5R,0603,TR; signal model: C2_6010B0011501_2_2uF_10V_3; room: Sheet8
C60099 = CAP_AL_SP: part number: CAP_AL_SP-15UF_25V,6010B0185101,CS_350X280X200_2,2.15MM,CAP_AL_SP,,,CAPACITOR-TA-SP,15UF,25V,M,105C,BX1.9,SM; signal model: C2_6010B0185101_15uF_25V; room: Sheet8
C60100 = CAP_TA_SP: part number: CAP_TA_SP-CSC_AX1.6,CSC_AX1.6_DY,CST_320X160X180_2_245,1.95MM,CAP_TA_SP,,,CAPACITOR-TA-SP,100UF,6.3V,M,85C,AX1.6,SMD,TR,45MOHM; signal model: C2_CSC_A_1_6_DY_CSC_A_1_6; room: Sheet12
C60101-C60104 = CSC0603: part number: CSC0603-22UF_6.3V_3,6010B0219002,CSC_160X080X100_2,1.10MM,CSC0603,0603,,CAPACITOR-CHIP,22UF,6.3V,M,X5R,0603,TR,0.8MM; signal model: C2_6010B0219002_22uF_6_3V_3; room: Sheet12
C60109 C60191 = CSC0402: part number: CSC0402-1UF_6.3V_2,6010B0392101,CSC_100X050X055_2,0.65MM,CSC0402,0402,X5R,CAPACITOR-CHIP,1UF,6.3V,K,X5R,0402,TR; signal model: C2_6010B0392101_1uF_6_3V_2; room: Sheet12
C60110 = CSC0805: part number: CSC0805-10UF_25V_5,6010B0150801,CSC_200X125X140_2,1.55MM,CSC0805,0805,X5R,CAP-CHIP,10UF,25V,K,X5R,0805,TR,1.25MM; signal model: C2_6010B0150801_10UF_25V_5; room: Sheet12
C60111 = CSC0805: part number: CSC0805-4.7UF_25V_5,6010B0048902,CSC_200X125X135_2,1.45MM,CSC0805,0805,,CAPACITOR-CHIP,4.7UF,25V,K,X5R,0805,TR; signal model: C2_6010B0048902_4_7uF_25V_5; room: Sheet12
C60112 = CSC0402: part number: CSC0402-0.1UF_25V_2,6010B0087101,CSC_100X050X040_2,0.55MM,CSC0402,0402,X5R,CAP-CHIP,0.1UF,25V,K,X5R,0402,TR; signal model: C2_6010B0087101_0_1uF_25V_2; room: Sheet12
C60113 = CAP_AL_SP: part number: CAP_AL_SP-15UF_25V,6010B0185101,CS_350X280X200_2,2.15MM,CAP_AL_SP,,,CAPACITOR-TA-SP,15UF,25V,M,105C,BX1.9,SM; signal model: C2_6010B0185101_15uF_25V; room: Sheet12
C60115 C60190 = CSC0402: part number: CSC0402-0.1UF_16V_2,6010A0036403,CSC_100X050X040_2,0.55MM,CSC0402,0402,X7R,CAP-CHIP,0.1UF,16V,K,X7R,0402,TAP; signal model: C2_6010A0036403_0_1uF_16V_2; room: Sheet12
C60166 = CSC0402: part number: CSC0402-CSC0402,CSC0402,CSC_100X050X040_2,0.55MM,CSC0402,0402,,CSC0402; signal model: C2_CSC0402_CSC0402; room: Sheet12
C60200-C60203 = CSC0805: part number: CSC0805-22UF_6.3V_5,6010A0040703,CSC_200X125X140_2,1.5MM,CSC0805,0805,X5R,CAPACITOR-CHIP,22UF,6.3V,M,X5R,0805,TR,1.25MM; signal model: C2_6010A0040703_22UF_6_3V_5; room: Sheet10
C60204 = CSC0805: part number: CSC0805-CSC0805,CSC0805,CSC_200X125X130_2,1.45MM,CSC0805,0805,,CSC0805; signal model: C2_CSC0805_CSC0805; room: Sheet10
C60209 C60230 = CSC0402: part number: CSC0402-4.7UF_6.3V_2,6010B0164602,CSC_100X050X065_2,0.75MM,CSC0402,0402,X5R,CAPACITOR-CHIP,4.7UF,6.3V,M,X5R,0402,TR,0.5MM; signal model: C2_6010B0164602_4_7UF_6_3V_2; room: Sheet10
C60210 = CSC0805: part number: CSC0805-10UF_25V_5,6010B0150801,CSC_200X125X140_2,1.55MM,CSC0805,0805,X5R,CAP-CHIP,10UF,25V,K,X5R,0805,TR,1.25MM; signal model: C2_6010B0150801_10UF_25V_5; room: Sheet10
C60211 C60214 = CSC0603: part number: CSC0603-4.7UF_25V_3,6010B0322201,CSC_160X080X095_2,1.10MM,CSC0603,0603,,CAPACITOR-CHIP,4.7UF,25V,K,X5R,0603,TR,0.8MM; signal model: C2_6010B0322201_4_7uF_25V_3; room: Sheet10
C60212 = CSC0402: part number: CSC0402-0.1UF_25V_2,6010B0087101,CSC_100X050X040_2,0.55MM,CSC0402,0402,X5R,CAP-CHIP,0.1UF,25V,K,X5R,0402,TR; signal model: C2_6010B0087101_0_1uF_25V_2; room: Sheet10
C60213 = CAP_AL_SP: part number: CAP_AL_SP-15UF_25V,6010B0185101,CS_350X280X200_2,2.15MM,CAP_AL_SP,,,CAPACITOR-TA-SP,15UF,25V,M,105C,BX1.9,SM; signal model: C2_6010B0185101_15uF_25V; room: Sheet10
C60215 = CSC0402: part number: CSC0402-0.1UF_16V_2,6010A0036403,CSC_100X050X040_2,0.55MM,CSC0402,0402,X7R,CAP-CHIP,0.1UF,16V,K,X7R,0402,TAP; signal model: C2_6010A0036403_0_1uF_16V_2; room: Sheet10
C60216 = CSC0402: part number: CSC0402-CSC0402,CSC0402,CSC_100X050X040_2,0.55MM,CSC0402,0402,,CSC0402; signal model: C2_CSC0402_CSC0402; room: Sheet10
C60231 = CSC0402: part number: CSC0402-1000PF_50V_2,6010071020AT,CSC_100X050X055_2,0.7MM,CSC0402,0402,X7R,CAPACITOR-CHIP,1000PF,50V,K,X7R,0402,TR; signal model: C2_6010071020AT_1000PF_50V_2; room: Sheet10
C60250 = CAP_AL_SP: part number: CAP_AL_SP-100UF_6.3V,6010B0228101,CS_730X430X210_2,2.25MM,CAP_AL_SP,,,CAPACITOR-AL-SP,100UF,6.3V,M,-40~+105C,DX1.9,SMD,TR,17MOHM; signal model: C2_6010B0228101_100uF_6_3V; room: Sheet11
C60251 = CSC0805: part number: CSC0805-22UF_6.3V_5,6010A0040703,CSC_200X125X140_2,1.5MM,CSC0805,0805,X5R,CAPACITOR-CHIP,22UF,6.3V,M,X5R,0805,TR,1.25MM; signal model: C2_6010A0040703_22UF_6_3V_5; room: Sheet11
C60259 = CSC0402: part number: CSC0402-1UF_6.3V_2,6010B0392101,CSC_100X050X055_2,0.65MM,CSC0402,0402,X5R,CAPACITOR-CHIP,1UF,6.3V,K,X5R,0402,TR; signal model: C2_6010B0392101_1uF_6_3V_2; room: Sheet11
C60260 C60261 = CSC0805: part number: CSC0805-4.7UF_25V_5,6010B0048902,CSC_200X125X135_2,1.45MM,CSC0805,0805,,CAPACITOR-CHIP,4.7UF,25V,K,X5R,0805,TR; signal model: C2_6010B0048902_4_7uF_25V_5; room: Sheet11
C60262 = CSC0402: part number: CSC0402-0.1UF_25V_2,6010B0087101,CSC_100X050X040_2,0.55MM,CSC0402,0402,X5R,CAP-CHIP,0.1UF,25V,K,X5R,0402,TR; signal model: C2_6010B0087101_0_1uF_25V_2; room: Sheet11
C60265 = CSC0402: part number: CSC0402-0.1UF_16V_2,6010A0036403,CSC_100X050X040_2,0.55MM,CSC0402,0402,X7R,CAP-CHIP,0.1UF,16V,K,X7R,0402,TAP; signal model: C2_6010A0036403_0_1uF_16V_2; room: Sheet11
C60266 = CSC0402: part number: CSC0402-CSC0402_DY,CSC0402_DY,CSC_100X050X040_2,0.55MM,CSC0402,0402,,CSC0402_OPEN; signal model: C2_CSC0402_DY_CSC0402_DY; room: Sheet11
C60280 = CSC0402: part number: CSC0402-1UF_10V_2,6010B0392201,CSC_100X050X055_2,0.65MM,CSC0402,0402,X5R,CAPACITOR-CHIP,1UF,10V,K,X5R,0402,TR; signal model: C2_6010B0392201_1uF_10V_2; room: Sheet11
C60281 = CSC0402: part number: CSC0402-470PF_50V_2,6010A0025101,CSC_100X050X040_2,0.55MM,CSC0402,0402,X7R,CAP-CHIP-471-K,50V-X7R-0402-TAP; signal model: C2_6010A0025101_470pF_50V_2; room: Sheet11
C60300-C60302 C60350 = CSC0603: part number: CSC0603-22UF_6.3V_3,6010B0219002,CSC_160X080X100_2,1.10MM,CSC0603,0603,,CAPACITOR-CHIP,22UF,6.3V,M,X5R,0603,TR,0.8MM; signal model: C2_6010B0219002_22uF_6_3V_3; room: Sheet13
C60303 C60304 C60352 = CSC0603: part number: CSC0603-CSC0603,CSC0603,CSC_160X080X080_2,0.95MM,CSC0603,0603,,CSC0603; signal model: C2_CSC0603_CSC0603; room: Sheet13
C60309 = CSC0402: part number: CSC0402-1UF_6.3V_2,6010B0392101,CSC_100X050X055_2,0.65MM,CSC0402,0402,X5R,CAPACITOR-CHIP,1UF,6.3V,K,X5R,0402,TR; signal model: C2_6010B0392101_1uF_6_3V_2; room: Sheet13
C60310 = CSC0805: part number: CSC0805-22UF_25V_5,6010B0345001,CSC_200X125X145_2,1.6MM,CSC0805,0805,X5R,CAPACITOR-CHIP,22UF,25V,M,X5R,0805,TR,1.25MM; signal model: C2_6010B0345001_22uF_25V_5; room: Sheet13
C60311 = CSC0805: part number: CSC0805-CSC0805,CSC0805,CSC_200X125X130_2,1.45MM,CSC0805,0805,,CSC0805; signal model: C2_CSC0805_CSC0805; room: Sheet13
C60312 = CSC0402: part number: CSC0402-0.1UF_25V_2,6010B0087101,CSC_100X050X040_2,0.55MM,CSC0402,0402,X5R,CAP-CHIP,0.1UF,25V,K,X5R,0402,TR; signal model: C2_6010B0087101_0_1uF_25V_2; room: Sheet13
C60315 = CSC0402: part number: CSC0402-0.1UF_16V_2,6010A0036403,CSC_100X050X040_2,0.55MM,CSC0402,0402,X7R,CAP-CHIP,0.1UF,16V,K,X7R,0402,TAP; signal model: C2_6010A0036403_0_1uF_16V_2; room: Sheet13
C60316 C60348 = CSC0402: part number: CSC0402-CSC0402,CSC0402,CSC_100X050X040_2,0.55MM,CSC0402,0402,,CSC0402; signal model: C2_CSC0402_CSC0402; room: Sheet13
C60351 = CSC0402: part number: CSC0402-0.22UF_6.3V_2,6010A0050701,CSC_100X050X040_2,0.55MM,CSC0402,0402,X5R,CAP-CHIP-0.22UF-M-6.3V-X5R-0402-TAP; signal model: C2_6010A0050701_0_22uF_6_3V_2; room: Sheet13
C60400 C60401 = CSC0603: part number: CSC0603-22UF_6.3V_3,6010B0219002,CSC_160X080X100_2,1.10MM,CSC0603,0603,,CAPACITOR-CHIP,22UF,6.3V,M,X5R,0603,TR,0.8MM; signal model: C2_6010B0219002_22uF_6_3V_3; room: Sheet15
C60405 = CSC0402: part number: CSC0402-22PF_50V_2,6010072202AT,CSC_100X050X040_2,0.55MM,CSC0402,0402,C0G,CAPACITOR-CHIP,22PF,50V,J,C0G,0402,TR; signal model: C2_6010072202AT_22pF_50V_2; room: Sheet15
C60410 = CSC0603: part number: CSC0603-10UF_6.3V_3,6010B0044902,CSC_160X080X095_2,1.05MM,CSC0603,0603,,CAPACITOR-CHIP,10UF,6.3V,M,X5R,0603,TR; signal model: C2_6010B0044902_10uF_6_3V_3; room: Sheet15
C60500-C60502 = CSC0603: part number: CSC0603-22UF_6.3V_3,6010B0219002,CSC_160X080X100_2,1.10MM,CSC0603,0603,,CAPACITOR-CHIP,22UF,6.3V,M,X5R,0603,TR,0.8MM; signal model: C2_6010B0219002_22uF_6_3V_3; room: Sheet17
C60509 = CSC0402: part number: CSC0402-1UF_6.3V_2,6010B0392101,CSC_100X050X055_2,0.65MM,CSC0402,0402,X5R,CAPACITOR-CHIP,1UF,6.3V,K,X5R,0402,TR; signal model: C2_6010B0392101_1uF_6_3V_2; room: Sheet17
C60510 = CSC0805: part number: CSC0805-10UF_25V_5,6010B0150801,CSC_200X125X140_2,1.55MM,CSC0805,0805,X5R,CAP-CHIP,10UF,25V,K,X5R,0805,TR,1.25MM; signal model: C2_6010B0150801_10UF_25V_5; room: Sheet17
C60511 = CSC0402: part number: CSC0402-0.1UF_25V_2,6010B0087101,CSC_100X050X040_2,0.55MM,CSC0402,0402,X5R,CAP-CHIP,0.1UF,25V,K,X5R,0402,TR; signal model: C2_6010B0087101_0_1uF_25V_2; room: Sheet17
C60515 = CSC0402: part number: CSC0402-0.1UF_16V_2,6010A0036403,CSC_100X050X040_2,0.55MM,CSC0402,0402,X7R,CAP-CHIP,0.1UF,16V,K,X7R,0402,TAP; signal model: C2_6010A0036403_0_1uF_16V_2; room: Sheet17
C60516 = CSC0402: part number: CSC0402-CSC0402,CSC0402,CSC_100X050X040_2,0.55MM,CSC0402,0402,,CSC0402; signal model: C2_CSC0402_CSC0402; room: Sheet17
C60600 = CSC0603: part number: CSC0603-10UF_6.3V_3,6010B0044902,CSC_160X080X095_2,1.05MM,CSC0603,0603,,CAPACITOR-CHIP,10UF,6.3V,M,X5R,0603,TR; signal model: C2_6010B0044902_10uF_6_3V_3; room: Sheet14
C60605 = CSC0402: part number: CSC0402-330PF_50V_2,6010A0010301,CSC_100X050X040_2,0.55MM,CSC0402,0402,X7R,CAP-CHIP-331-J,50V-X7R-0402-TAP; signal model: C2_6010A0010301_330pF_50V_2; room: Sheet14
C60610 = CSC0603: part number: CSC0603-4.7UF_6.3V_3,6010B0009906,CSC_160X080X090_2,1.00MM,CSC0603,0603,,CAPACITOR-CHIP,4.7UF,6.3V,K,X5R,0603,TR; signal model: C2_6010B0009906_4_7uF_6_3V_3; room: Sheet14
C60900-C60903 = CSC0603: part number: CSC0603-22UF_6.3V_3,6010B0219001,CSC_160X080X090_2,1.05MM,CSC0603,0603,,CAPACITOR-CHIP,22UF,6.3V,R6,0603,TR; signal model: C2_6010B0219001_22UF_6_3V_3; room: Sheet16
C60904 = CSC0603: part number: CSC0603-CSC0603,CSC0603,CSC_160X080X080_2,0.95MM,CSC0603,0603,,CSC0603; signal model: C2_CSC0603_CSC0603; room: Sheet16
C60909 = CSC0402: part number: CSC0402-4.7UF_6.3V_2,6010B0164602,CSC_100X050X065_2,0.75MM,CSC0402,0402,X5R,CAPACITOR-CHIP,4.7UF,6.3V,M,X5R,0402,TR,0.5MM; signal model: C2_6010B0164602_4_7UF_6_3V_2; room: Sheet16
C60910 = CSC0805: part number: CSC0805-10UF_25V_5,6010B0150801,CSC_200X125X140_2,1.55MM,CSC0805,0805,X5R,CAP-CHIP,10UF,25V,K,X5R,0805,TR,1.25MM; signal model: C2_6010B0150801_10UF_25V_5; room: Sheet16
C60911 = CSC0805: part number: CSC0805-CSC0805,CSC0805,CSC_200X125X130_2,1.45MM,CSC0805,0805,,CSC0805; signal model: C2_CSC0805_CSC0805; room: Sheet16
C60912 = CSC0402: part number: CSC0402-0.1UF_25V_2,6010B0087101,CSC_100X050X040_2,0.55MM,CSC0402,0402,X5R,CAP-CHIP,0.1UF,25V,K,X5R,0402,TR; signal model: C2_6010B0087101_0_1uF_25V_2; room: Sheet16
C60915 = CSC0402: part number: CSC0402-0.1UF_16V_2,6010A0036403,CSC_100X050X040_2,0.55MM,CSC0402,0402,X7R,CAP-CHIP,0.1UF,16V,K,X7R,0402,TAP; signal model: C2_6010A0036403_0_1uF_16V_2; room: Sheet16
C60916 = CSC0402: part number: CSC0402-CSC0402,CSC0402,CSC_100X050X040_2,0.55MM,CSC0402,0402,,CSC0402; signal model: C2_CSC0402_CSC0402; room: Sheet16
C60920 = CSC0402: part number: CSC0402-220PF_50V_2,6010B0076701,CSC_100X050X040_2,0.55MM,CSC0402,0402,C0G,CAP-CHIP,220PF,50V,J,C0G,0402,TR; signal model: C2_6010B0076701_220pF_50V_2; room: Sheet16
C60930 = CSC0402: part number: CSC0402-1UF_10V_2,6010B0392201,CSC_100X050X055_2,0.65MM,CSC0402,0402,X5R,CAPACITOR-CHIP,1UF,10V,K,X5R,0402,TR; signal model: C2_6010B0392201_1uF_10V_2; room: Sheet16
C66000 C66001 = CAP_AL_SP: part number: CAP_AL_SP-330UF_2V_9MR_PANA_-35%,6010B0136301,CS_730X430X210_2,2.25MM,CAP_AL_SP,7.3X4.3,,CAPACITOR-AL-SP,330UF,2V,-35%/+10%,105C,DX1.9,SMD,TR,9MOHM; signal model: C2_6010B0136301_330uF_2V_9mR_Pana_-35%; room: Sheet19
C66002 C66004 = CAP_AL_SP: part number: CAP_AL_SP-CSC_DX1.9,CSC_DX1.9_DY,CS_730X430X190_2,2.05MM,CAP_AL_SP,,,CAPACITOR-AL-SP,470UF,2V,M,105C,DX1.9,SMD,TR,4.5MOHM; signal model: C2_CSC_D_1_9_DY_CSC_D_1_9; room: Sheet19
C66003 C66006 C66007 = CSC0603: part number: CSC0603-22UF_6.3V_3,6010B0219002,CSC_160X080X100_2,1.10MM,CSC0603,0603,,CAPACITOR-CHIP,22UF,6.3V,M,X5R,0603,TR,0.8MM; signal model: C2_6010B0219002_22uF_6_3V_3; room: Sheet19
C66008 C66009 = CSC0603: part number: CSC0603-CSC0603,CSC0603,CSC_160X080X080_2,0.95MM,CSC0603,0603,,CSC0603; signal model: C2_CSC0603_CSC0603; room: Sheet19
C66010 C66020 C66030 C66040 = CSC0805: part number: CSC0805-10UF_25V_5,6010B0335901,CSC_200X125X190_2,2.05MM,CSC0805,0805,X5R,CAPACITOR-CER,10UF,25V,K,X5R,0805,SMD,TR; signal model: C2_6010B0335901_10uF_25V_5; room: Sheet19
C66011 C66021 C66031 C66041 = CSC0603: part number: CSC0603-4.7UF_25V_3,6010B0322201,CSC_160X080X095_2,1.10MM,CSC0603,0603,,CAPACITOR-CHIP,4.7UF,25V,K,X5R,0603,TR,0.8MM; signal model: C2_6010B0322201_4_7uF_25V_3; room: Sheet19
C66015 C66025 C66035 C66045 = CSC0402: part number: CSC0402-0.22UF_16V_2,6010B0150901,CSC_100X050X055_2,0.7MM,CSC0402,0402,X7R,CAPACITOR-CHIP,0.22UF,16V,K,X7R,0402,TR,0.5MM; signal model: C2_6010B0150901_0_22uF_16V_2; room: Sheet19
C66016 C66026 C66036 C66046 = CSC0402: part number: CSC0402-1000PF_50V_2,6010071020AT,CSC_100X050X055_2,0.7MM,CSC0402,0402,X7R,CAPACITOR-CHIP,1000PF,50V,K,X7R,0402,TR; signal model: C2_6010071020AT_1000PF_50V_2; room: Sheet19
C66017 C66027 C66037 C66047 = CSC0402: part number: CSC0402-2.2UF_6.3V_2,6010B0059302,CSC_100X050X055_2,0.65MM,CSC0402,0402,X5R,CAPACITOR-CHIP,2.2UF,6.3V,M,X5R,0402,TR; signal model: C2_6010B0059302_2_2UF_6_3V_2; room: Sheet19
C66018 C66028 C66038 C66048 = CSC0402: part number: CSC0402-1UF_6.3V_2,6010B0392101,CSC_100X050X055_2,0.65MM,CSC0402,0402,X5R,CAPACITOR-CHIP,1UF,6.3V,K,X5R,0402,TR; signal model: C2_6010B0392101_1uF_6_3V_2; room: Sheet19
C66100 C66109 = CSC0402: part number: CSC0402-1UF_10V_2,6010B0392201,CSC_100X050X055_2,0.65MM,CSC0402,0402,X5R,CAPACITOR-CHIP,1UF,10V,K,X5R,0402,TR; signal model: C2_6010B0392201_1uF_10V_2; room: Sheet18
C66107 C66407 C66607 = CSC0402: part number: CSC0402-470PF_50V_2,6010A0025101,CSC_100X050X040_2,0.55MM,CSC0402,0402,X7R,CAP-CHIP-471-K,50V-X7R-0402-TAP; signal model: C2_6010A0025101_470pF_50V_2; room: Sheet18
C66113 C66199 C66413 C66670 = CSC0402: part number: CSC0402-0.01UF_50V_2,6010B0058401,CSC_100X050X040_2,0.55MM,CSC0402,0402,X7R,CAP-CHIP,0.01UF,50V,K,X7R,0402,TAP; signal model: C2_6010B0058401_0_01uF_50V_2; room: Sheet18
C66114 C66124 C66134 C66144 C66414 = CSC0402: part number: CSC0402-0.047UF_25V_2,6010B0083801,CSC_100X050X040_2,0.55MM,CSC0402,0402,X7R,CAP-CHIP,0.047UF,25V,K,X7R,0402,TR; signal model: C2_6010B0083801_0_047uF_25V_2; room: Sheet18
C66150 C66180 C66182 C66480 C66482 C66605 C66680 C66682 C66683 = CSC0402: part number: CSC0402-1000PF_50V_2,6010071020AT,CSC_100X050X055_2,0.7MM,CSC0402,0402,X7R,CAPACITOR-CHIP,1000PF,50V,K,X7R,0402,TR; signal model: C2_6010071020AT_1000PF_50V_2; room: Sheet18
C66151 C66197 C66198 C66451 = CSC0402: part number: CSC0402-CSC0402,CSC0402,CSC_100X050X040_2,0.55MM,CSC0402,0402,,CSC0402; signal model: C2_CSC0402_CSC0402; room: Sheet18
C66160 C66460 = CSC0402: part number: CSC0402-0.1UF_16V_2,6010A0036403,CSC_100X050X040_2,0.55MM,CSC0402,0402,X7R,CAP-CHIP,0.1UF,16V,K,X7R,0402,TAP; signal model: C2_6010A0036403_0_1uF_16V_2; room: Sheet18
C66170 C66470 = CSC0402: part number: CSC0402-270PF_50V_2,6010A0009801,CSC_100X050X055_2,0.7MM,CSC0402,0402,X7R,CAPACITOR-CHIP-270PF-J,50V-X7R-0402-TAP; signal model: C2_6010A0009801_270pF_50V_2; room: Sheet18
C66171 C66471 = CSC0402: part number: CSC0402-3300PF_50V_2,6010A0025701,CSC_100X050X040_2,0.55MM,CSC0402,0402,X7R,CAP-CHIP-332-K,50V-X7R-0402-TAP; signal model: C2_6010A0025701_3300pF_50V_2; room: Sheet18
C66172 C66472 C66671 = CSC0402: part number: CSC0402-47PF_50V_2,6010074702AT,CSC_100X050X040_2,0.55MM,CSC0402,0402,NPO,CAP-CHIP-470-J,50V-NPO-0402; signal model: C2_6010074702AT_47pF_50V_2; room: Sheet18
C66296-C66299 = CAP_AL_SP: part number: CAP_AL_SP-15UF_25V,6010B0185101,CS_350X280X200_2,2.15MM,CAP_AL_SP,,,CAPACITOR-TA-SP,15UF,25V,M,105C,BX1.9,SM; signal model: C2_6010B0185101_15uF_25V; room: Sheet19
C66300 = CAP_AL_SP: part number: CAP_AL_SP-CSC_DX1.9,CSC_DX1.9_DY,CS_730X430X190_2,2.05MM,CAP_AL_SP,,,CAPACITOR-AL-SP,470UF,2V,M,105C,DX1.9,SMD,TR,4.5MOHM; signal model: C2_CSC_D_1_9_DY_CSC_D_1_9; room: Sheet20
C66301 = CAP_AL_SP: part number: CAP_AL_SP-330UF_2V_9MR_PANA_-35%,6010B0136301,CS_730X430X210_2,2.25MM,CAP_AL_SP,7.3X4.3,,CAPACITOR-AL-SP,330UF,2V,-35%/+10%,105C,DX1.9,SMD,TR,9MOHM; signal model: C2_6010B0136301_330uF_2V_9mR_Pana_-35%; room: Sheet20
C66303 C66306-C66309 = CSC0603: part number: CSC0603-22UF_6.3V_3,6010B0219002,CSC_160X080X100_2,1.10MM,CSC0603,0603,,CAPACITOR-CHIP,22UF,6.3V,M,X5R,0603,TR,0.8MM; signal model: C2_6010B0219002_22uF_6_3V_3; room: Sheet20
C66310 C66311 = CSC0603: part number: CSC0603-4.7UF_25V_3,6010B0322201,CSC_160X080X095_2,1.10MM,CSC0603,0603,,CAPACITOR-CHIP,4.7UF,25V,K,X5R,0603,TR,0.8MM; signal model: C2_6010B0322201_4_7uF_25V_3; room: Sheet20
C66312 = CSC0402: part number: CSC0402-1UF_25V_2,6010B0455901,CSC_100X050X055_2,0.65MM,CSC0402,0402,X5R,CAPACITOR-CHIP,1UF,25V,K,X5R,0402,TR,0.5MM; signal model: C2_6010B0455901_1UF_25V_2; room: Sheet20
C66315 = CSC0402: part number: CSC0402-0.22UF_16V_2,6010B0150901,CSC_100X050X055_2,0.7MM,CSC0402,0402,X7R,CAPACITOR-CHIP,0.22UF,16V,K,X7R,0402,TR,0.5MM; signal model: C2_6010B0150901_0_22uF_16V_2; room: Sheet20
C66316 = CSC0402: part number: CSC0402-1000PF_50V_2,6010071020AT,CSC_100X050X055_2,0.7MM,CSC0402,0402,X7R,CAPACITOR-CHIP,1000PF,50V,K,X7R,0402,TR; signal model: C2_6010071020AT_1000PF_50V_2; room: Sheet20
C66317 = CSC0603: part number: CSC0603-1UF_25V_3,6010B0067602,CSC_160X080X080_2,0.90MM,CSC0603,0603,,CAPACITOR-CHIP,1UF,25V,K,X5R,0603,TR; signal model: C2_6010B0067602_1uF_25V_3; room: Sheet20
C66450 = CSC0402: part number: CSC0402-1200PF_50V_2,6010B0065301,CSC_100X050X040_2,0.55MM,CSC0402,0402,X7R,CAP-CHIP,1200PF,50V,K,X7R,0402,TR; signal model: C2_6010B0065301_1200pF_50V_2; room: Sheet18
C66598 C66599 = CAP_AL_SP: part number: CAP_AL_SP-15UF_25V,6010B0185101,CS_350X280X200_2,2.15MM,CAP_AL_SP,,,CAPACITOR-TA-SP,15UF,25V,M,105C,BX1.9,SM; signal model: C2_6010B0185101_15uF_25V; room: Sheet20
C66600-C66602 = CSC0603: part number: CSC0603-22UF_6.3V_3,6010B0219002,CSC_160X080X100_2,1.10MM,CSC0603,0603,,CAPACITOR-CHIP,22UF,6.3V,M,X5R,0603,TR,0.8MM; signal model: C2_6010B0219002_22uF_6_3V_3; room: Sheet21
C66603 C66604 = CSC0603: part number: CSC0603-CSC0603,CSC0603,CSC_160X080X080_2,0.95MM,CSC0603,0603,,CSC0603; signal model: C2_CSC0603_CSC0603; room: Sheet21
C66610 C66611 = CSC0805: part number: CSC0805-10UF_25V_5,6010B0335901,CSC_200X125X190_2,2.05MM,CSC0805,0805,X5R,CAPACITOR-CER,10UF,25V,K,X5R,0805,SMD,TR; signal model: C2_6010B0335901_10uF_25V_5; room: Sheet21
C66615 = CSC0402: part number: CSC0402-0.1UF_16V_2,6010A0036403,CSC_100X050X040_2,0.55MM,CSC0402,0402,X7R,CAP-CHIP,0.1UF,16V,K,X7R,0402,TAP; signal model: C2_6010A0036403_0_1uF_16V_2; room: Sheet21
C66616 = CSC0402: part number: CSC0402-CSC0402,CSC0402,CSC_100X050X040_2,0.55MM,CSC0402,0402,,CSC0402; signal model: C2_CSC0402_CSC0402; room: Sheet21
C66617 = CSC0402: part number: CSC0402-2.2UF_6.3V_2,6010B0059302,CSC_100X050X055_2,0.65MM,CSC0402,0402,X5R,CAPACITOR-CHIP,2.2UF,6.3V,M,X5R,0402,TR; signal model: C2_6010B0059302_2_2UF_6_3V_2; room: Sheet21
C66650 = CSC0402: part number: CSC0402-6800PF_25V_2,6010A0000701,CSC_100X050X040_2,0.55MM,CSC0402,0402,X7R,CAP-CHIP-682-K,25V-X7R-0402-TAP; signal model: C2_6010A0000701_6800pF_25V_2; room: Sheet18
C66651 = CSC0402: part number: CSC0402-0.033UF_16V_2,6010B0010101,CSC_100X050X040_2,0.55MM,CSC0402,0402,X7R,CAP-CHIP,0.033UF,16V,K,X7R,0402,TR; signal model: C2_6010B0010101_0_033uF_16V_2; room: Sheet18
C66652 = CSC0402: part number: CSC0402-2200PF_50V_2,6010A0036305,CSC_100X050X040_2,0.55MM,CSC0402,0402,X7R,CAP-CHIP-2200PF-50V-K-X7R-0402-TAP; signal model: C2_6010A0036305_2200pF_50V_2; room: Sheet18
C67000 C67001 C67006 = CAP_AL_SP: part number: CAP_AL_SP-330UF_2V_9MR_PANA_-35%,6010B0136301,CS_730X430X210_2,2.25MM,CAP_AL_SP,7.3X4.3,,CAPACITOR-AL-SP,330UF,2V,-35%/+10%,105C,DX1.9,SMD,TR,9MOHM; signal model: C2_6010B0136301_330uF_2V_9mR_Pana_-35%; room: Sheet109
C67002 C67003 = CAP_AL_SP: part number: CAP_AL_SP-330UF_2V_9MR_PANA_-35%,6010B0136301,CS_730X430X210_2,2.25MM,CAP_AL_SP,7.3X4.3,,CAPACITOR-AL-SP,330UF,2V,-35%/+10%,105C,DX1.9,SMD,TR,9MOHM; signal model: C2_6010B0136301_330uF_2V_9mR_Pana_-35%; room: Sheet110
C67004 C67005 = CAP_AL_SP: part number: CAP_AL_SP-330UF_2V_9MR_PANA_-35%,6010B0136301,CS_730X430X210_2,2.25MM,CAP_AL_SP,7.3X4.3,,CAPACITOR-AL-SP,330UF,2V,-35%/+10%,105C,DX1.9,SMD,TR,9MOHM; signal model: C2_6010B0136301_330uF_2V_9mR_Pana_-35%; room: Sheet111
C67009 C67088 = CSC0402: part number: CSC0402-1UF_6.3V_2,6010B0006001,CSC_100X050X040_2,0.55MM,CSC0402,0402,X5R,CAP-CHIP,1UF,6.3V,K,X5R,0402,TR; signal model: C2_6010B0006001_1uF_6_3V_2; room: Sheet108
C67010 C67011 C67020 C67021 = CSC0805: part number: CSC0805-10UF_25V_5,6010B0335901,CSC_200X125X190_2,2.05MM,CSC0805,0805,X5R,CAPACITOR-CER,10UF,25V,K,X5R,0805,SMD,TR; signal model: C2_6010B0335901_10uF_25V_5; room: Sheet109
C67012 C67022 = CSC0603: part number: CSC0603-1UF_25V_3,6010B0067602,CSC_160X080X080_2,0.90MM,CSC0603,0603,,CAPACITOR-CHIP,1UF,25V,K,X5R,0603,TR; signal model: C2_6010B0067602_1uF_25V_3; room: Sheet109
C67013 C67023 = CAP_AL_SP: part number: CAP_AL_SP-15UF_25V,6010B0185101,CS_350X280X200_2,2.15MM,CAP_AL_SP,,,CAPACITOR-TA-SP,15UF,25V,M,105C,BX1.9,SM; signal model: C2_6010B0185101_15uF_25V; room: Sheet109
C67015 C67025 = CSC0402: part number: CSC0402-0.22UF_16V_2,6010B0150901,CSC_100X050X055_2,0.7MM,CSC0402,0402,X7R,CAPACITOR-CHIP,0.22UF,16V,K,X7R,0402,TR,0.5MM; signal model: C2_6010B0150901_0_22uF_16V_2; room: Sheet109
C67016 C67026 = CSC0402: part number: CSC0402-CSC0402,CSC0402,CSC_100X050X040_2,0.55MM,CSC0402,0402,,CSC0402; signal model: C2_CSC0402_CSC0402; room: Sheet109
C67019 C67029 = CSC0402: part number: CSC0402-1UF_6.3V_2,6010B0392101,CSC_100X050X055_2,0.65MM,CSC0402,0402,X5R,CAPACITOR-CHIP,1UF,6.3V,K,X5R,0402,TR; signal model: C2_6010B0392101_1uF_6_3V_2; room: Sheet109
C67030 C67031 C67040 C67041 = CSC0805: part number: CSC0805-10UF_25V_5,6010B0335901,CSC_200X125X190_2,2.05MM,CSC0805,0805,X5R,CAPACITOR-CER,10UF,25V,K,X5R,0805,SMD,TR; signal model: C2_6010B0335901_10uF_25V_5; room: Sheet110
C67032 C67042 = CSC0603: part number: CSC0603-1UF_25V_3,6010B0067602,CSC_160X080X080_2,0.90MM,CSC0603,0603,,CAPACITOR-CHIP,1UF,25V,K,X5R,0603,TR; signal model: C2_6010B0067602_1uF_25V_3; room: Sheet110
C67033 C67043 = CAP_AL_SP: part number: CAP_AL_SP-15UF_25V,6010B0185101,CS_350X280X200_2,2.15MM,CAP_AL_SP,,,CAPACITOR-TA-SP,15UF,25V,M,105C,BX1.9,SM; signal model: C2_6010B0185101_15uF_25V; room: Sheet110
C67035 C67045 = CSC0402: part number: CSC0402-0.22UF_16V_2,6010B0150901,CSC_100X050X055_2,0.7MM,CSC0402,0402,X7R,CAPACITOR-CHIP,0.22UF,16V,K,X7R,0402,TR,0.5MM; signal model: C2_6010B0150901_0_22uF_16V_2; room: Sheet110
C67036 C67046 = CSC0402: part number: CSC0402-CSC0402,CSC0402,CSC_100X050X040_2,0.55MM,CSC0402,0402,,CSC0402; signal model: C2_CSC0402_CSC0402; room: Sheet110
C67039 C67049 = CSC0402: part number: CSC0402-1UF_6.3V_2,6010B0392101,CSC_100X050X055_2,0.65MM,CSC0402,0402,X5R,CAPACITOR-CHIP,1UF,6.3V,K,X5R,0402,TR; signal model: C2_6010B0392101_1uF_6_3V_2; room: Sheet110
C67050 C67051 C67060 C67061 = CSC0805: part number: CSC0805-10UF_25V_5,6010B0335901,CSC_200X125X190_2,2.05MM,CSC0805,0805,X5R,CAPACITOR-CER,10UF,25V,K,X5R,0805,SMD,TR; signal model: C2_6010B0335901_10uF_25V_5; room: Sheet111
C67052 C67062 = CSC0603: part number: CSC0603-1UF_25V_3,6010B0067602,CSC_160X080X080_2,0.90MM,CSC0603,0603,,CAPACITOR-CHIP,1UF,25V,K,X5R,0603,TR; signal model: C2_6010B0067602_1uF_25V_3; room: Sheet111
C67053 C67063 = CAP_AL_SP: part number: CAP_AL_SP-15UF_25V,6010B0185101,CS_350X280X200_2,2.15MM,CAP_AL_SP,,,CAPACITOR-TA-SP,15UF,25V,M,105C,BX1.9,SM; signal model: C2_6010B0185101_15uF_25V; room: Sheet111
C67055 C67065 = CSC0402: part number: CSC0402-0.22UF_16V_2,6010B0150901,CSC_100X050X055_2,0.7MM,CSC0402,0402,X7R,CAPACITOR-CHIP,0.22UF,16V,K,X7R,0402,TR,0.5MM; signal model: C2_6010B0150901_0_22uF_16V_2; room: Sheet111
C67056 C67066 = CSC0402: part number: CSC0402-CSC0402,CSC0402,CSC_100X050X040_2,0.55MM,CSC0402,0402,,CSC0402; signal model: C2_CSC0402_CSC0402; room: Sheet111
C67059 C67069 = CSC0402: part number: CSC0402-1UF_6.3V_2,6010B0392101,CSC_100X050X055_2,0.65MM,CSC0402,0402,X5R,CAPACITOR-CHIP,1UF,6.3V,K,X5R,0402,TR; signal model: C2_6010B0392101_1uF_6_3V_2; room: Sheet111
C67080 C67081 = CSC0402: part number: CSC0402-CSC0402,CSC0402,CSC_100X050X040_2,0.55MM,CSC0402,0402,,CSC0402; signal model: C2_CSC0402_CSC0402; room: Sheet108
C67082 = CSC0402: part number: CSC0402-0.01UF_50V_2,6010B0058401,CSC_100X050X040_2,0.55MM,CSC0402,0402,X7R,CAP-CHIP,0.01UF,50V,K,X7R,0402,TAP; signal model: C2_6010B0058401_0_01uF_50V_2; room: Sheet108
C67087 C67089 = CSC0402: part number: CSC0402-1000PF_50V_2,6010071020AT,CSC_100X050X055_2,0.7MM,CSC0402,0402,X7R,CAPACITOR-CHIP,1000PF,50V,K,X7R,0402,TR; signal model: C2_6010071020AT_1000PF_50V_2; room: Sheet108
C67090 C67091 C67096 = CSC0603: part number: CSC0603-22UF_6.3V_3,6010B0219001,CSC_160X080X090_2,1.05MM,CSC0603,0603,,CAPACITOR-CHIP,22UF,6.3V,R6,0603,TR; signal model: C2_6010B0219001_22UF_6_3V_3; room: Sheet109
C67092 C67093 = CSC0603: part number: CSC0603-22UF_6.3V_3,6010B0219001,CSC_160X080X090_2,1.05MM,CSC0603,0603,,CAPACITOR-CHIP,22UF,6.3V,R6,0603,TR; signal model: C2_6010B0219001_22UF_6_3V_3; room: Sheet110
C67094 C67095 = CSC0603: part number: CSC0603-22UF_6.3V_3,6010B0219001,CSC_160X080X090_2,1.05MM,CSC0603,0603,,CAPACITOR-CHIP,22UF,6.3V,R6,0603,TR; signal model: C2_6010B0219001_22UF_6_3V_3; room: Sheet111
C67097 = CSC0603: part number: CSC0603-CSC0603,CSC0603,CSC_160X080X080_2,0.95MM,CSC0603,0603,,CSC0603; signal model: C2_CSC0603_CSC0603; room: Sheet109
