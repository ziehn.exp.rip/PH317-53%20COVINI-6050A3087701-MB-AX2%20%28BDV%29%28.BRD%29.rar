# Allegro board PH317-53 COVINI-6050A3087701-MB-AX2 (BDV)(.BRD).brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
FBB_CMD11: length 27.2
  BOTTOM w0.109: U50700.L10 206.11,144.68 206.11,144.68 206.31,144.48 207.24,144.48 207.31,144.4 207.4,144.49 208.16,144.49 208.38,144.71 208.38,145.26 U50700.H10
  BOTTOM w0.137: U50000.B39 186.74,139.38 187.06,139.7 190.36,139.7 190.64,139.42 192.01,139.42 193.82,139.42 198.87,144.47 200.4,144.47 200.8,144.06 206.48,144.06 206.61,144.19 207.1,144.19 207.31,144.4
FBB_CMD12: length 23.4
  BOTTOM w0.137: U50000.C39 186.01,139.38 186.36,139.73 186.7,139.73 186.93,139.96 188.69,139.96 188.77,140.04 190.64,140.04 190.88,139.79 192.17,139.79 192.17,139.79 193.11,139.79 193.11,139.79 193.66,139.79 198.71,144.84 200.45,144.84 200.98,144.31 204.38,144.31 204.57,144.5 204.57,144.63 204.98,145.05 204.98,145.66 U50700.M11
FBB_CMD13: length 29.4
  L8 w0.086: v4(206.45,146.42) 206.13,146.74 206.13,148.37 v4(206.45,148.69)
  BOTTOM w0.137: v4(206.45,146.42) 206.11,146.76 206.11,146.8 206.11,146.8 U50700.L12 ; U50000.C41 185.99,140.78 186.34,140.42 186.64,140.42 186.86,140.2 188.17,140.2 188.37,140.4 190.8,140.4 191.02,140.17 192.33,140.17 193.5,140.17 199.64,146.31 199.64,148.53 200.34,149.23 205.91,149.23 v4(206.45,148.69)
FBB_CMD14: length 30.6
  L3 w0.086: v4(207.24,145.69) 207.24,145.77 206.86,146.15 206.86,148.89 v1(205.89,149.86)
  BOTTOM w0.109: U50700.J11 207.27,145.69 v4(207.24,145.69) 207.19,145.69 U50700.K11
  BOTTOM w0.137: U50000.B41 186.71,140.78 187.05,140.44 187.92,140.44 188.2,140.71 191.19,140.71 191.35,140.55 192.97,140.55 195.27,142.85 195.27,143.02 196.66,144.42 196.99,144.42 199.13,146.56 199.13,148.62 200.1,149.59 200.34,149.59 200.36,149.61 205.63,149.61 v1(205.89,149.86)
FBB_CMD15: length 29.8
  L3 w0.086: v4(207.23,147.15) 207.61,147.54 v1(207.61,149.86)
  BOTTOM w0.109: U50700.J12 207.23,147.15 v4(207.23,147.15) U50700.K12
  BOTTOM w0.137: U50000.A41 187.91,140.78 188.23,141.09 191.19,141.09 191.35,140.93 192.81,140.93 194.89,143.01 194.89,143.18 198.75,147.04 198.75,148.83 199.89,149.97 205.12,149.97 205.51,150.36 207.12,150.36 v1(207.61,149.86)
FBB_CMD16: length 37.2
  L8 w0.086: v4(208.03,164.21) 208.35,163.27 208.35,163.05 v4(207.98,162.47)
  BOTTOM w0.137: U50000.B49 186.84,146.04 188.35,146.04 189,146.69 189,148.46 189.62,150.25 190.22,151.96 191.1,154.49 193.75,158 196.08,161.07 198.22,163.91 199.9,165.58 200.88,166.08 204.78,166.64 206.22,166.64 206.48,166.38 v4(208.03,164.21) ; v4(207.98,162.47) U50800.L3
FBB_CMD17: length 37.6
  L8 w0.086: v1(207.91,165.11) 207.9,165.1 207.7,164.53 207.7,164.1 207.59,163.36 207.59,163.1 v4(207.22,162.45)
  BOTTOM w0.109: U50800.J3 v4(207.22,162.45) 207.24,162.45 U50800.K3
  BOTTOM w0.137: U50000.A49 187.27,146.31 188.22,146.31 188.61,146.69 188.61,149.23 189.13,150.74 190.11,153.53 190.28,154.04 190.69,154.58 197.84,164.03 197.84,164.06 197.94,164.16 197.95,164.18 197.96,164.18 199.67,165.89 200.81,166.48 204.62,167.02 206.38,167.02 206.77,166.63 207.71,165.31 v1(207.91,165.11)
FBB_CMD18_RST: length 34
  BOTTOM w0.137: U50000.A48 188.37,145.68 189.41,146.72 189.41,148.21 189.99,149.88 191.61,154.55 195.61,159.83 198.55,162.77 198.55,163.65 200.18,165.28 205.09,165.28 R50806.1 206.19,165.95 206.19,165.5 206.93,164.76 206.93,163.66 U50800.J1
FBB_CMD19: length 35.1
  L8 w0.086: v4(206.04,160.02) 206.27,159.8 207.41,159.8 207.61,160 207.61,160.59 v4(207.23,160.96)
  BOTTOM w0.109: U50800.J4 v4(207.23,160.96) U50800.K4
  BOTTOM w0.137: v4(206.04,160.02) 205.56,159.54 203.85,159.54 203.57,159.27 202.23,159.27 201.8,159.7 200.57,159.7 200.01,160.27 199.3,160.27 193.32,154.29 193.21,154.14 193.08,153.97 191.23,148.64 190.99,147.97 190.99,146.52 188.87,144.39 187.69,144.39 187.68,144.4 186.88,144.4 186.64,144.64 185.64,144.64 185.29,144.98 U50000.D47
FBB_CMD20: length 33.8
  L8 w0.086: v4(205.73,163.96) 206.09,163.61 206.09,162.11 v4(206.48,161.71)
  BOTTOM w0.137: v4(206.48,161.71) U50800.H3 ; v4(205.73,163.96) 205.18,164.52 200.49,164.52 199.54,163.58 199.54,162.11 195.88,158.45 195.78,158.45 194.7,157.37 192.36,154.28 190.62,149.26 190.24,148.17 190.24,146.66 188.56,144.98 U50000.A47
FBB_CMD21: length 30.7
  BOTTOM w0.137: U50000.B47 186.71,144.98 187.05,144.64 188.64,144.64 190.62,146.61 190.62,148.03 190.93,148.94 192.74,154.15 192.83,154.27 192.83,154.27 193.11,154.63 194.21,156.1 198.76,160.64 200.07,160.64 200.77,159.94 201.9,159.94 202.32,159.52 203.44,159.52 203.73,159.81 205.14,159.81 205.73,160.39 205.73,160.97 U50800.G4
FBB_CMD22: length 38.4
  L8 w0.086: v1(206.46,164.55) 206.84,164.17 206.84,160.94 v4(207.25,160.22)
  BOTTOM w0.109: U50800.K5 207.61,160.58 v4(207.25,160.22) 207.22,160.22 U50800.J5
  BOTTOM w0.137: v1(206.46,164.55) 205.35,164.9 200.33,164.9 199.06,163.63 199.06,162.41 194.88,158.23 191.96,154.38 190.29,149.58 189.77,148.08 189.77,146.63 188.47,145.33 186.33,145.33 185.98,144.98 U50000.C47
FBB_CMD23: length 34.5
  BOTTOM w0.109: U50800.L5 207.36,159.59 207.13,159.59 206.13,160.59 U50800.H5
  BOTTOM w0.137: U50000.C45 186.01,143.58 186.36,143.93 186.7,143.93 186.92,144.16 187.59,144.16 187.65,144.1 189.08,144.1 191.38,146.41 191.38,147.78 193.65,150.04 193.65,153.83 199.27,159.46 201.7,159.46 202.13,159.03 203.82,159.03 204.05,159.26 205.72,159.26 205.95,159.49 207.03,159.49 207.13,159.59
FBB_CMD24: length 34
  BOTTOM w0.137: U50800.M4 208.73,160.96 208.73,160.38 208.47,160.11 208.47,159.5 208.19,159.22 206.03,159.22 205.76,158.94 204.2,158.94 204.05,158.79 201.92,158.79 201.63,159.08 199.43,159.08 196.58,156.23 196.58,155.31 194.02,152.76 194.02,149.65 191.76,147.38 191.76,146.3 189.23,143.78 187.63,143.78 187.51,143.9 187.06,143.9 187.06,143.9 187.02,143.9 186.7,143.58 U50000.B45
FBB_CMD25: length 34.2
  BOTTOM w0.137: U50800.M11 209.48,156.46 209.48,157.01 209.64,157.17 209.64,157.54 208.25,158.92 206.26,158.92 205.96,158.62 204.34,158.62 204.27,158.55 201.83,158.55 201.67,158.7 199.59,158.7 197.09,156.2 197.09,154.91 194.4,152.23 194.4,149.49 192.14,147.23 192.14,146.14 189.52,143.53 187.25,143.53 U50000.A45
FBB_CMD26_CKE: length 39.4
  TOP w0.137: v4(207.78,158.03) 208.34,158.03 R50805.1
  L8 w0.076: v4(205.79,157.69) 206.56,157.61 206.93,157.61 v4(207.78,158.03) 209.32,158.03 209.45,157.91 209.45,157.55 v4(209.23,157.33)
  BOTTOM w0.109: v4(209.23,157.33) U50800.M10 ; v4(205.79,157.69) U50800.G10
  BOTTOM w0.137: v4(207.78,158.03) 207.78,158.42 207.52,158.68 206.48,158.68 206.14,158.35 204.55,158.35 204.5,158.3 201.67,158.3 201.57,158.4 199.82,158.4 197.7,156.28 197.7,154.53 194.78,151.62 194.78,148.15 189.86,143.23 185.45,143.23 U50000.D44
FBB_CMD27: length 34
  BOTTOM w0.109: U50800.L10 208.46,156.94 208.46,157.32 208.18,157.61 206.29,157.61 206.11,157.42 U50800.H10
  BOTTOM w0.137: U50000.A44 187.2,142.9 187.22,142.91 190.08,142.91 195.23,148.07 195.23,151.29 198.41,154.47 198.41,156.45 200.08,158.13 201.47,158.13 201.54,158.05 204.72,158.05 204.78,158.11 206.31,158.11 206.63,158.42 207.11,158.42 207.34,158.19 207.34,157.61
FBB_CMD28: length 29.5
  BOTTOM w0.137: U50800.G11 204.98,156.46 204.98,157 204.29,157.69 202.54,157.69 202.42,157.81 201.45,157.81 201.37,157.89 200.35,157.89 200.16,157.7 200.16,157.67 199.1,156.61 199.1,154.29 195.61,150.8 195.61,147.91 190.36,142.66 187.44,142.66 187.33,142.56 187.06,142.56 186.74,142.88 U50000.B44
FBB_CMD29: length 29.5
  L8 w0.086: v4(205.03,152.4) 206.19,153.56 206.19,155.42 v4(206.48,155.71)
  BOTTOM w0.137: v4(205.03,152.4) 205,152.4 204.92,152.48 198.4,152.48 196.07,150.16 196.07,147.84 190.66,142.42 187.54,142.42 187.43,142.32 186.97,142.32 186.75,142.53 186.34,142.53 185.99,142.88 U50000.C44 ; U50800.H12 v4(206.48,155.71)
FBB_CMD30: length 30.4
  L8 w0.086: v4(207.23,154.96) 206.79,154.53 206.79,152.85 v4(206.52,152.58)
  BOTTOM w0.109: U50800.K12 v4(207.23,154.96) U50800.J12
  BOTTOM w0.137: U50000.C42 186,141.48 186.35,141.83 186.63,141.83 186.86,142.06 187.7,142.06 187.83,142.18 190.95,142.18 196.95,148.18 196.95,150.11 198.89,152.05 204.54,152.05 204.7,151.9 205.91,151.9 206.48,152.46 206.48,152.54 v4(206.52,152.58)
FBB_CMD31: length 31.9
  L8 w0.086: v4(207.58,152.79) 207.58,152.82 207.6,152.83 207.6,155.07 207.56,155.11 207.56,155.83 207.55,155.85 207.55,156.02 207.24,156.34 v4(207.24,156.42)
  BOTTOM w0.109: U50800.J11 v4(207.24,156.42) U50800.K11
  BOTTOM w0.137: U50000.B42 186.7,141.48 187.04,141.82 187.8,141.82 187.9,141.92 191.22,141.92 191.42,142.11 191.84,142.11 192.35,142.62 192.35,143.03 197.56,148.24 197.56,150.15 199.06,151.65 206.24,151.65 207.38,152.79 v4(207.58,152.79)
FBB_CMD32: length 33.7
  L3 w0.086: v1(208.86,149.93) 208.86,149.85 208.4,149.39 208.4,147.41 208.35,147.36 208.35,147 208,146.66 v4(208,146.43)
  BOTTOM w0.137: v1(208.86,149.93) 207.98,150.81 200.2,150.81 198.38,148.98 198.38,147.43 196.31,145.37 196.31,145.14 192.48,141.31 191.35,141.31 191.29,141.36 188.15,141.36 187.93,141.14 185.46,141.14 U50000.D41 ; v4(208,146.43) 208.36,146.78 U50700.H12
FBB_CMD33: length 32.4
  L8 w0.086: v4(207.98,155.71) 208.35,155.35 208.35,153.2 208.47,153.08 208.82,153.08 v4(209.2,152.71)
  BOTTOM w0.137: U50000.A42 187.86,141.48 188.02,141.65 191.31,141.65 191.35,141.69 192.33,141.69 193.89,143.25 193.89,143.48 197.99,147.58 197.99,149.93 199.23,151.17 206.37,151.17 207.31,152.11 208.66,152.11 209.2,152.65 v4(209.2,152.71) ; U50800.L12 v4(207.98,155.71)
FBB_D0: length 32.4
  L8 w0.109: v4(209.48,138.91) 209.94,138.45 209.94,137.13 208.43,135.63 205.65,135.63 205.37,135.9 187.97,135.9 186.55,134.48 184.46,134.48 184.41,134.43 183.12,134.43 182.78,134.77 v4(181.97,134.77)
  BOTTOM w0.17: v4(181.97,134.77) U50000.H32 ; v4(209.48,138.91) 209.86,139.28 U50700.F2
FBB_D1: length 33.7
  L10 w0.109: v4(185.47,134.13) 185.85,134.51 186.47,134.51 186.55,134.59 186.81,134.59 187.66,135.44 199.26,135.44 199.37,135.32 210.66,135.32 212.86,137.52 212.86,140.78 v4(213.23,141.16)
  BOTTOM w0.17: v4(213.23,141.16) U50700.B4 ; v4(185.47,134.13) U50000.D32
FBB_D2: length 30.7
  L8 w0.109: v4(188.9,135) 189.01,134.89 204.25,134.89 204.47,134.67 209.86,134.67 212.86,137.68 212.86,138.64 212.86,138.65 212.86,139.5 212.86,139.5 212.86,140.03 v4(212.48,140.41)
  BOTTOM w0.17: U50700.B3 212.86,140.03 v4(212.48,140.41) ; U50000.A33 187.38,135.36 188.54,135.36 v4(188.9,135)
FBB_D3: length 28.8
  L8 w0.109: v4(210.23,139.66) 210.61,139.28 210.61,137.01 208.75,135.16 205.36,135.16 205.06,135.45 188.17,135.45 187.7,134.98 v4(187.7,134.91)
  BOTTOM w0.17: v4(187.7,134.91) 187.62,134.83 186.85,134.83 U50000.B32 ; v4(210.23,139.66) U50700.E2
FBB_D4: length 34.8
  L8 w0.109: v4(184.08,134.02) 184.49,133.79 184.63,133.73 187.08,133.73 187.79,134.44 204.06,134.44 204.31,134.19 210.36,134.19 213.6,137.44 213.6,139.29 v4(213.23,139.66)
  BOTTOM w0.17: v4(184.08,134.02) U50000.E32 ; v4(213.23,139.66) U50700.B2
FBB_D5: length 34.1
  L10 w0.109: v4(210.98,140.41) 210.98,140.17 210.61,139.8 210.61,137.59 209.24,136.23 199.82,136.23 199.13,136.92 187.68,136.92 186.02,135.26 185.25,135.26 185.13,135.15 185.13,134.73 184.91,134.51 184.46,134.51 184.35,134.4 182.92,134.4 v4(182.7,134.18)
  BOTTOM w0.17: v4(182.7,134.18) U50000.G32 ; U50700.E3 v4(210.98,140.41)
FBB_D6: length 38.6
  L10 w0.109: v4(213.98,140.41) 213.61,140.03 213.61,137.31 211.17,134.87 189.54,134.87 189.2,134.53 187.83,134.53 187.03,133.73 185.24,133.73 185.23,133.72 184.93,133.72 184.91,133.74 184.37,133.74 183.72,133.09 181.56,133.09 v4(181.2,132.73)
  BOTTOM w0.17: U50000.J30 181.6,133.06 v4(181.2,132.73) ; v4(213.98,140.41) U50700.A3
FBB_D7: length 29.7
  L10 w0.109: v4(183.4,134.78) 183.77,135.14 184.2,135.14 184.4,135.34 184.4,135.7 184.6,135.9 185.23,135.9 185.56,136.23 186.44,136.23 187.81,137.6 199.2,137.6 199.98,136.82 206.26,136.82 207.19,137.75 207.33,137.75 207.53,137.95 207.53,138.09 207.6,138.16 207.6,138.43 207.71,138.53 208.12,138.53 208.36,138.78 208.36,139.29 v4(208.73,139.66)
  BOTTOM w0.17: v4(208.73,139.66) 209.11,139.28 U50700.G2 ; v4(183.4,134.78) U50000.F32
FBB_D8: length 34
  L3 w0.109: v4(210.23,147.16) 209.85,146.77 209.85,145.89 209.69,145.73 209.69,144.31 208.19,142.82 205.63,142.82 204.34,141.53 196.99,141.53 194.18,138.72 187.36,138.72 185.46,138.47 184.83,138.2 184.43,137.8 184.34,137.52 184.19,137.37 183.74,137.37 183.61,137.24 183.2,137.24 v4(182.6,136.98)
  BOTTOM w0.17: U50700.E13 v4(210.23,147.16) ; v4(182.6,136.98) U50000.H36
FBB_D9: length 32.9
  L3 w0.109: v4(183.35,137.61) 183.65,137.96 183.95,138.55 184.03,138.64 185.04,138.64 185.36,138.95 185.71,138.95 186.8,139.38 193.91,139.38 197.55,143.02 204.1,143.02 205.38,144.31 208.15,144.31 208.42,144.57 208.42,145.03 208.63,145.24 208.87,145.24 209.11,145.48 209.11,147.53 v4(209.48,147.91)
  BOTTOM w0.17: U50000.G36 183.33,137.61 v4(183.35,137.61) ; U50700.F13 209.86,147.53 v4(209.48,147.91)
FBB_D10: length 33.1
  L3 w0.109: v4(208.73,147.16) 208.73,146.94 208.37,146.58 208.37,146.15 208.27,146.06 207.82,146.06 207.61,145.85 207.61,145.49 207.41,145.28 204.93,145.28 204.59,144.94 204.59,144.43 203.68,143.52 197.1,143.52 193.43,139.86 186.36,139.86 185.58,139.36 185.13,139.39 184.62,139.39 184.13,139.36 183.25,139.36 183.04,139.16 183.04,138.86 182.87,138.69 182.5,138.69 182.27,138.47 182.27,137.96 v4(181.94,137.62)
  BOTTOM w0.17: v4(208.73,147.16) 209.11,147.53 U50700.G13 ; v4(181.94,137.62) U50000.J36
FBB_D11: length 39.1
  L8 w0.109: v4(184,136.98) 184.18,137.17 186.17,137.17 187.84,138.84 193.82,138.84 194.13,138.53 203.67,138.53 203.88,138.74 203.88,140.65 204,140.78 204.44,140.78 204.61,140.94 204.61,144.73 205.18,145.3 209.61,145.3 209.78,145.48 209.78,145.85 209.96,146.02 211.25,146.02 211.35,146.12 211.35,146.66 211.47,146.78 211.91,146.78 212.1,146.97 212.1,147.35 212.29,147.54 212.86,147.54 v4(213.23,147.91)
  BOTTOM w0.17: v4(184,136.98) U50000.F36 ; U50700.B13 v4(213.23,147.91)
FBB_D12: length 37
  L3 w0.109: v4(212.49,146.41) 212.11,146.03 212.11,143.86 211.31,143.07 211.31,141.32 211.33,141.3 211.33,140.26 211.31,140.24 211.31,140.15 211.2,140.04 206,140.04 205.25,139.29 197.49,139.29 194.82,136.62 186.72,136.62 186.35,136.26 185.54,136.26 185.2,135.91 184.58,135.91 184.18,135.51 v4(184.03,135.51)
  BOTTOM w0.17: U50700.B12 212.86,146.78 v4(212.49,146.41) ; v4(184.03,135.51) U50000.F33
FBB_D13: length 36.3
  L8 w0.109: v4(213.24,145.64) 213.04,145.43 213.04,144.31 212.23,143.51 210.89,143.51 209.77,142.39 209.77,141.19 209.35,140.77 208.58,140.77 208.36,140.55 208.36,137.58 207.83,137.05 206.22,137.05 205.97,136.81 187.35,136.81 186.82,136.27 185.94,136.27 185.56,135.89 v4(185.56,135.64)
  BOTTOM w0.17: v4(213.24,145.64) U50700.B11 ; v4(185.56,135.64) U50000.D33
FBB_D14: length 43.5
  L3 w0.109: v4(181.29,134.18) 181.77,134.38 182.04,134.38 182.45,134.56 182.95,134.56 183.41,134.39 184.3,134.39 184.82,134.51 186.47,134.51 187.37,135.41 195.32,135.41 197.65,137.74 205.43,137.74 206.21,138.53 212.62,138.53 212.86,138.76 212.86,142.82 213.84,143.8 213.84,145.23 213.62,145.46 213.62,146.79 v4(213.98,147.16)
  BOTTOM w0.17: v4(213.98,147.16) U50700.A12 ; v4(181.29,134.18) U50000.J32
FBB_D15: length 35.6
  L3 w0.109: v4(210.97,146.39) 210.61,146.03 210.61,144.27 209.22,142.88 209.22,141.99 208.77,141.54 205.21,141.54 204.45,140.78 197.49,140.78 194.3,137.59 186.31,137.59 186.12,137.4 185.14,137.4 184.28,136.54 184.05,136.54 183.66,136.25 183.66,135.82 183.3,135.45 182.73,135.45 v4(182.67,135.51)
  BOTTOM w0.17: v4(210.97,146.39) 210.61,146.75 U50700.E12 ; v4(182.67,135.51) U50000.G33
FBB_D16: length 18.5
  L8 w0.109: v4(200.48,147.16) 200.39,147.25 198.06,147.25 194.71,143.9 186.02,143.9 185.59,143.48 185.06,143.48 v4(184.81,143.23)
  BOTTOM w0.17: U50000.E45 184.75,143.23 v4(184.81,143.23) ; v4(200.48,147.16) 200.86,146.78 U50700.V12
FBB_D17: length 20
  L3 w0.109: v4(185.46,143.87) 185.57,143.76 187.98,143.76 192.86,148.65 194.87,148.65 195.38,149.16 200.62,149.16 200.84,148.95 200.84,148.3 v4(201.23,147.91)
  BOTTOM w0.17: v4(201.23,147.91) U50700.U13 ; v4(185.46,143.87) 185.39,143.87 U50000.D45
FBB_D18: length 24.9
  L3 w0.109: v4(203.48,147.16) 203.11,147.53 203.11,148.81 202.16,149.76 195.21,149.76 194.72,149.27 192.57,149.27 187.93,144.63 185.67,144.63 184.78,143.74 184.21,143.74 v4(184.02,143.93)
  BOTTOM w0.17: v4(203.48,147.16) 203.86,146.78 U50700.P12 ; v4(184.02,143.93) 184.02,143.9 U50000.F45
FBB_D19: length 25.5
  L8 w0.109: v4(183.33,143.25) 183.88,143.58 184.25,143.58 184.9,143.85 185.69,144.63 194.64,144.63 198.29,148.29 198.3,148.28 205.34,148.28 205.72,147.91 v4(205.73,147.91)
  BOTTOM w0.17: v4(183.33,143.25) U50000.G45 ; v4(205.73,147.91) U50700.M13
FBB_D20: length 18.9
  L3 w0.109: v4(201.23,146.41) 200.81,145.98 195.67,145.98 194.53,144.84 192.03,144.84 189.15,141.96 186.47,141.96 186.3,141.79 185.74,141.79 v4(185.54,141.99)
  BOTTOM w0.17: v4(185.54,141.99) 185.1,141.55 U50000.D42 ; U50700.U12 v4(201.23,146.41)
FBB_D21: length 20.6
  L3 w0.109: v4(184.1,141.18) 184.35,141.43 189.82,141.43 192.52,144.13 194.82,144.13 196.01,145.33 201.59,145.33 201.94,145.68 v4(201.96,145.68)
  BOTTOM w0.17: v4(201.96,145.68) U50700.U11 ; v4(184.1,141.18) U50000.E42
FBB_D22: length 24.9
  L8 w0.109: v4(204.23,147.9) 203.85,147.53 202.5,147.53 202.36,147.39 202.36,146.98 202.16,146.78 198.32,146.78 194.87,143.33 193.16,143.33 193.12,143.37 185.99,143.37 185.45,142.83 183.81,142.83 183.66,142.69 183.43,141.83 v4(183.37,141.8)
  BOTTOM w0.17: U50000.F42 183.68,141.48 v4(183.37,141.8) ; v4(204.23,147.9) U50700.P13
FBB_D23: length 28.2
  L8 w0.109: v4(204.98,147.16) 204.61,146.78 204.61,146.16 204.69,146.08 204.69,145.54 204.38,145.23 200.98,145.23 200.18,146.03 198.47,146.03 194.98,142.53 187.12,142.53 187.03,142.62 185.9,142.62 185.67,142.4 184.82,142.4 184.06,141.63 184,141.63 183.72,141.36 182.3,141.36 182.12,141.19 v4(181.93,141.15)
  BOTTOM w0.17: U50000.H41 182.27,140.78 181.93,141.12 v4(181.93,141.15) ; U50700.N13 v4(204.98,147.16)
FBB_D24: length 18.8
  L8 w0.109: v4(184.74,140.47) 185.06,140.47 185.43,140.84 186.52,140.84 186.79,141.11 199.16,141.11 199.58,141.53 201.4,141.53 201.78,141.16 v4(201.98,141.16)
  BOTTOM w0.17: v4(184.74,140.47) 184.44,140.78 U50000.E41 ; U50700.U4 v4(201.98,141.16)
FBB_D25: length 25.5
  L10 w0.109: v4(184.06,139.71) 184.11,139.76 184.22,139.76 184.59,140.13 184.59,140.13 184.9,140.13 185.14,140.37 185.14,140.7 186.14,141.7 198.63,141.7 199.94,143.01 203.87,143.01 204.64,142.24 204.64,140.8 v4(204.25,140.41)
  BOTTOM w0.17: v4(204.25,140.41) 203.87,140.03 U50700.P3 ; U50000.F39 184.03,139.71 v4(184.06,139.71)
FBB_D26: length 22.3
  L10 w0.109: v4(184.76,139.04) 186.24,139.04 187.69,140.49 198.93,140.49 199.97,141.53 202.92,141.53 203.1,141.34 203.1,140.04 v4(203.48,139.66)
  BOTTOM w0.17: U50000.E39 184.41,139.38 v4(184.76,139.04) ; U50700.P2 203.86,139.28 v4(203.48,139.66)
FBB_D27: length 24.7
  L10 w0.109: v4(185.46,139.74) 185.5,139.69 186.23,139.69 186.47,139.92 186.47,141 186.56,141.09 198.7,141.09 200.03,142.42 203.6,142.42 203.86,142.16 203.86,141.76 203.86,141.75 203.86,139.3 v4(204.25,138.9)
  BOTTOM w0.17: v4(204.25,138.9) 204.61,139.26 U50700.N2 ; v4(185.46,139.74) U50000.D39
FBB_D28: length 29.4
  L10 w0.109: v4(204.96,139.67) 205.44,140.15 205.44,140.72 205.06,141.1 205.06,142.67 204.14,143.58 199.61,143.58 198.33,142.31 186.66,142.31 186.42,142.55 185.54,142.55 185.18,142.19 185.18,141.66 184.16,140.64 183.99,140.64 183.79,140.45 183.67,140.15 183.67,139.7 183.4,139.44 v4(183.4,138.98)
  BOTTOM w0.17: v4(204.96,139.67) 205.36,139.28 U50700.M2 ; v4(183.4,138.98) U50000.F38
FBB_D29: length 19.2
  L10 w0.109: v4(184.21,138.26) 184.57,138.62 186.67,138.62 187.94,139.89 199.11,139.89 200,140.78 200.61,140.78 200.98,140.41 v4(201.23,140.41)
  BOTTOM w0.17: v4(184.21,138.26) U50000.E38 ; v4(201.23,140.41) U50700.U3
FBB_D30: length 16.9
  L8 w0.109: v4(185.97,137.78) 186.03,137.78 187.67,139.42 200.25,139.42 v4(200.48,139.66)
  BOTTOM w0.17: v4(200.48,139.66) 200.86,140.03 U50700.V3 ; U50000.D36 185.28,137.28 185.78,137.78 v4(185.97,137.78)
FBB_D31: length 18.5
  L10 w0.109: v4(201.23,138.91) 200.1,138.91 199.75,139.25 188.06,139.25 186.18,137.37 185.03,137.37 v4(184.78,137.63)
  BOTTOM w0.17: U50700.U2 v4(201.23,138.91) ; v4(184.78,137.63) 184.43,137.28 U50000.E36
FBB_D32: length 32
  L3 w0.109: v4(179.06,147.41) 179.06,148.03 179.22,148.18 179.22,149.09 179.5,149.37 179.5,150.87 180.61,151.99 180.61,152.01 180.85,152.25 180.88,152.25 186.48,157.86 189.6,157.86 193.83,162.09 200.64,162.09 200.64,162.09 201.08,162.09 201.08,162.09 201.61,162.09 v4(201.98,161.71)
  BOTTOM w0.17: v4(179.06,147.41) U50000.M50 ; v4(201.98,161.71) U50800.B3
FBB_D33: length 33.7
  L3 w0.109: v4(200.48,162.46) 200.41,162.54 193.62,162.54 190.01,158.93 186.67,158.93 178.93,151.2 178.93,149.59 178.36,149.01 178.36,147.4 178.71,147.04 178.71,146.35 178.76,146.3 178.76,145.77 178.52,145.53 178.44,145.44 v4(178.45,145.33)
  BOTTOM w0.17: v4(178.45,145.33) 178.44,145.36 U50000.P48 ; U50800.A3 v4(200.48,162.46)
FBB_D34: length 32.5
  L8 w0.109: v4(179.86,148.14) 179.86,148.48 180.11,148.73 180.11,149.89 180.8,150.58 181.67,150.58 184.65,153.56 191.52,153.56 199.29,161.34 203.65,161.34 203.86,161.54 203.86,162.09 v4(204.23,162.46)
  BOTTOM w0.17: v4(204.23,162.46) U50800.E2 ; v4(179.86,148.14) U50000.M51
FBB_D35: length 31.3
  L3 w0.109: v4(179.78,146.73) 179.42,147.08 179.42,147.74 179.5,147.82 179.5,148.41 179.66,148.57 179.94,148.57 180.12,148.75 180.12,150.09 182.2,152.17 182.2,152.93 186.67,157.41 192.37,157.41 196.3,161.34 200.86,161.34 v4(201.23,160.96)
  BOTTOM w0.17: v4(179.78,146.73) U50000.M49 ; U50800.B4 v4(201.23,160.96)
FBB_D36: length 36.8
  L3 w0.109: v4(177.77,144.68) 178.1,145.02 178.1,145.68 178.02,145.77 178.02,146.86 177.97,146.9 177.97,149.12 178.34,149.49 178.34,151.25 187.37,160.27 190.72,160.27 194.03,163.59 201.61,163.59 v4(201.98,163.21)
  BOTTOM w0.17: v4(201.98,163.21) U50800.B2 ; U50000.P47 177.8,144.68 v4(177.77,144.68)
FBB_D37: length 37.3
  L3 w0.109: v4(204.98,163.21) 204.61,163.59 204.61,164.21 204.4,164.41 194.22,164.41 190.53,160.72 187.18,160.72 177.58,151.13 177.58,150.11 177.42,149.95 177.42,149.16 v4(177.58,149)
  BOTTOM w0.17: v4(204.98,163.21) U50800.F2 ; U50000.P52 v4(177.58,149)
FBB_D38: length 44.8
  L3 w0.109: v4(205.73,162.46) 205.36,162.84 205.36,163.06 205.36,163.37 205.36,163.37 205.36,164.21 204.7,164.86 194.03,164.86 190.34,161.18 186.99,161.18 177.13,151.32 177.13,148.93 177.54,148.52 177.54,147.28 177.31,147.05 177.31,145.72 177.38,145.65 177.38,144.31 177.1,144.03 v4(177.1,143.94)
  BOTTOM w0.17: v4(205.73,162.46) U50800.G2 ; v4(177.1,143.94) 177.1,144.03 177.35,144.28 U50000.R46
FBB_D39: length 37.4
  L8 w0.109: v4(203.48,161.71) 203.1,162.1 199.34,162.1 191.42,154.18 184.63,154.18 181.46,151.01 180.62,151.01 179.31,149.69 179.31,147.76 179.43,147.63 179.43,146.65 179.2,146.43 178.95,146.43 178.83,146.3 178.83,145.93 178.58,145.68 178.3,145.68 178.11,145.49 178.11,145.48 178.1,145.47 178.1,145.02 178.17,144.95 178.17,144.28 178.32,143.99 178.48,143.94 v4(178.48,143.93)
  BOTTOM w0.17: v4(203.48,161.71) U50800.E3 ; v4(178.48,143.93) 178.47,143.94 178.44,143.94 U50000.P46
FBB_D40: length 27.4
  L10 w0.109: v4(201.98,155.71) 201.61,156.09 195.39,156.09 190.8,151.51 184.23,151.51 182.65,149.92 182.65,148.86 182.34,148.56 180.96,148.56 180.75,148.35 180.75,147.43 180.75,147.42 180.75,147.36 v4(180.73,147.34)
  BOTTOM w0.17: v4(180.73,147.34) 180.61,147.22 U50000.L50 ; v4(201.98,155.71) U50800.B12
FBB_D41: length 30.8
  L10 w0.109: v4(203.48,155.71) 203.11,156.09 203.11,156.76 203.03,156.84 201.97,156.84 201.61,157.2 201.61,157.65 201.41,157.85 195.51,157.85 190.33,152.66 183.95,152.66 181.26,149.98 v4(180.76,149.98)
  BOTTOM w0.17: v4(203.48,155.71) U50800.E12 ; U50000.L51 180.2,147.91 181.14,148.85 181.14,149.65 180.81,149.98 v4(180.76,149.98)
FBB_D42: length 25.3
  L10 w0.109: v4(201.21,156.46) 200.82,156.85 195.22,156.85 190.53,152.16 184.13,152.16 181.16,149.19 180.75,149.19 v4(180.51,148.94)
  BOTTOM w0.17: v4(201.21,156.46) 201.58,156.09 U50800.B11 ; U50000.L52 180.2,148.63 v4(180.51,148.94)
FBB_D43: length 26.1
  L10 w0.109: v4(180.55,146.11) 180.55,146.11 180.6,146.16 180.61,146.16 180.88,146.3 181.47,146.3 181.61,146.44 181.61,147.28 181.6,147.29 181.6,147.57 181.61,147.58 181.61,147.7 181.72,147.81 182.29,147.81 183.06,148.59 183.06,149.02 183.85,149.81 183.85,150.17 184.51,150.83 191.08,150.83 195.55,155.3 200.06,155.3 v4(200.48,155.72)
  BOTTOM w0.17: v4(180.55,146.11) 180.54,146.11 180.53,146.11 U50000.L49 ; v4(200.48,155.72) U50800.A12
FBB_D44: length 37.9
  L10 w0.109: v4(179.87,143.92) 179.78,144.01 179.78,144.76 180.01,144.99 180.19,144.99 180.32,145.12 180.32,145.59 180.12,145.79 180.12,146.24 180.2,146.31 180.2,146.98 180.35,147.13 180.35,148.45 180.12,148.68 180.12,149.9 180.88,150.66 181.25,150.66 183.74,153.16 190.12,153.16 195.25,158.29 195.31,158.29 195.35,158.33 201.66,158.33 202.12,157.86 203.5,157.86 203.86,157.5 203.86,155.34 v4(204.23,154.96)
  BOTTOM w0.17: v4(179.87,143.92) 179.82,143.92 U50000.M46 ; v4(204.23,154.96) U50800.E13
FBB_D45: length 27.3
  L10 w0.109: v4(201.23,154.96) 200.86,154.59 196.14,154.59 191.7,150.15 184.87,150.15 184.48,149.76 184.48,148.94 184.14,148.59 183.9,148.59 182.3,147 182.3,146.86 182.31,146.85 182.31,146.57 182.3,146.56 182.3,145.79 181.96,145.45 181.96,145.21 181.66,144.91 180.76,144.91 v4(180.55,144.7)
  BOTTOM w0.17: v4(180.55,144.7) 180.51,144.74 180.44,144.74 U50000.L47 ; v4(201.23,154.96) U50800.B13
FBB_D46: length 37.9
  L10 w0.109: v4(179.18,146.07) 179.19,146.08 179.25,146.08 179.43,146.26 179.43,148.07 179.32,148.24 179.32,149.78 180.71,151.17 181.06,151.17 183.51,153.62 189.93,153.62 195.09,158.78 202.03,158.78 202.45,158.36 203.64,158.36 204.62,157.38 204.62,154.56 v4(204.98,154.19)
  BOTTOM w0.17: v4(179.18,146.07) 179.2,146.05 179.2,146 U50000.M48 ; v4(204.98,154.19) 204.61,154.56 U50800.F13
FBB_D47: length 41.2
  L10 w0.109: v4(179.23,144.66) 179.33,144.76 179.33,145.53 179.13,145.72 179.03,145.72 178.77,145.99 178.77,146.55 178.71,146.6 178.71,146.86 178.69,146.88 178.69,146.92 178.71,146.94 178.71,147.08 178.38,147.42 178.38,149.04 178.7,149.37 178.7,150.18 182.59,154.07 189.74,154.07 195.06,159.38 202.06,159.38 202.64,158.81 204.36,158.81 205.34,157.83 205.34,157.83 205.39,157.77 205.39,155.3 v4(205.73,154.96)
  BOTTOM w0.17: v4(205.73,154.96) U50800.G13 ; v4(179.23,144.66) U50000.M47
FBB_D48: length 39
  L10 w0.109: v1(214.3,155.73) 214.76,155.27 214.76,153.12 210.6,148.96 210.6,148.45 210.43,148.28 200.13,148.28 196.11,144.27 186.58,144.27 186.22,144.63 v4(184.77,144.63)
  BOTTOM w0.17: v1(214.3,155.73) 213.9,155.34 U50800.V12 ; U50000.D48 184.76,145.34 184.76,144.65 184.77,144.63 v4(184.77,144.63)
FBB_D49: length 29.3
  L10 w0.109: v4(186.18,147.4) 186.3,147.52 192.54,147.52 196.99,151.97 208.27,151.97 208.43,152.13 209.21,152.13 209.84,152.76 209.84,154.58 v4(210.23,154.96)
  BOTTOM w0.17: U50800.P12 v4(210.23,154.96) ; U50000.C50 186.12,147.4 v4(186.18,147.4)
FBB_D50: length 33.8
  L8 w0.109: v4(213.21,154.94) 213.75,154.4 213.75,152.81 211.87,150.93 203.67,150.93 203.38,151.21 197.33,151.21 193.59,147.48 190.63,147.48 188.31,146.47 188.01,146.33 186.45,146.33 v4(186.15,146.04)
  BOTTOM w0.17: U50800.U13 212.86,154.63 213.17,154.94 v4(213.21,154.94) ; v4(186.15,146.04) U50000.C48
FBB_D51: length 30
  L10 w0.109: v4(186.84,146.73) 187.45,146.12 193.9,146.12 199.28,151.5 209.23,151.5 210.64,152.9 210.64,153.87 v4(210.98,154.21)
  BOTTOM w0.17: v4(186.84,146.73) 186.15,146.73 U50000.C49 ; U50800.P13 v4(210.98,154.21)
FBB_D52: length 35.2
  L10 w0.109: v4(184.75,145.97) 185.19,146.41 186.37,146.41 187.17,145.6 194.12,145.6 199.56,151.05 208.39,151.05 208.79,150.64 209.68,150.64 212.11,153.07 212.11,155.34 v4(212.48,155.71)
  BOTTOM w0.17: U50800.U12 v4(212.48,155.71) ; U50000.E49 184.4,146.32 184.76,145.96 184.75,145.96 v4(184.75,145.97)
FBB_D53: length 28.9
  L10 w0.109: v4(209.48,154.21) 209.11,153.84 206.68,153.84 205.82,152.98 196.41,152.98 192.01,148.59 185.37,148.59 185.09,148.31 185.09,147.9 184.78,147.59 v4(184.78,147.43)
  BOTTOM w0.17: U50000.E50 184.75,147.43 v4(184.78,147.43) ; U50800.N13 v4(209.48,154.21)
FBB_D54: length 30.2
  L10 w0.109: v4(208.73,154.96) 208.36,154.59 206.67,154.59 205.88,153.79 196.01,153.79 191.66,149.44 185.92,149.44 185.32,148.84 185.25,148.84 185.25,148.84 184.8,148.84 183.64,147.68 183.64,147.13 v4(184.04,146.72)
  BOTTOM w0.17: v4(208.73,154.96) U50800.M13 ; v4(184.04,146.72) U50000.F49
FBB_D55: length 40.2
  L8 w0.109: v4(183.34,145.97) 183.74,145.57 186.34,145.57 186.77,146 188.48,146 189.82,146.35 193.51,146.35 197.17,150.02 200.97,150.02 200.97,150.01 201.31,150.01 201.31,150.02 203.07,150.02 203.09,150 203.43,150 203.45,150.02 204.97,150.02 205.3,150.35 207.96,150.35 208.03,150.42 212.06,150.42 214.73,153.09 214.73,156.02 214.59,156.16 213.53,156.16 v4(213.23,156.46)
  BOTTOM w0.17: v4(213.23,156.46) U50800.U11 ; v4(183.34,145.97) 183.41,145.97 U50000.F48
FBB_D56: length 37.5
  L8 w0.109: v4(183.26,147.37) 183.26,147.91 183.91,148.56 184.11,148.56 184.42,148.88 184.42,149.19 185.76,150.52 192.97,150.52 197.04,154.59 205.2,154.59 205.36,154.75 205.36,155.39 206.8,156.84 209.32,156.84 210.57,158.09 210.57,160.17 210.64,160.23 210.64,161.37 v4(210.98,161.71)
  BOTTOM w0.17: v4(210.98,161.71) U50800.P3 ; v4(183.26,147.37) U50000.F50
FBB_D57: length 36
  L3 w0.109: v4(186.05,149.02) 188.06,151.03 189.87,152.84 194.27,152.84 196.02,154.59 203.61,154.59 203.85,154.82 203.85,156.64 204.05,156.84 204.44,156.84 204.6,157 204.6,157.82 205.66,158.87 208.23,158.87 208.5,158.6 210.86,158.6 212.11,159.86 212.11,161.34 v4(212.48,161.71)
  BOTTOM w0.17: v4(212.48,161.71) U50800.U3 ; U50000.D52 185.64,149.02 v4(186.05,149.02)
FBB_D58: length 37
  L3 w0.109: v4(181.26,146.76) 181.24,146.78 181.24,146.94 181.58,147.28 181.58,147.37 181.58,147.37 181.58,147.66 181.58,147.66 181.58,147.68 181.71,147.81 182.12,147.81 182.64,148.33 182.64,149.68 183.53,150.58 183.71,150.58 184.78,151.65 185.09,151.65 188.27,154.82 192.75,154.82 196.87,158.94 203.19,158.94 203.88,159.64 203.88,160.42 204.07,160.61 204.46,160.61 204.61,160.75 204.61,161.12 204.83,161.34 206.64,161.34 206.86,161.56 206.86,161.87 207.08,162.09 208.36,162.09 v4(208.73,162.46)
  BOTTOM w0.17: v4(208.73,162.46) U50800.M2 ; U50000.J50 181.27,146.8 v4(181.26,146.76)
FBB_D59: length 43
  L3 w0.109: v4(213.23,162.46) 213.61,162.09 213.61,160.06 211.27,157.71 208.13,157.71 208.03,157.61 206.3,157.61 205.36,156.66 205.36,153.1 205.06,152.8 196.23,152.8 194.34,150.91 191.23,150.91 188.31,147.99 187.89,147.57 186.92,147.57 185.71,146.36 185.3,146.36 185.28,146.33 183.81,146.33 183.7,146.23 183.7,145.69 183.41,145.4 182.7,145.4 v4(182.67,145.42)
  BOTTOM w0.17: v4(213.23,162.46) U50800.V3 ; U50000.H48 182.55,145.43 182.61,145.43 182.61,145.42 v4(182.67,145.42)
FBB_D60: length 35.8
  L3 w0.109: v4(209.48,163.21) 209.11,162.84 209.11,162.62 209.11,162.62 209.11,162.31 209.11,161.87 209.11,161.87 209.11,161.56 208.9,161.35 207.79,161.35 207.61,161.18 207.61,160.76 207.45,160.59 205.41,160.59 203.27,158.45 197.25,158.45 193.16,154.37 188.63,154.37 185.38,151.11 184.92,151.11 183.83,150.03 183.83,149.83 183.52,149.52 v4(183.02,149.52)
  BOTTOM w0.17: v4(183.02,149.52) 183.02,148.5 U50000.H51 ; v4(209.48,163.21) U50800.N2
FBB_D61: length 39.5
  L8 w0.109: v4(210.23,162.46) 209.87,162.1 209.35,162.1 209.11,161.87 209.11,160.48 209.55,160.04 209.55,159.34 208.73,158.52 204.93,158.52 203.86,157.45 203.86,156.26 203.69,156.09 196.15,156.09 192.19,152.12 185.45,152.12 184.36,151.03 183.87,150.54 183.42,150.54 182.65,149.78 182.65,148.95 182.25,148.54 181.46,148.54 v4(181.13,148.21)
  BOTTOM w0.17: v4(210.23,162.46) U50800.P2 ; v4(181.13,148.21) U50000.J51
FBB_D62: length 40.8
  L3 w0.109: v4(213.23,160.96) 212.86,160.59 212.86,159.94 211.06,158.15 208.25,158.15 207.98,158.42 205.95,158.42 205.36,157.83 205.36,157.17 204.6,156.41 204.6,154.02 204.38,153.8 196.24,153.8 193.83,151.39 190.27,151.39 187.43,148.55 185.6,148.55 185.49,148.67 184.67,148.67 183.64,147.63 183.64,146.71 183.37,146.44 182.96,146.44 v4(182.66,146.74)
  BOTTOM w0.17: v4(213.23,160.96) U50800.U4 ; v4(182.66,146.74) 182.3,146.38 U50000.H49
FBB_D63: length 42.6
  L3 w0.109: v4(182,148.91) 181.82,149.09 181.82,149.47 182.82,150.48 182.92,150.48 187.71,155.27 192.55,155.27 196.67,159.4 203.18,159.4 203.56,159.77 203.56,160.63 203.85,160.91 203.85,161.86 204.09,162.1 206.02,162.1 206.11,162.19 206.11,163.39 206.3,163.59 208.96,163.59 209.12,163.75 209.12,164.3 209.27,164.44 210.13,164.44 210.52,164.83 212.34,164.83 212.86,164.31 212.86,163.59 v4(212.48,163.21)
  BOTTOM w0.17: v4(182,148.91) U50000.H52 ; v4(212.48,163.21) U50800.U2
FBB_DBI0: length 30.6
  L10 w0.109: v4(186.15,134.87) 186.41,135.12 186.98,135.12 188.11,136.25 199.08,136.25 199.56,135.78 209.43,135.78 210.97,137.32 211.48,137.32 212.11,137.95 212.11,139.05 211.73,139.43 v4(211.73,139.66)
  BOTTOM w0.17: U50000.C32 185.8,134.52 v4(186.15,134.87) ; v4(211.73,139.66) U50700.D2
FBB_DBI1: length 40.8
  L3 w0.109: v4(210.98,147.91) 211.36,147.53 212.62,147.53 212.86,147.3 212.86,145.34 213.04,145.16 213.04,143.82 212.12,142.9 212.12,139.35 212.06,139.28 206.24,139.28 205.49,138.53 197.48,138.53 195.04,136.09 186.85,136.09 186.03,135.26 185.1,135.26 184.76,134.92 v4(184.76,134.88)
  BOTTOM w0.17: v4(184.76,134.88) 184.74,134.89 U50000.E33 ; U50700.D13 211.36,147.53 v4(210.98,147.91)
FBB_DBI2: length 22.3
  L3 w0.109: v4(202.73,147.91) 202.36,147.53 202.36,146.94 202.2,146.78 194.77,146.78 193.56,145.57 191.73,145.57 188.79,142.62 185.54,142.62 185.28,142.37 184.28,142.37 v4(184.23,142.32)
  BOTTOM w0.17: U50700.R13 203.11,147.53 v4(202.73,147.91) ; U50000.E44 184.4,142.49 v4(184.23,142.32)
FBB_DBI3: length 23.8
  L8 w0.109: v4(182.68,139.66) 182.69,139.63 183.37,139.36 184.47,139.36 184.52,139.42 185.03,139.42 185.05,139.39 185.19,139.33 186.01,139.33 187.25,140.57 200.09,140.57 200.3,140.78 202.16,140.78 202.16,140.77 202.35,140.58 202.35,140.19 202.5,140.03 202.91,140.03 203.09,139.85 203.09,139.26 v4(202.74,138.91)
  BOTTOM w0.17: U50000.G39 182.96,139.38 v4(182.68,139.66) ; v4(202.74,138.91) 203.11,139.28 U50700.R2
FBB_DBI4: length 35.4
  L8 w0.109: v4(178.37,146.72) 178.37,148.37 178.26,148.48 178.26,150.15 180.44,152.33 181.3,152.33 184.09,155.12 190.86,155.12 199.33,163.59 203.11,163.59 v4(203.48,163.21)
  BOTTOM w0.17: v4(178.37,146.72) 178.39,146.72 178.38,146.72 U50000.P49 ; v4(203.48,163.21) U50800.D2
FBB_DBI5: length 29.2
  L8 w0.109: v4(203.48,154.18) 203.08,153.79 196.87,153.79 192.65,149.56 188.43,149.56 187.47,148.61 184.58,148.61 183.66,147.69 183.56,146.59 183.36,146.4 182.49,146.31 182.29,146.11 182.29,145.7 182.09,145.51 181.79,145.51 181.49,145.8 180.73,145.8 180.69,145.76 180.29,145.76 179.95,145.42 v4(179.95,145.35)
  BOTTOM w0.17: U50800.D13 203.48,154.22 v4(203.48,154.18) ; U50000.L48 180.2,145.67 179.95,145.42 v4(179.95,145.35)
FBB_DBI6: length 33.8
  L8 w0.109: v4(211.73,154.96) 212.11,154.59 212.66,154.59 212.85,154.4 212.85,153.88 212.91,153.82 212.91,153.23 212.58,152.91 211.93,152.91 211.34,152.31 210.11,152.31 209.33,151.52 204.02,151.52 203.6,151.94 196.97,151.94 193.1,148.07 190.01,148.07 188.3,147.27 186.75,147.27 186.6,147.13 v4(185.45,146.76)
  BOTTOM w0.17: v4(185.45,146.76) 185.42,146.76 U50000.D50 ; U50800.R13 v4(211.73,154.96)
FBB_DBI7: length 42.4
  L3 w0.109: v4(181.95,147.43) 182.63,147.43 183.5,148.3 183.85,148.3 184.65,149.09 184.65,149.35 185.02,149.73 185.85,149.73 187.15,151.03 189.54,153.42 193.88,153.42 195.8,155.34 202.9,155.34 203.11,155.55 203.11,157.35 203.42,157.65 203.75,157.65 205.39,159.29 208.27,159.29 208.51,159.54 208.89,159.54 209.04,159.39 209.54,159.39 209.79,159.64 211.14,159.64 211.35,159.86 211.35,161.86 211.58,162.09 211.93,162.09 212.11,162.27 212.11,162.31 212.11,162.31 212.11,162.62 212.11,162.62 212.11,163.05 212.11,163.06 212.11,163.37 212.11,163.38 212.11,163.43 211.95,163.59 211.36,163.59 v4(210.98,163.21)
  BOTTOM w0.17: v4(181.95,147.43) U50000.H50 ; v4(210.98,163.21) U50800.R2
FBB_DEBUG0: length 6.8
  BOTTOM w0.137: R50220.1 191.35,133.7 190.74,133.7 188.48,135.97 186.94,135.97 186.67,136.24 186.37,136.24 186.03,136.58 U50000.C35
FBB_DEBUG1: length 7.4
  TOP w0.102: v1(192.6,146.88) 192.22,147.26 R50221.1
  L10 w0.102: v1(188.12,146.81) 192.36,146.81 192.43,146.88 v1(192.6,146.88)
  BOTTOM w0.109: U50000.B50 186.84,147.43 187.51,147.43 v1(188.12,146.81)
FBB_EDC0: length 30.9
  L8 w0.109: v4(186.86,135.54) 187.67,136.35 206.24,136.35 206.47,136.12 207.56,136.12 209.1,137.66 209.1,139.89 209.24,140.03 211.98,140.03 212.11,139.91 212.11,139.28 v4(212.48,138.91)
  BOTTOM w0.17: v4(186.86,135.54) U50000.B33 ; U50700.C2 v4(212.48,138.91)
FBB_EDC1: length 34.7
  L3 w0.109: v4(184.71,136.3) 185.24,136.82 186.26,136.82 186.57,137.14 194.54,137.14 197.43,140.03 204.79,140.03 204.8,140.05 205.12,140.05 205.86,140.79 209.08,140.79 209.77,141.48 209.77,142.4 211.33,143.96 211.33,146.54 211.73,146.94 v4(211.73,147.16)
  BOTTOM w0.17: U50000.E35 184.43,136.58 184.71,136.3 184.71,136.3 v4(184.71,136.3) ; U50700.C13 212.11,147.53 v4(211.73,147.16)
FBB_EDC2: length 22.8
  L3 w0.109: v4(182.45,142.65) 182.53,142.68 182.69,142.83 185.08,142.83 185.51,143.27 188.31,143.27 191.37,146.33 193.47,146.33 194.67,147.53 201.6,147.53 v4(201.98,147.16)
  BOTTOM w0.17: U50700.T13 202.36,147.53 v4(201.98,147.16) ; v4(182.45,142.65) U50000.G44
FBB_EDC3: length 21.1
  L8 w0.109: v4(182.65,138.33) 183.29,138.59 183.94,138.59 184.06,138.64 186.09,138.64 187.37,139.93 194.92,139.93 195.03,140.03 201.61,140.03 v4(201.98,139.66)
  BOTTOM w0.17: v4(201.98,139.66) 202.36,139.28 U50700.T2 ; v4(182.65,138.33) U50000.H38
FBB_EDC4: length 33.1
  L8 w0.109: v4(202.73,162.46) 202.36,162.84 199.27,162.84 191.07,154.63 184.44,154.63 181.22,151.41 180.26,151.41 178.75,149.9 v4(178.75,148.88)
  BOTTOM w0.17: U50000.P50 178.44,147.42 178.44,147.92 178.41,147.95 178.41,148.31 178.44,148.34 178.44,148.56 v4(178.75,148.88) ; v4(202.73,162.46) U50800.C2
FBB_EDC5: length 27.4
  L8 w0.109: v4(181.89,145.97) 181.62,146.24 181.62,146.85 181.82,147.06 182.11,147.06 182.11,147.05 182.33,147.05 182.74,147.46 182.74,148.11 183.1,148.47 183.1,149.02 183.53,149.45 183.76,149.45 185.33,151.03 185.65,151.35 193.16,151.35 197.15,155.34 202.36,155.34 v4(202.73,154.96)
  BOTTOM w0.17: v4(202.73,154.96) U50800.C13 ; v4(181.89,145.97) U50000.J48
FBB_EDC6: length 31.7
  L8 w0.109: v4(185.46,148.17) 185.75,147.88 186.62,147.72 187.86,147.72 188.31,148.01 189.53,148.81 192.58,148.81 196.49,152.72 204.04,152.72 204.75,152.01 209.11,152.01 209.94,152.85 211.06,152.85 211.36,153.14 211.36,153.65 211.54,153.84 212.11,153.84 v4(212.48,154.21)
  BOTTOM w0.17: v4(185.46,148.17) 185.46,148.14 U50000.D51 ; U50800.T13 v4(212.48,154.21)
FBB_EDC7: length 36.9
  L3 w0.109: v4(211.73,162.46) 211.36,162.84 210.81,162.84 210.61,162.63 210.61,160.72 210.37,160.48 209.18,160.48 208.91,160.22 207.94,160.22 207.4,159.68 205.1,159.68 203.41,157.99 197.59,157.99 193.48,153.88 189.24,153.88 185.71,150.34 184.97,150.34 184.24,149.62 184.24,149.24 v4(183.98,148.97)
  BOTTOM w0.17: U50000.F51 184.04,148.12 184.04,148.92 v4(183.98,148.97) ; v4(211.73,162.46) U50800.T2
FBB_WCK01: length 37.6
  L10 w0.097: v4(181.24,135.52) 181.85,135.15 182.12,135.15 182.35,134.91 182.99,134.91 183.69,135.61 183.69,136.23 183.87,136.41 184.24,136.41 184.61,136.78 186.37,136.78 188.05,138.45 199.28,138.45 200.28,137.45 205.14,137.45 206.05,138.36 206.05,141.37 206.22,141.54 211.12,141.54 211.36,141.3 211.59,141.3 v4(211.73,141.16)
  BOTTOM w0.122: v4(181.24,135.52) U50000.J33 ; v4(211.73,141.16) U50700.D4
FBB_WCK01#: length 37.6
  L10 w0.097: v4(181.95,135.53) 182.11,135.37 182.21,135.37 182.44,135.14 182.89,135.14 183.46,135.71 183.46,136.32 183.78,136.64 184.15,136.64 184.51,137 186.28,137 187.95,138.68 199.37,138.68 200.38,137.67 205.05,137.67 205.83,138.46 205.83,141.47 206.13,141.77 211.21,141.77 211.45,141.52 211.85,141.52 211.95,141.62 211.95,141.76 211.8,141.9 v4(211.73,141.9)
  BOTTOM w0.122: U50000.H33 182.07,135.18 181.95,135.3 v4(181.95,135.53) ; v4(211.73,141.9) 211.36,141.53 U50700.D5
FBB_WCK23: length 26.9
  L3 w0.097: v4(203.47,145.68) 203.47,145.57 202.83,144.92 202.83,144.57 202.57,144.31 196.35,144.31 192.79,140.74 186.46,140.74 186.16,141.05 184.48,141.05 184.25,140.82 183.87,140.82 183.49,141.2 182.56,141.2 182.17,140.81 181.6,140.81 181.33,140.54 181.33,139.88 181.33,139.74 v4(181.28,139.69)
  BOTTOM w0.122: v4(203.47,145.68) 203.12,146.03 U50700.R11 ; v4(181.28,139.69) U50000.J39
FBB_WCK23#: length 27
  L3 w0.097: v4(181.98,139.7) 181.85,139.7 181.56,139.99 181.56,140.45 181.69,140.59 182.26,140.59 182.66,140.98 183.4,140.98 183.78,140.6 184.34,140.6 184.57,140.82 186.07,140.82 186.37,140.52 192.88,140.52 196.44,144.08 202.66,144.08 203.05,144.47 203.05,144.83 203.17,144.95 203.37,144.95 203.5,144.82 v4(203.5,144.7)
  BOTTOM w0.122: v4(181.98,139.7) U50000.H39 ; U50700.R10 203.11,145.09 v4(203.5,144.7)
FBB_WCK45: length 34.9
  L3 w0.097: v4(180.53,143.92) 180.5,143.92 179.36,145.07 179.36,145.59 179.92,146.16 179.92,146.34 180.14,146.55 180.14,147.8 180.44,148.1 180.44,148.33 181.07,148.97 181.07,149.73 187.44,156.1 187.86,156.1 188.37,156.61 192.65,156.61 196.62,160.59 202.84,160.59 202.93,160.68 202.93,160.87 202.83,160.97 v4(202.73,160.97)
  BOTTOM w0.122: v4(202.73,160.97) U50800.D4 ; v4(180.53,143.92) 180.5,143.93 U50000.L46
FBB_WCK45#: length 34.9
  L3 w0.097: v4(202.7,160.22) 202.55,160.37 196.72,160.37 192.74,156.39 188.46,156.39 187.95,155.88 187.53,155.88 181.3,149.64 181.3,148.88 180.66,148.24 180.66,148 180.36,147.71 180.36,146.46 180.14,146.24 180.14,146.06 179.58,145.5 179.58,145.16 180.45,144.29 180.61,144.29 180.73,144.24 180.91,144.06 180.91,143.78 v4(180.57,143.24)
  BOTTOM w0.122: v4(202.7,160.22) 203.07,160.59 U50800.D5 ; v4(180.57,143.24) U50000.L45
FBB_WCK67: length 43.8
  L10 w0.097: v4(210.98,156.46) 211.13,156.61 211.13,156.79 211.41,157.07 213.51,157.07 213.91,156.67 213.91,156.14 213.89,156.14 213.89,155.33 213.91,155.33 213.9,153.34 213.9,153.07 210.05,149.23 205.07,149.23 204.81,149.49 199.86,149.49 195.2,144.82 186.71,144.82 186.22,145.31 183.42,145.31 182.76,144.66 v4(182.76,144.46)
  BOTTOM w0.122: v4(210.98,156.46) U50800.R11 ; v4(182.76,144.46) 182.75,144.48 182.72,144.48 U50000.H47
FBB_WCK67#: length 43.7
  L10 w0.097: v4(211.74,156.45) 211.46,156.45 211.35,156.56 211.35,156.7 211.5,156.85 213.42,156.85 213.68,156.58 213.68,156.36 213.67,156.36 213.67,155.11 213.68,155.11 213.68,153.19 213.68,153.17 209.96,149.45 205.16,149.45 204.9,149.71 199.77,149.71 195.11,145.05 186.8,145.05 186.31,145.54 183.32,145.54 182.64,144.86 182.6,144.86 182.39,144.65 182.39,143.94 v4(182.45,143.88)
  BOTTOM w0.122: v4(182.45,143.88) 182.43,143.89 U50000.H46 ; v4(211.74,156.45) U50800.R10
FBB_WCKB01: length 38.1
  L8 w0.097: v4(182.72,136.26) 182.87,136.41 182.99,136.41 183.17,136.23 183.63,136.23 183.81,136.41 184.27,136.41 184.55,136.69 186.6,136.69 187.72,137.81 192.31,137.81 192.76,137.36 205.03,137.36 205.58,137.92 205.58,140.8 206.33,141.55 208.97,141.55 209.27,141.84 209.27,142.67 210.66,144.06 211.83,144.06 212.32,144.55 212.32,145.14 212.1,145.36 212.02,145.36 v4(211.73,145.66)
  BOTTOM w0.122: v4(211.73,145.66) U50700.D11 ; U50000.G35 183,136.54 182.73,136.26 182.72,136.26 v4(182.72,136.26)
FBB_WCKB01#: length 38.1
  L8 w0.097: v4(182,136.28) 182.62,136.63 183.09,136.63 183.27,136.45 183.53,136.45 183.72,136.64 184.18,136.64 184.45,136.91 186.5,136.91 187.63,138.04 192.4,138.04 192.85,137.58 204.93,137.58 205.36,138.01 205.36,140.89 206.24,141.77 208.88,141.77 209.05,141.94 209.05,142.77 210.57,144.28 211.74,144.28 212.1,144.65 212.1,145.04 212,145.14 211.86,145.14 211.73,145.01 v4(211.73,144.91)
  BOTTOM w0.122: U50700.D10 v4(211.73,144.91) ; v4(182,136.28) U50000.H35
FBB_WCKB23: length 24.1
  L8 w0.097: v4(183.38,140.46) 183.38,140.46 183.32,140.4 183.15,140.4 183.04,140.5 183.04,140.74 183.16,140.86 183.54,140.86 183.78,140.62 184.37,140.62 185.06,141.31 186.29,141.31 186.66,141.68 197.85,141.68 198.94,142.77 202.39,142.77 202.9,142.27 202.9,141.74 v4(203.48,141.16)
  BOTTOM w0.122: v4(203.48,141.16) 203.29,140.96 203.29,140.96 U50700.R4 ; v4(183.38,140.46) U50000.F41
FBB_WCKB23#: length 24.1
  L8 w0.097: v4(182.67,140.45) 182.82,140.6 182.82,140.84 183.07,141.08 183.63,141.08 183.87,140.84 184.28,140.84 184.97,141.53 186.19,141.53 186.57,141.91 197.76,141.91 198.84,142.99 202.49,142.99 203.12,142.36 203.12,141.83 203.18,141.78 203.35,141.78 v4(203.49,141.91)
  BOTTOM w0.122: U50700.R5 v4(203.49,141.91) ; v4(182.67,140.45) U50000.G41
FBB_WCKB45: length 33.8
  L8 w0.097: v4(179.16,142.51) 179.19,142.51 179.19,142.51 179.21,142.55 179.22,142.55 179.57,143.14 179.57,143.37 179.53,143.41 179.53,144.06 179.85,144.38 179.85,144.9 179.54,145.2 179.54,145.58 180.15,146.19 180.15,146.27 180.36,146.48 180.36,147.6 180.69,147.93 180.69,148.29 181.19,148.79 181.19,149.38 181.77,149.97 182.16,149.97 184.97,152.79 192.07,152.79 196.11,156.83 202.37,156.83 v4(202.73,156.46)
  BOTTOM w0.122: U50000.M44 v4(179.16,142.51) ; v4(202.73,156.46) U50800.D11
FBB_WCKB45#: length 33.8
  L8 w0.097: v4(179.16,143.27) 179.19,143.27 179.31,143.39 179.31,144.15 179.62,144.47 179.62,144.81 179.32,145.11 179.32,145.68 179.93,146.28 179.93,146.36 180.14,146.57 180.14,147.7 180.47,148.03 180.47,148.38 180.97,148.88 180.97,149.48 181.68,150.19 182.06,150.19 184.88,153.01 191.98,153.01 196.02,157.05 202.54,157.05 v4(202.74,157.25)
  BOTTOM w0.122: U50000.M45 179.5,143.72 179.4,143.81 179.26,143.81 179.14,143.69 179.14,143.29 v4(179.16,143.27) ; v4(202.74,157.25) U50800.D10
FBB_WCKB67: length 49.5
  L8 w0.097: v4(181.32,145.3) 181.57,145.05 182.87,145.05 183.11,145.29 187.08,145.29 187.21,145.42 194.16,145.42 198.17,149.43 212.32,149.43 215.35,152.47 215.35,156.92 213.32,158.95 211.96,158.95 211.13,159.78 211.13,160.37 v4(211.73,160.96)
  BOTTOM w0.122: U50800.R4 v4(211.73,160.96) ; U50000.J47 181.32,145.3 v4(181.32,145.3)
FBB_WCKB67#: length 49.5
  L8 w0.097: v4(211.72,160.17) 211.73,160.24 211.63,160.34 211.42,160.34 211.35,160.27 211.35,159.88 212.05,159.17 213.41,159.17 215.57,157.01 215.57,152.37 212.41,149.21 198.26,149.21 194.25,145.2 187.3,145.2 187.17,145.07 183.2,145.07 182.96,144.83 181.57,144.83 181.55,144.83 v4(181.26,144.53)
  BOTTOM w0.122: U50800.R5 211.36,160.54 v4(211.72,160.17) ; v4(181.26,144.53) U50000.J46
FBB_ZQ_1_A: length 1.3
  TOP w0.25: R50700.1 208.08,149.22 208.08,148.79 v4(208.02,148.73)
  BOTTOM w0.2: U50700.J14 207.61,148.32 v4(208.02,148.73)
FBB_ZQ_1_B: length 1.4
  TOP w0.25: R50701.1 207.23,149.21 v4(207.23,148.66)
  BOTTOM w0.2: U50700.K14 207.05,148.48 v4(207.23,148.66)
FBB_ZQ_2_A: length 2.2
  TOP w0.203: v4(207.18,153.4) 207.11,153.32 207.11,152.4 207.43,152.08 R50800.1
  BOTTOM w0.3: v4(207.18,153.4) 206.86,153.72 U50800.J14
FBB_ZQ_2_B: length 2.1
  TOP w0.203: R50801.1 208.05,152.22 208.05,153.4 v4(207.98,153.46)
  BOTTOM w0.3: v4(207.98,153.46) U50800.K14
FBC1_VREFC: length 1.6
  TOP w0.3: R50910.2 207.23,99.08 206.82,99.48 v4(206.8,99.48)
  BOTTOM w0.3: U50900.K1 206.51,99.77 v4(206.8,99.48)
FBC2_VREFC: length 1.4
  TOP w0.381: v4(207.05,125.54) 206.9,125.69 R51010.2
  BOTTOM w0.3: v4(207.05,125.54) 207.26,125.34 U51000.K1
FBC_CLK0: length 35.8
  L10 w0.097: v4(182.7,122.9) 183.18,122.56 183.55,122.56 183.75,122.36 184.42,122.36 184.73,122.68 185.2,122.68 185.28,122.6 187.55,122.6 192.82,117.32 192.82,114.11 196.57,110.37 196.57,109.9 199.98,106.49 201.89,106.49 201.92,106.45 204.84,106.45 205.57,105.72 207.25,105.72 207.48,105.95 207.48,106.17 v4(207.63,106.32)
  BOTTOM w0.122: U50900.J10 v4(207.63,106.32) ; v4(182.7,122.9) 182.7,122.9 U50000.G15
FBC_CLK0#: length 35.7
  L10 w0.097: v4(206.88,106.32) 207.16,106.32 207.25,106.22 207.25,106.04 207.16,105.95 205.66,105.95 204.93,106.68 202.02,106.68 201.98,106.71 200.08,106.71 196.79,109.99 196.79,110.46 193.05,114.21 193.05,117.41 187.64,122.82 185.38,122.82 185.29,122.9 184.64,122.9 184.32,122.59 183.84,122.59 183.75,122.68 183.75,123.15 183.65,123.24 183.43,123.24 183.28,123.1 v4(183.28,122.97)
  BOTTOM w0.122: v4(183.28,122.97) 183.29,122.97 U50000.F15 ; U50900.K10 v4(206.88,106.32)
FBC_CLK1: length 36
  L3 w0.089: 185.08,125.81 185.06,125.81 185.06,125.81 184.59,125.81 184.19,125.41 183.64,125.41 183.59,125.46 182.9,125.46 182.86,125.49 182.23,125.49 181.6,126.12 181.6,126.81 181.61,126.82 181.61,126.94 181.63,126.96 181.63,127.12 181.72,127.21 v4(181.89,127.21)
  L3 w0.097: 185.08,125.81 185.1,125.83 186.88,125.83 188.28,125.4 188.29,125.4 190.08,124.85 200.52,114.41 204.76,114.41 205.78,115.42 205.78,116.56 205.47,116.87 205.47,117.37 206.48,118.39 206.48,118.53 206.39,118.62 v4(206.13,118.62)
  BOTTOM w0.102: v4(181.89,127.21) 182.3,126.8 U50000.H21
  BOTTOM w0.122: v4(206.13,118.62) U51000.J10
FBC_CLK1#: length 36.1
  L3 w0.089: 181.41,126.9 181.41,126.04 182.15,125.3 182.79,125.3 182.82,125.27 183.51,125.27 183.56,125.22 184.26,125.22 184.67,125.62 185.08,125.62 185.08,125.62
  L3 w0.097: 181.41,126.9 v4(181.24,127.07) ; 185.08,125.62 185.09,125.61 186.85,125.61 188.22,125.19 188.27,125.17 189.96,124.65 200.42,114.18 204.85,114.18 206,115.33 206,116.66 205.69,116.96 205.69,117.28 206.71,118.3 206.71,118.46 v4(206.88,118.63)
  BOTTOM w0.102: v4(181.24,127.07) 181.53,126.78 U50000.J21
  BOTTOM w0.122: U51000.K10 v4(206.88,118.63)
FBC_CMD0: length 39.8
  BOTTOM w0.137: U50900.H3 207.65,100.8 207.65,99.29 207.26,98.1 206.15,96.98 204.87,96.47 203.17,96.47 199.97,97.64 197.74,99.86 190.02,109.4 189.32,110.27 189.32,117.55 187.65,119.22 186.97,119.22 186.75,119.43 186.15,119.43 U50000.C11
FBC_CMD1: length 39.4
  L10 w0.086: v1(206.89,98.35) 206.89,98.36 207.26,99.27 207.26,100.38 v4(206.88,101.06)
  BOTTOM w0.109: U50900.J3 v4(206.88,101.06) U50900.K3
  BOTTOM w0.137: v1(206.89,98.35) 205.86,97.32 204.87,96.88 203.27,96.88 202.57,97.09 200.17,97.96 198.28,99.86 197.81,100.43 197.81,102.34 191.04,109.11 191.04,109.57 189.68,110.93 189.68,117.61 187.84,119.46 187.06,119.46 186.74,119.78 U50000.B11
