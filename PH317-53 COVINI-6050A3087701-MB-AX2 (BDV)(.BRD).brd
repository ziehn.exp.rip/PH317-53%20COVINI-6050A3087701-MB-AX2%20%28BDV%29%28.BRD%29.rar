# Allegro board PH317-53 COVINI-6050A3087701-MB-AX2 (BDV)(.BRD).brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
FBC_WCKB67#: length 46.7
  L10 w0.097: v4(211.37,121.59) 211.37,121.63 211.27,121.73 211.09,121.73 211,121.63 211,121.11 211,120.95 209.88,119.84 206.33,119.84 206.13,119.64 206.13,119.15 205.76,118.78 205.76,118.37 206.03,118.09 206.03,117.59 205.62,117.18 205.62,117.01 206.16,116.47 206.16,115.41 205.84,115.1 205.55,114.8 205.45,114.8 204.92,114.27 204.47,114.27 203.62,113.42 199.66,113.42 196.9,116.18 196.9,119.08 188.67,127.31 187.17,127.31 186.54,127.94 185.28,127.94 184.94,128.28 184.54,128.28 184.25,127.99 183.75,127.99 183.35,128.39 181.93,128.39 181.48,128.84 181.48,128.99 v4(181.29,129.18)
  BOTTOM w0.122: v4(181.29,129.18) U50000.J24 ; v4(211.37,121.59) 211.01,121.94 U51000.R5
FBC_ZQ_1_A: length 1.4
  TOP w0.225: v4(207.67,110.14) 207.16,110.64 R50900.1
  BOTTOM w0.102: U50900.J14 207.26,109.73 v4(207.67,110.14)
FBC_ZQ_1_B: length 1.4
  TOP w0.225: v4(206.88,110.06) 206.4,110.55 R50901.1
  BOTTOM w0.102: U50900.K14 v4(206.88,110.06)
FBC_ZQ_2_A: length 2.1
  TOP w0.3: v4(206.87,114.84) 206.84,114.82 206.84,113.96 207.08,113.72 R51000.1
  BOTTOM w0.3: U51000.J14 206.87,114.88 v4(206.87,114.84)
FBC_ZQ_2_B: length 2.1
  TOP w0.3: v4(207.63,114.87) 207.85,114.65 207.85,113.47 R51001.1
  BOTTOM w0.3: U51000.K14 v4(207.63,114.87)
FBD1_VREFC: length 1.3
  TOP w0.254: R51110.2 166.58,92.82 v4(166.93,93.18)
  BOTTOM w0.3: v4(166.93,93.18) 167.1,93.18 U51100.K1
FBD2_VREFC: length 1.3
  TOP w0.25: v4(192.12,92.31) 192.25,92.18 R51210.2
  BOTTOM w0.3: U51200.K1 191.96,92.43 192,92.43 v4(192.12,92.31)
FBD_CLK0: length 28.6
  L10 w0.097: v4(174.19,117.99) 174.19,117.71 173.83,117.35 173.83,116.49 173.84,116.47 173.84,114.9 173.74,114.79 173.74,114.03 174.36,113.41 174.36,112.69 175.13,111.91 175.13,100.71 173.96,99.54 173.96,94.97 173.12,94.13 173.12,92.79 173.37,92.55 173.56,92.55 v4(173.77,92.35)
  BOTTOM w0.122: v4(173.77,92.35) U51100.J10 ; v4(174.19,117.99) U50000.Y8
FBD_CLK0#: length 28.6
  L10 w0.097: v4(173.77,93.1) 173.77,92.87 173.67,92.77 173.46,92.77 173.35,92.89 173.35,94.03 174.19,94.88 174.19,99.45 175.36,100.62 175.36,112 174.58,112.78 174.58,113.5 173.96,114.12 173.96,114.7 174.06,114.8 174.06,116.56 174.05,116.58 174.05,117.18 174.15,117.27 v4(174.29,117.27)
  BOTTOM w0.122: U50000.Y7 173.7,116.98 173.58,117.1 173.58,117.27 173.65,117.33 174.23,117.33 v4(174.29,117.27) ; v4(173.77,93.1) U51100.K10
FBD_CLK1: length 32.2
  L3 w0.097: v4(177.08,118) 177.13,118 177.63,117.5 177.63,117.5 177.69,117.44 177.69,117.1 176.47,115.88 176.47,115 176.04,114.58 176.04,113.89 176.84,113.1 176.84,110.36 177.99,105.82 180.45,103.36 180.45,98.39 181.14,97.69 181.14,95.1 181.28,94.96 181.28,94.16 181.58,93.86 182.14,93.86 182.39,94.1 182.84,94.1 183.08,93.86 184.66,93.86 184.95,93.56 185.09,93.56 v4(185.32,93.79)
  BOTTOM w0.122: v4(177.08,118) 177.13,118 U50000.R8 ; U51200.J10 v4(185.32,93.79)
FBD_CLK1#: length 32.2
  L3 w0.097: v4(177.05,117.33) 177.23,117.51 177.3,117.51 177.47,117.35 177.47,117.19 176.24,115.97 176.24,115.1 175.82,114.67 175.82,113.8 176.61,113.01 176.61,110.33 177.79,105.71 180.22,103.27 180.22,98.29 180.92,97.6 180.92,95 181.06,94.87 181.06,94.06 181.49,93.63 182.24,93.63 182.48,93.88 182.74,93.88 182.99,93.63 184.56,93.63 184.86,93.34 185.07,93.34 v4(185.31,93.1)
  BOTTOM w0.122: v4(177.05,117.33) U50000.R7 ; U51200.K10 v4(185.31,93.1)
FBD_CMD0: length 27.6
  L8 w0.086: v4(169.26,92.35) 168.63,92.72 167,92.72 v1(165.7,93.11)
  BOTTOM w0.137: v1(165.7,93.11) 163.93,94.88 163.93,97.68 165.02,100.99 165.08,101.17 165.1,101.21 169.51,109.4 169.56,109.5 171.09,111.03 171.09,112.33 170.77,112.64 170.77,112.91 171.1,113.24 U50000.AD2 ; U51100.H3 169.26,92.34 v4(169.26,92.35)
FBD_CMD1: length 25.8
  L8 w0.086: v1(165.73,94.31) 166.82,93.56 167.1,93.56 167.66,93.47 167.87,93.47 v4(168.51,93.09)
  BOTTOM w0.109: U51100.J3 v4(168.51,93.09) U51100.K3
  BOTTOM w0.137: U50000.AD1 171.1,112.66 171.33,112.43 171.33,110.73 169.87,109.27 167.2,104.32 167.2,102.67 165.37,100.83 165.02,99.78 164.32,97.66 164.32,95.29 165.3,94.31 v1(165.73,94.31)
FBD_CMD2_RST: length 26.5
  BOTTOM w0.137: U50000.AD4 171.45,114.53 171.45,112.68 171.48,112.65 171.48,112.65 171.6,112.52 171.6,110.46 170.18,109.04 167.97,104.94 167.97,102.9 165.7,100.63 165.35,99.58 165.35,96.27 R51106.1 164.79,95.58 165.53,94.85 166.05,94.85 166.44,94.46 166.44,92.99 166.7,92.74 167.36,92.74 U51100.J1
FBD_CMD3: length 26
  L8 w0.086: v4(170.01,93.09) 168.61,94.49 167.13,94.49 166.25,95.37 v1(165.71,95.37)
  BOTTOM w0.109: U51100.J4 v4(170.01,93.09) 169.63,93.46 U51100.K4
  BOTTOM w0.137: v1(165.71,95.37) 166.23,95.89 166.23,100.6 169.01,103.38 169.01,106.07 170.48,108.81 171.85,110.18 171.85,112.73 U50000.AC1
FBD_CMD4: length 23.3
  BOTTOM w0.137: U51100.L3 168.51,94.59 167.1,94.59 166.62,95.07 166.62,100.44 170.1,103.92 170.1,107.3 170.79,108.58 171.45,109.24 171.45,109.44 172.12,110.11 172.12,112.94 171.8,113.27 U50000.AC2
FBD_CMD5: length 21.4
  BOTTOM w0.137: U51100.M4 170,95.33 170.93,95.33 171.26,95.66 171.26,99.96 170.94,100.28 170.94,108.06 171.02,108.21 171.83,109.02 171.83,109.48 172.38,110.03 172.38,112 172.39,112 172.39,113.04 172.15,113.28 172.15,113.62 171.8,113.97 U50000.AC3
FBD_CMD6: length 23.2
  BOTTOM w0.109: U51100.J5 170.7,93.03 170.7,93.15 U51100.K5
  BOTTOM w0.137: 170.7,93.15 170.87,93.32 170.87,93.58 171.41,94.12 171.41,94.66 171.55,94.8 171.55,100.07 171.42,100.19 171.42,108.08 172.21,108.86 172.21,109.52 172.63,109.94 172.63,113.11 172.85,113.33 172.85,113.62 173.2,113.97 U50000.AA3
FBD_CMD7: length 25.5
  L8 w0.076: v4(170.99,94.4) 171.31,94.08 v4(171.31,93.12) 171.27,93.09 171.04,92.07 v4(171.04,91.61)
  BOTTOM w0.109: U51100.H5 v4(171.04,91.61) ; v4(170.99,94.4) U51100.L5
  BOTTOM w0.137: v4(171.31,93.12) 171.72,93.53 171.72,94.35 171.8,94.43 171.8,107.85 172.58,108.63 172.58,109.56 172.86,109.84 172.86,112.94 173.2,113.27 U50000.AA2
FBD_CMD8: length 24.4
  BOTTOM w0.137: U50000.AA1 173.2,109.74 172.96,109.51 172.96,108.48 172.18,107.69 172.18,100.19 172.04,100.06 172.04,94.08 171.99,94.03 171.99,92.9 171.51,92.42 171.51,91.28 171.07,90.84 170.01,90.84 U51100.G4
FBD_CMD9: length 27.1
  BOTTOM w0.137: U51100.G11 174.51,90.84 172.96,90.84 172.67,91.13 172.67,92.39 172.26,92.8 172.26,93.78 172.36,93.89 172.36,100 172.56,100.19 172.56,106.42 173.34,107.21 173.34,109.49 173.55,109.71 173.55,114.4 173.2,114.75 U50000.AA4
FBD_CMD10_CKE: length 26.5
  TOP w0.137: R51105.1 172.66,93.38 172.68,93.37 v4(172.68,93.21)
  L8 w0.076: v4(173.62,91.38) v4(172.68,93.21) v4(173.53,95.12)
  BOTTOM w0.109: U51100.M10 v4(173.53,95.12) ; v4(173.62,91.38) 173.79,91.21 U51100.G10
  BOTTOM w0.137: U50000.Y1 173.9,109.64 173.72,109.46 173.72,107.05 172.95,106.28 172.95,100 172.68,99.74 172.68,93.77 172.54,93.63 172.54,93.36 v4(172.68,93.21)
FBD_CMD11: length 25
  BOTTOM w0.109: U51100.L10 173.6,94.21 173.35,93.97 173.35,93.18 173.19,93.01 173.34,92.86 173.34,92.22 173.7,91.86 174.03,91.86 U51100.H10
  BOTTOM w0.137: U50000.Y2 173.9,113.29 174.25,112.94 174.25,109.58 174.11,109.44 174.11,103.55 173.58,103.03 173.58,100.2 172.94,99.56 172.94,95.01 173.04,94.91 173.04,93.52 173.04,93.16 173.19,93.01
FBD_CMD12: length 21.5
  BOTTOM w0.137: U50000.Y3 173.9,114.01 174.25,113.66 174.25,113.28 174.47,113.06 174.47,113.05 174.48,113.04 174.48,103.09 174.88,102.7 174.88,101.07 173.18,99.38 173.18,95.88 173.45,95.62 173.69,95.62 173.97,95.34 174.51,95.34 U51100.M11
FBD_CMD13: length 25.1
  L3 w0.086: v4(177.54,93.87) 177.23,94.19 175.57,94.19 v4(175.26,93.88)
  BOTTOM w0.137: v4(177.54,93.87) 177.97,94.3 177.97,100.1 175.49,102.59 175.49,103.81 174.86,104.44 174.86,111.2 174.74,111.33 174.74,113.14 174.94,113.34 174.94,113.62 175.3,113.97 U50000.V3 ; U51100.L12 175.59,94.21 v4(175.26,93.88)
FBD_CMD14: length 28.2
  L8 w0.086: v4(174.56,93.09) 174.97,93.5 176.97,93.5 177.15,93.32 177.15,92.84 177.28,92.72 v1(178.56,92.72)
  BOTTOM w0.109: U51100.K11 174.56,93.14 v4(174.56,93.09) 174.56,93.04 U51100.J11
  BOTTOM w0.137: v1(178.56,92.72) 178.37,92.9 178.37,100.14 178.2,100.31 178.2,101.8 175.24,104.77 175.24,111.29 174.98,111.56 174.98,113 175.3,113.33 U50000.V2
FBD_CMD15: length 27.8
  L8 w0.086: v4(176.01,93.09) 176.38,92.71 176.38,92.04 176.47,91.95 177.82,91.95 178.25,91.52 v1(178.79,91.52)
  BOTTOM w0.109: U51100.K12 v4(176.01,93.09) 175.63,92.72 U51100.J12
  BOTTOM w0.137: U50000.V1 175.3,111.79 175.62,111.47 175.62,104.92 178.62,101.93 178.62,95.5 178.69,95.43 178.69,93.6 179.04,93.25 179.04,91.77 v1(178.79,91.52)
FBD_CMD16: length 31.8
  L8 w0.086: v1(192.84,92.82) 191.16,92.67 191.13,92.64 191.12,92.64 v4(190.55,92.33)
  BOTTOM w0.137: v1(192.84,92.82) 193.91,93.33 194.81,93.87 195.1,94.17 195.1,94.17 195.1,96.01 195.09,96.02 195.03,96.35 195.03,96.35 194.34,99.18 194.34,99.18 194.17,99.89 184.72,109.34 184.63,109.4 181.41,111.44 180.79,112.06 180.79,112.08 180.79,112.08 180.79,113.06 180.72,113.13 180.54,113.44 180.54,113.54 U50000.L3 ; v4(190.55,92.33) U51200.L3
FBD_CMD17: length 31
  BOTTOM w0.109: U51200.K3 190.54,93.08 190.54,93.1 U51200.J3
  BOTTOM w0.137: U50000.L2 180.2,113.28 180.52,112.96 180.52,111.96 181.26,111.22 183.95,109.4 184.5,109.02 188.16,105.36 188.16,105.08 190.73,102.52 191.01,102.52 193.83,99.7 193.97,99.1 193.97,99.1 194.63,96.39 194.63,96.39 194.73,95.85 194.73,94.33 194.57,94.17 193.74,93.67 193.54,93.58 193.36,93.49 193.02,93.36 192.53,93.15 192.41,93.1 190.54,93.1
FBD_CMD18_RST: length 27.5
  BOTTOM w0.137: U51200.J1 192.26,93.46 192.52,93.57 192.53,93.58 193.21,93.84 193.52,94 R51206.1 194.26,94.6 193.79,95.07 193.79,95.32 193.34,95.76 193.34,99.65 190.91,102.09 190.45,102.09 186.97,105.57 186.97,106.02 184.4,108.59 181.12,111.02 180.2,111.94 U50000.L1
FBD_CMD19: length 32.7
  L8 w0.086: v1(193.21,94.34) 192.37,93.49 189.46,93.49 v4(189.05,93.09)
  BOTTOM w0.109: U51200.J4 v4(189.05,93.09) U51200.K4
  BOTTOM w0.137: U50000.M4 179.85,114.53 179.85,111.92 180.97,110.8 184.53,107.93 185.75,106.7 185.75,106 190.22,101.53 190.93,101.53 192.92,99.54 192.92,95.42 192.8,95.31 192.8,94.76 193.21,94.35 v1(193.21,94.34)
FBD_CMD20: length 27.4
  L8 w0.086: v4(189.8,93.84) 190.18,94.21 191.68,94.21 v4(192.05,94.59)
  BOTTOM w0.137: v4(189.8,93.84) U51200.H3 ; v4(192.05,94.59) 192.07,94.59 192.48,95 192.48,99.44 191.03,100.89 190.32,100.89 184.26,106.96 184.26,107.44 183.59,108.11 182.13,109.4 180.8,110.57 179.5,111.87 U50000.M1
FBD_CMD21: length 25.3
  BOTTOM w0.137: U50000.M2 179.5,113.24 179.18,112.91 179.18,111.77 180.95,110 180.95,109.55 181.61,108.89 182.09,108.89 182.75,108.23 182.75,107.93 188.87,101.81 188.87,100.51 188.27,99.91 188.27,98.33 187.65,97.72 187.65,96.84 187.9,96.59 187.9,95.18 188.48,94.59 189.06,94.59 U51200.G4
FBD_CMD22: length 27.2
  L8 w0.086: v4(188.12,93.11) 188.12,94.37 v4(188.1,94.39)
  BOTTOM w0.109: U51200.K5 188.52,92.71 v4(188.12,93.11) 188.48,93.46 U51200.J5
  BOTTOM w0.137: v4(188.1,94.39) 187.63,94.86 187.63,96.47 187.39,96.71 187.39,97.95 187.9,98.45 187.9,102.07 182.01,107.97 181.59,107.97 180.59,108.97 180.59,109.97 178.92,111.63 178.92,113.1 179.16,113.34 179.16,113.62 179.5,113.97 U50000.M3
FBD_CMD23: length 28.5
  BOTTOM w0.109: U51200.L5 187.72,92.92 187.72,93.28 188.66,94.21 U51200.H5
  BOTTOM w0.137: U50000.P3 178.1,113.94 178.42,113.61 178.42,113.46 178.42,113.46 178.42,113.34 178.43,113.3 178.68,113.04 178.68,111.43 180.18,109.93 180.18,108.35 187.52,101.01 187.52,98.61 187.11,98.21 187.11,96.51 187.35,96.27 187.35,94.61 187.5,94.46 187.5,93.23 187.62,93.11 187.72,93.11
FBD_CMD24: length 28.1
  BOTTOM w0.137: U50000.P2 178.1,113.28 178.44,112.94 178.44,111.25 179.79,109.9 179.79,107.81 184.84,102.76 185.19,102.76 187.13,100.82 187.13,98.75 186.83,98.45 186.83,96.39 187.07,96.16 187.07,94.53 187.26,94.34 187.26,92.19 187.85,91.59 189.05,91.59 U51200.M4
FBD_CMD25: length 28.7
  BOTTOM w0.137: U51200.M11 184.55,90.84 185.1,90.84 185.25,90.69 186.23,90.69 186.99,91.44 186.99,94.08 186.82,94.25 186.82,95.87 186.54,96.15 186.54,98.59 186.75,98.8 186.75,100.5 186.75,100.5 186.75,100.67 185.03,102.38 184.69,102.38 179.41,107.66 179.41,109.84 178.17,111.08 178.17,112.71 U50000.P1
FBD_CMD26_CKE: length 36.7
  TOP w0.137: R51205.1 186.15,92.55 v4(186.1,92.6)
  L8 w0.076: v4(185.42,91.09) 185.81,91.09 185.92,91.2 185.92,92.41 v4(186.1,92.6) 186.06,92.61 185.71,93.37 185.71,93.55 v4(185.96,94.5)
  BOTTOM w0.109: U51200.G10 184.97,94.98 v4(185.96,94.5) ; U51200.M10 184.93,91.36 185.07,91.5 185.35,91.5 185.49,91.36 185.49,91.16 v4(185.42,91.09)
  BOTTOM w0.137: U50000.R4 177.61,114.88 177.75,114.74 177.75,112.57 177.89,112.43 177.89,110.94 179.03,109.79 179.03,107.2 184.23,102 184.87,102 186.37,100.51 186.37,100.14 186.37,100.14 186.37,98.8 186.26,98.69 186.26,95.96 186.57,95.66 186.57,94.05 186.74,93.88 186.74,91.61 186.5,91.37 186.15,91.37 185.98,91.54 185.98,92.48 v4(186.1,92.6)
FBD_CMD27: length 28.3
  BOTTOM w0.109: U51200.H10 185.43,94.21 185.7,93.95 185.7,92.98 185.71,92.98 185.71,92.11 185.46,91.86 185.03,91.86 U51200.L10
  BOTTOM w0.137: U50000.R1 177.4,112.56 177.59,112.37 177.59,110.74 178.53,109.8 178.53,107.16 182.83,102.87 182.83,102.67 183.87,101.63 184.71,101.63 186.02,100.32 186.02,95.74 186.32,95.44 186.32,93.83 186.5,93.66 186.5,93.3 186.17,92.98 185.71,92.98
FBD_CMD28: length 24.2
  BOTTOM w0.137: U50000.R2 177.4,113.24 177.08,112.91 177.08,112.53 177.35,112.25 177.35,110.51 178.13,109.73 178.13,107.03 181.45,103.7 181.45,102.7 182.9,101.25 184.56,101.25 185.75,100.06 185.75,98.31 185.75,98.31 185.75,96 185.3,95.55 185.3,95.55 185.09,95.34 184.55,95.34 U51200.G11
FBD_CMD29: length 25
  BOTTOM w0.137: U51200.H12 183.05,93.84 181.71,93.84 181.49,94.07 181.49,94.49 180.95,95.02 180.95,95.77 179.98,96.74 179.98,97.43 180.21,97.66 180.21,99.43 180.59,99.82 180.59,104.03 177.66,106.96 177.66,109.67 177.04,110.29 177.04,112.2 176.82,112.42 176.82,113.11 177.05,113.34 177.05,113.64 177.4,113.99 U50000.R3
FBD_CMD30: length 26.4
  L10 w0.086: v1(180.7,93.79) 180.99,93.5 182.64,93.5 v4(183.05,93.09)
  BOTTOM w0.109: U51200.K12 v4(183.05,93.09) U51200.J12
  BOTTOM w0.137: v1(180.7,93.79) 180.21,94.28 180.21,96.1 179.74,96.57 179.74,97.81 179.83,97.89 179.83,99.52 180.2,99.9 180.2,103.46 177.23,106.44 177.23,109.64 176.77,110.09 176.77,112.09 176.58,112.29 176.58,113.11 176.35,113.34 176.35,113.61 176,113.96 U50000.U3
FBD_CMD31: length 28
  L10 w0.086: v4(184.53,93.06) 184.13,92.66 183.96,92.66 183.91,92.71 180.9,92.71 180.76,92.85 v1(180.69,92.85)
  BOTTOM w0.109: U51200.K11 184.18,92.71 v4(184.53,93.06) 184.53,93.11 U51200.J11
  BOTTOM w0.137: U50000.U2 176,113.28 176.32,112.95 176.32,112.14 176.5,111.96 176.5,109.88 176.76,109.63 176.76,106.1 179.83,103.03 179.83,100.15 179.47,99.79 179.47,96.35 179.75,96.07 179.75,94.14 180.69,93.2 v1(180.69,92.85)
FBD_CMD32: length 34.2
  L8 w0.086: v4(175.25,92.31) 174.88,91.94 174.88,90.68 175.09,90.46 177.96,90.46 v1(178.79,89.64)
  BOTTOM w0.137: v4(175.25,92.31) 175.59,91.96 U51100.H12 ; U50000.V4 175.66,114.52 175.66,112.35 175.66,111.94 176,111.61 176,105.49 179.02,102.47 179.02,100.36 178.89,100.23 178.89,95.76 179.02,95.63 179.02,93.86 179.65,93.22 179.65,90.48 178.82,89.64 v1(178.79,89.64)
FBD_CMD33: length 27.2
  L10 w0.086: v1(180.78,91.58) 181.15,91.96 183.42,91.96 v4(183.8,92.34)
  BOTTOM w0.137: v1(180.78,91.58) 180.73,91.63 180.73,91.74 180.16,92.31 180.16,93.17 179.4,93.93 179.4,95.79 179.19,96 179.19,100 179.39,100.2 179.39,102.93 176.38,105.95 176.38,109.56 176.24,109.7 176.24,111.78 176,112.02 U50000.U1 ; v4(183.8,92.34) U51200.L12
FBD_D0: length 35.7
  L10 w0.109: v4(169.26,87.84) 168.88,88.21 168.88,88.81 168.73,88.97 168.3,88.97 168.14,89.13 168.14,93.31 167.99,93.45 167.53,93.45 167.37,93.61 167.37,94.25 166.62,95 166.62,102.6 167.35,103.33 167.35,109.77 167.22,110.2 166.82,110.79 166.81,110.8 166.81,112.44 167.49,113.12 167.49,113.77 167.6,114.43 167.6,117.49 167.45,117.64 166.86,117.64 166.55,117.95 v4(166.48,118.68)
  BOTTOM w0.17: U50000.AK8 166.48,118.1 v4(166.48,118.68) ; v4(169.26,87.84) U51100.B3
FBD_D1: length 32.9
  L10 w0.109: v4(166.61,113.83) 165.89,113.11 165.89,110.7 166.4,109.28 166.4,103.65 165.27,102.53 165.27,92.74 166.55,91.47 166.55,87.71 166.78,87.48 167.2,87.48 167.36,87.32 167.36,86.91 167.56,86.71 168.74,86.71 v4(169.26,86.19)
  BOTTOM w0.17: U50000.AK4 166.54,114.53 166.54,113.89 v4(166.61,113.83) ; U51100.A3 v4(169.26,86.19)
FBD_D2: length 28.6
  L8 w0.109: v4(167.76,90.84) 167.37,90.45 166.51,90.45 166.31,90.25 165.98,90.25 164.35,91.89 164.35,99.15 167.87,102.66 167.87,109.87 167.23,110.51 v4(167.23,110.87)
  BOTTOM w0.17: v4(167.23,110.87) 166.53,111.58 166.53,113.11 U50000.AK2 ; v4(167.76,90.84) U51100.F2
FBD_D3: length 33.6
  L8 w0.109: v4(167.19,112.17) 166.75,112.17 166.21,111.64 166.21,110.25 166.9,109.56 166.9,102.98 163.45,99.52 163.45,89.94 165.91,87.47 168.13,87.47 v4(168.51,87.09)
  BOTTOM w0.17: v4(168.51,87.09) U51100.B2 ; U50000.AK3 167.26,113.82 167.26,112.24 v4(167.19,112.17)
FBD_D4: length 30.9
  L8 w0.109: v4(167.24,115.97) 167.58,115.47 167.58,114.34 167.41,114.04 167.41,113.33 167.45,113.09 167.99,112.55 167.99,110.53 168.35,110.18 168.35,102.5 165.25,99.4 165.25,97.01 164.8,96.56 164.8,92.6 166.2,91.21 168.12,91.21 v4(168.51,91.59)
  BOTTOM w0.17: U51100.G2 v4(168.51,91.59) ; v4(167.24,115.97) 166.9,115.62 U50000.AK5
FBD_D5: length 35.8
  L10 w0.109: v4(166.48,116.63) 166.83,116.29 166.83,114.82 166.82,114.29 167.04,114.07 167.04,113.44 166.36,112.76 166.36,110.73 166.88,109.28 166.88,103.5 166.17,102.79 166.17,93.34 166.74,92.77 167.12,92.77 167.38,92.5 167.38,88.46 167.62,88.22 167.95,88.22 168.13,88.05 168.13,87.65 168.34,87.44 169.54,87.44 169.89,87.09 v4(170.76,87.09)
  BOTTOM w0.17: v4(170.76,87.09) 170.01,87.09 U51100.B4 ; v4(166.48,116.63) U50000.AK6
FBD_D6: length 33
  L10 w0.109: v4(169.26,89.34) U51100.E3 168.88,94.2 168.73,94.35 168.19,94.35 167.39,95.16 167.39,102.62 167.95,103.18 167.95,112.57 168.33,112.96 168.33,113.63 168.98,114.29 168.98,114.84 168.95,114.88 168.95,116.68 169.04,117.21 169.04,117.57 168.87,117.73 168.36,117.73 168.06,118.03 v4(167.19,118.03)
  BOTTOM w0.17: v4(167.19,118.03) U50000.AK9 ; v4(169.26,89.34) U51100.E3
FBD_D7: length 35.4
  L8 w0.109: v4(167.18,117.28) 167.18,117.26 166.84,116.92 166.84,115.83 166.86,115.76 166.86,114.22 167,114.08 167,113.01 167.54,112.47 167.54,111.47 167.35,111.27 166.89,111.27 166.73,111.11 166.73,110.37 167.38,109.72 167.38,102.82 163.9,99.33 163.9,91.03 165.4,89.53 166.53,89.53 166.72,89.72 167.6,89.72 167.6,89.72 167.92,89.72 167.92,89.72 168.14,89.72 168.51,90.09 v4(168.51,90.09)
  BOTTOM w0.17: v4(168.51,90.09) 168.51,90.09 U51100.E2 ; v4(167.18,117.28) 167.18,117.26 U50000.AK7
FBD_D8: length 33.1
  L3 w0.109: v4(168.59,114.43) 168.88,114.14 168.88,112.31 168.76,112.19 168.76,111.59 168.8,111.54 168.8,111.06 168.8,111.06 168.8,110.99 168.77,110.96 168.77,101.62 169.64,100.75 169.64,96.99 169.64,96.98 169.64,96.68 169.64,96.67 169.64,91.1 170.41,90.33 170.41,89.37 170.82,88.96 171.76,88.96 173.47,87.24 174.14,87.24 174.36,87.46 174.89,87.46 v4(175.26,87.84)
  BOTTOM w0.17: v4(175.26,87.84) U51100.B12 ; v4(168.59,114.43) U50000.AG4
FBD_D9: length 32.7
  L3 w0.109: v4(176.76,90.84) 177.13,91.21 177.13,93.24 176.9,93.46 175.12,93.46 174.87,93.71 174.87,94.89 174.13,95.63 174.13,99.46 173.69,102.62 172.73,108.34 172.46,110.17 172.46,112.51 171.43,113.54 171.43,115.21 171.02,115.63 171.02,116.25 171.18,116.41 171.18,116.75 169.91,118.02 169.91,118.54 170.04,118.68 v4(170.04,118.7)
  BOTTOM w0.17: U50000.AF9 169.74,118.38 170.04,118.68 v4(170.04,118.7) ; v4(176.76,90.84) U51100.F13
FBD_D10: length 30.9
  L3 w0.109: v4(168.53,115.81) 168.63,115.81 168.9,115.64 168.9,114.79 169.8,113.89 169.8,113.28 169.99,113.09 169.99,111.42 170.84,110.57 170.84,109.91 171.02,106.11 171.02,102.5 171.84,100.48 171.84,94.64 172.18,93.37 172.58,92.4 172.58,91.27 173.05,90.8 174.45,90.8 174.9,90.35 174.9,89.71 v4(175.25,89.36)
  BOTTOM w0.17: U50000.AG6 168.54,115.81 v4(168.53,115.81) ; U51100.E12 175.6,89.71 v4(175.25,89.36)
FBD_D11: length 30.9
  L3 w0.109: v4(168.6,116.74) 168.86,117 169.64,117 169.78,116.86 169.78,116.35 169.54,116.12 169.54,115.83 170.48,114.89 170.91,114.89 171.05,114.75 171.05,113.32 171.9,112.47 171.9,109.75 172.93,102.36 172.93,95.21 174.14,94 174.14,93.02 174.44,92.72 175.52,92.72 175.62,92.62 175.62,91.98 v4(176.01,91.59)
  BOTTOM w0.17: v4(168.6,116.74) 168.76,116.74 U50000.AG7 ; v4(176.01,91.59) U51100.G13
FBD_D12: length 39.5
  L3 w0.109: v4(176.76,87.09) 176.38,86.72 175.85,86.72 175.85,86.71 175.02,86.71 174.88,86.58 174.88,86.16 174.45,85.73 173.39,85.73 171.66,87.46 167.6,87.46 167.39,87.67 167.39,100.22 166.79,100.83 166.79,112.49 167.47,113.17 167.47,113.92 167.22,114.17 v4(167.22,114.53)
  BOTTOM w0.17: v4(176.76,87.09) U51100.B13 ; v4(167.22,114.53) U50000.AJ4
FBD_D13: length 36.4
  L3 w0.109: v4(174.49,87.07) 174.49,87.07 173.94,86.52 173.4,86.52 171.72,88.2 168.36,88.2 168.14,88.43 168.14,100.28 167.57,100.85 167.57,110.58 167.63,110.65 167.63,111.73 168.18,112.85 168.35,113.01 168.35,114.01 168.19,114.17 167.78,114.17 167.61,114.34 167.61,114.92 167.95,115.25 v4(167.95,115.27)
  BOTTOM w0.17: v4(174.49,87.07) U51100.B11 ; v4(167.95,115.27) U50000.AJ5
FBD_D14: length 43.3
  L3 w0.109: v4(176.01,86.34) 174.94,85.27 173.21,85.27 171.62,86.86 171.16,86.86 171,86.7 166.89,86.7 166.56,87.03 166.56,88.13 166.49,88.21 166.49,94.85 166.34,95 166.34,112.7 166.98,113.34 166.98,114 166.86,114.12 166.86,115.36 167.08,115.59 167.51,115.59 167.61,115.69 167.61,116.41 168.11,116.91 v4(168.11,117)
  BOTTOM w0.17: v4(168.11,117) 168.11,116.91 167.6,116.36 U50000.AJ6 ; v4(176.01,86.34) U51100.A12
FBD_D15: length 29.2
  L3 w0.109: v4(169.41,115.23) 169.41,114.61 170.15,113.87 170.15,113.82 171.36,112.61 171.36,110.27 171.71,105.84 171.71,102.54 172.39,100.76 172.39,95.17 173.12,93.68 173.12,92.43 174.34,91.21 175.45,91.21 175.63,91.04 175.63,90.46 v4(176.01,90.09)
  BOTTOM w0.17: U51100.E13 v4(176.01,90.09) ; v4(169.41,115.23) U50000.AG5
FBD_D16: length 24.7
  L3 w0.109: v4(174.4,115.87) 174.36,115.87 174.04,115.55 174.04,115.06 174.3,114.81 174.51,114.81 175.2,114.12 175.2,113.2 175.5,112.9 175.5,109.79 176.57,105.35 178.39,101.18 178.39,96.85 177.94,96.39 177.42,96.39 177.13,96.11 177.13,95.93 176.91,95.71 U51100.N13 v4(176.01,95.34)
  BOTTOM w0.17: v4(174.4,115.87) 174.39,115.87 173.92,116.28 U50000.Y6 ; U51100.N13 v4(176.01,95.34)
FBD_D17: length 22.2
  L3 w0.109: v4(176.01,96.84) 176.38,97.21 177.74,97.21 177.91,97.38 177.91,100.1 177.78,100.39 175.98,104.69 174.9,109.83 174.9,112.83 173.92,113.81 173.92,114.83 173.52,115.23 v4(173.48,115.23)
  BOTTOM w0.17: v4(173.48,115.23) 173.52,115.23 U50000.Y5 ; v4(176.01,96.84) U51100.P12
FBD_D18: length 24
  L3 w0.109: v4(176.76,94.59) 177.13,94.96 177.83,94.96 178.95,96.09 178.95,102.11 177.17,105.65 176.02,110.39 176.02,113.12 175.51,113.63 175.51,114.31 174.94,114.89 174.94,115.21 174.96,115.23 v4(174.96,115.24)
  BOTTOM w0.17: v4(176.76,94.59) U51100.M13 ; v4(174.96,115.24) 174.97,115.25 174.98,115.27 U50000.V5
FBD_D19: length 20.8
  L8 w0.109: v4(174.38,114.4) 174.38,113.74 176.94,111.18 176.94,100.33 177.13,100.13 177.13,96.47 v4(176.76,96.09)
  BOTTOM w0.17: v4(174.38,114.4) U50000.Y4 ; v4(176.76,96.09) U51100.P13
FBD_D20: length 19.7
  L3 w0.109: v4(173.49,116.59) 173.11,116.22 173.11,115.93 173.11,114.81 173.45,114.47 173.45,113.64 174.25,112.84 174.25,110.03 175.45,104.11 176.33,102.14 177.15,100.22 177.15,99.48 v4(176.76,99.09)
  BOTTOM w0.17: v4(173.49,116.59) U50000.AA6 ; U51100.U13 v4(176.76,99.09)
FBD_D21: length 17.7
  L3 w0.109: v4(172.77,115.78) 172.68,115.7 172.68,114.36 172.99,114.05 172.99,113.48 173.76,112.72 173.76,110 174.11,107.52 175.4,102.01 v4(176.01,99.84)
  BOTTOM w0.17: v4(176.01,99.84) U51100.V12 ; v4(172.77,115.78) U50000.AA5
FBD_D22: length 18.9
  L3 w0.109: v4(171.45,115.93) 171.78,115.6 171.78,114.01 173.1,112.69 173.1,109.95 173.48,107.55 174.45,102.16 174.9,100.06 174.9,99.45 v4(175.26,99.09)
  BOTTOM w0.17: U51100.U12 v4(175.26,99.09) ; v4(171.45,115.93) U50000.AC5
FBD_D23: length 18.7
  L8 w0.109: v4(172.29,114.41) 172.62,114.41 172.97,114.06 172.97,113.23 174.91,111.29 174.91,98.74 v4(174.53,98.36)
  BOTTOM w0.17: v4(172.29,114.41) U50000.AC4 ; U51100.U11 v4(174.53,98.36)
FBD_D24: length 30.9
  L10 w0.109: v4(168.53,95.36) 168.92,94.96 171.42,94.96 173.19,96.73 173.19,99.89 174.58,101.28 174.58,110.86 173.86,111.59 173.86,113.32 173.41,113.77 173.41,114.58 173.12,114.86 173.12,116.77 173.39,117.04 173.39,117.54 173.24,117.69 171.79,117.69 v4(171.39,117.28)
  BOTTOM w0.17: v4(168.53,95.36) U51100.M2 ; v4(171.39,117.29) U50000.AD7
FBD_D25: length 26.4
  L10 w0.109: v4(172.16,116.62) 172.16,116.53 172.19,116.5 172.19,115.78 172.67,115.29 172.67,114.35 172.94,114.08 172.94,113.54 173.41,113.07 173.41,111.4 174.13,110.68 174.13,101.75 172.64,100.26 172.64,96.9 171.23,95.48 169.87,95.48 169.27,96.08 v4(169.27,96.08)
  BOTTOM w0.17: v4(169.27,96.08) 169.27,96.08 U51100.P3 ; v4(172.16,116.62) 172.14,116.62 172.12,116.6 172.12,116.6 U50000.AC6
FBD_D26: length 21.4
  L10 w0.109: v4(170.01,115.97) 169.97,115.93 169.97,115 169.63,114.66 169.63,114.32 169.9,114.04 169.9,113.28 171.15,112.04 171.15,110.46 171.87,109.74 171.87,103.93 171,103.06 169.5,103.06 169.39,102.95 169.39,101.45 168.96,101.02 168.96,100.2 168.88,100.12 168.88,99.22 169.01,99.09 v4(169.26,99.09)
  BOTTOM w0.17: v4(169.26,99.09) U51100.U3 ; v4(170.01,115.97) U50000.AF6
FBD_D27: length 25.3
  L10 w0.109: v4(170.77,116.61) 171.02,116.36 171.02,115.75 171.4,115.37 171.4,113.84 172.5,112.74 172.5,111.02 173.23,110.3 173.23,102.57 171.64,100.98 171.64,97.46 171.4,97.22 168.66,97.22 168.51,97.07 v4(168.51,96.84)
  BOTTOM w0.17: v4(170.77,116.61) U50000.AD6 ; v4(168.51,96.84) U51100.P2
FBD_D28: length 21.9
  L10 w0.109: v4(168.51,99.84) 168.38,99.97 168.38,101.66 168.9,102.18 168.9,103.51 169.01,103.62 170.92,103.62 171.42,104.12 171.42,109.55 170.69,110.27 170.69,110.76 170.53,110.93 169.8,110.93 169.69,111.03 169.69,113.96 169.42,114.23 169.42,114.75 169.76,115.09 169.76,115.37 169.56,115.58 169.5,115.58 169.31,115.77 v4(169.31,116.61)
  BOTTOM w0.17: U50000.AF7 169.33,116.61 v4(169.31,116.61) ; v4(168.51,99.84) U51100.V3
FBD_D29: length 28.5
  L10 w0.109: v4(170.08,117.26) 170.66,117.26 171.84,116.08 171.84,114.09 172.96,112.97 172.96,111.21 173.68,110.49 173.68,102.13 172.13,100.59 172.13,97.14 171.45,96.45 168.14,96.45 v4(167.76,96.07)
  BOTTOM w0.17: U51100.N2 167.77,96.07 v4(167.76,96.07) ; v4(170.08,117.26) U50000.AF8
FBD_D30: length 24
  L8 w0.109: v4(170.43,112.08) 170.43,112.07 170.82,111.68 170.82,111.09 171.61,110.31 171.61,100.97 171.81,100.76 171.81,96.25 171.04,95.48 169.95,95.48 169.63,95.81 169.63,97.96 v4(170.01,98.34)
  BOTTOM w0.17: U50000.AF2 169.7,113.4 170.29,112.81 170.29,112.22 v4(170.43,112.08) ; v4(170.01,98.34) U51100.U4
FBD_D31: length 20.4
  L10 w0.109: v4(167.76,99.09) 167.93,99.26 167.93,101.84 168.45,102.37 168.45,103.97 168.56,104.07 170.73,104.07 170.97,104.31 170.97,109.1 170.58,109.48 169.41,109.48 168.78,110.11 168.78,113.54 169.06,113.82 v4(169.33,113.82)
  BOTTOM w0.17: v4(169.33,113.82) U50000.AF3 ; v4(167.76,99.09) U51100.U2
FBD_D32: length 20.5
  L3 w0.109: v4(189.8,98.34) 189.43,98.71 189.43,104.51 184.18,109.76 184.18,112.31 183.49,113 183.49,115.07 183.4,115.16 v4(183.4,115.21)
  BOTTOM w0.17: U50000.F4 183.4,115.16 v4(183.4,115.21) ; U51200.B3 v4(189.8,98.34)
FBD_D33: length 16.2
  L3 w0.109: v4(190.55,99.84) 190.55,104.32 184.64,110.23 184.64,112.11 v4(184.87,112.34)
  BOTTOM w0.17: U50000.E1 184.84,112.34 v4(184.87,112.34) ; v4(190.55,99.84) U51200.A3
FBD_D34: length 24.2
  L3 w0.109: v4(184.03,114.51) 184.3,114.24 184.89,114.24 185.07,114.07 185.07,112.78 185.24,112.61 186.07,112.61 186.55,112.13 186.55,110.19 191.69,105.05 191.69,97.4 191.5,97.21 190.18,97.21 v4(189.8,96.84)
  BOTTOM w0.17: v4(184.03,114.51) U50000.F3 ; v4(189.8,96.84) U51200.E3
FBD_D35: length 21.9
  L3 w0.109: v4(184.02,115.9) 183.25,115.9 182.42,115.07 182.42,113.58 183.28,112.71 183.28,111.57 183.33,111.52 183.33,111.2 183.28,111.16 183.28,109.62 188.86,104.04 188.86,100.23 188.64,100.01 188.64,99.5 v4(189.05,99.09)
  BOTTOM w0.17: v4(189.05,99.09) U51200.B4 ; v4(184.02,115.9) U50000.F5
FBD_D36: length 23.9
  L3 w0.109: v4(191.3,95.34) 191.68,95.71 192.32,95.71 192.91,96.3 192.91,100.16 192.95,100.2 192.95,105.34 187.67,110.62 187.67,111.74 187.54,111.87 187.54,111.95 187.54,111.95 187.54,112.24 187.54,112.57 187.33,112.78 186.51,112.78 186.16,113.13 v4(185.47,113.13)
  BOTTOM w0.17: U50000.D2 185.12,113.48 v4(185.47,113.13) ; U51200.F2 v4(191.3,95.34)
FBD_D37: length 17.8
  L3 w0.109: v4(191.3,98.34) 190.93,98.71 190.93,98.93 190.93,98.93 190.93,100.06 191.08,100.21 191.08,104.81 186.12,109.76 186.01,109.88 v4(186.01,111.72)
  BOTTOM w0.17: U51200.B2 v4(191.3,98.34) ; v4(186.01,111.72) 185.71,111.72 185.46,111.96 185.46,112.41 U50000.D1
FBD_D38: length 25.8
  L3 w0.109: v4(186.15,113.85) 186.23,113.77 187.06,113.77 187.47,113.36 187.47,113.08 187.85,112.69 187.85,112.69 188.06,112.48 188.06,112.48 188.26,112.28 188.26,110.79 193.4,105.64 193.4,100.01 193.36,99.97 193.36,96.11 193.34,96.09 193.34,95.87 192.44,94.97 190.93,94.97 v4(190.55,94.59)
  BOTTOM w0.17: v4(186.15,113.85) U50000.C3 ; U51200.G2 v4(190.55,94.59)
FBD_D39: length 22.8
  L3 w0.109: v4(190.55,96.09) 190.93,96.47 192.28,96.47 192.5,96.68 192.5,105.14 187.16,110.48 v4(187.16,112.42)
  BOTTOM w0.17: v4(187.16,112.42) 186.37,112.42 186.16,112.64 186.16,112.92 186.16,112.92 186.16,113.12 U50000.C2 ; v4(190.55,96.09) U51200.E2
FBD_D40: length 19.4
  L10 w0.109: v4(183.06,99.09) 183.05,99.09 182.67,99.47 182.67,99.68 182.68,99.68 182.68,99.99 182.67,100 182.67,103.44 180.09,106.02 180.09,113.1 180.4,113.41 180.4,114.24 181.44,115.28 v4(181.9,115.28)
  BOTTOM w0.17: U51200.B13 183.05,99.09 v4(183.06,99.09) ; v4(181.9,115.28) U50000.J5
FBD_D41: length 17.5
  L10 w0.109: v4(183.8,99.84) 183.52,100.12 183.52,103.55 180.54,106.53 180.54,112.84 181.17,113.47 181.17,114.29 181.06,114.4 v4(181.06,114.4)
  BOTTOM w0.17: U50000.J4 181.09,114.4 v4(181.06,114.4) ; v4(183.8,99.84) U51200.A12
FBD_D42: length 23.6
  L10 w0.109: v4(180.5,117.98) 180.24,117.72 180.24,116.85 180.21,116.82 180.21,116.27 180.36,116.12 180.36,115.61 180.17,115.42 180.17,114.74 179.83,114.39 179.83,113.39 179.63,113.19 179.63,105.79 181.78,103.64 181.78,99.01 182.07,98.72 182.07,98.71 U51200.B12 v4(183.8,98.34)
  BOTTOM w0.17: v4(183.8,98.34) U51200.B12 ; v4(180.5,117.98) U50000.L8
FBD_D43: length 16.7
  L10 w0.109: v4(181.4,112.3) 181.4,111.9 181.51,111.8 181.51,109.76 184.93,106.33 184.93,99.51 184.55,99.13 184.55,99.13 v4(184.55,99.13)
  BOTTOM w0.17: v4(181.4,112.3) 181.26,112.45 181.26,112.92 181.6,113.26 U50000.J2 ; v4(184.55,99.13) 184.55,99.13 184.55,99.13 184.18,98.76 U51200.B11
FBD_D44: length 21.6
  L10 w0.109: v4(183.75,112.09) 183.78,112.09 184.18,111.69 184.18,109.54 187.01,106.71 187.01,97.72 185.75,96.46 183.42,96.46 183.05,96.09 v4(183.06,96.09)
  BOTTOM w0.17: U51200.E13 183.05,96.09 v4(183.06,96.09) ; U50000.F1 183.75,112.72 v4(183.75,112.09)
FBD_D45: length 26
  L10 w0.109: v4(183.05,94.59) 183.4,94.94 186.16,94.94 188.59,97.38 188.59,100.18 188.89,100.47 188.89,101.27 188.59,101.57 188.59,107.09 185.56,110.12 185.56,111.8 185.29,112.06 185.29,112.48 185.06,112.72 184.46,112.72 v4(184,113.18)
  BOTTOM w0.17: v4(183.05,94.59) U51200.G13 ; v4(184,113.18) U50000.F2
FBD_D46: length 22.6
  L10 w0.109: v4(183.8,96.84) 184.04,96.84 184.37,97.17 185.57,97.17 186.39,97.99 186.39,106.56 183.39,109.55 183.39,112.14 182.44,113.1 182.44,114.3 182.58,114.45 v4(182.77,114.45)
  BOTTOM w0.17: v4(182.77,114.45) 182.73,114.45 U50000.H4 ; v4(183.8,96.84) U51200.E12
FBD_D47: length 27.9
  L10 w0.109: v4(182.28,95.32) 182.68,95.71 185.49,95.71 185.68,95.9 186.17,95.9 187.64,97.37 187.64,106.82 184.66,109.8 184.66,111.98 184.07,112.57 183.82,112.57 183.54,112.86 183.54,114.4 182.98,114.95 182.98,115.52 v4(182.66,115.84)
  BOTTOM w0.17: U50000.H5 182.42,115.58 v4(182.66,115.84) ; v4(182.28,95.32) U51200.F13
FBD_D48: length 39.1
  L10 w0.109: v4(183.8,86.34) 183.55,86.59 178.64,86.59 177.8,87.43 176.91,87.43 176.9,87.44 176.65,87.44 176.39,87.69 176.39,101.42 176.17,101.64 176.17,112.29 175.31,113.15 175.31,116.26 175.28,116.29 175.28,117.03 v4(175.56,117.31)
  BOTTOM w0.17: v4(175.56,117.31) U50000.V7 ; v4(183.8,86.34) U51200.V12
FBD_D49: length 40.2
  L10 w0.109: v4(174.91,118.06) 175.29,117.69 175.77,117.69 175.85,117.61 175.97,117.49 175.97,117.08 176.03,117.02 176.03,116.39 176.08,116.34 176.08,114.97 175.82,114.7 175.82,113.54 176.67,112.69 176.67,102 177.15,101.51 177.15,88.33 177.3,88.19 177.92,88.19 178.19,87.91 179.9,87.91 180.39,87.43 181.99,87.43 182.02,87.46 184.18,87.46 v4(184.55,87.09)
  BOTTOM w0.17: v4(184.55,87.09) U51200.U11 ; v4(174.91,118.06) U50000.V8
FBD_D50: length 36.2
  L8 w0.109: v4(174.92,116.69) 174.92,116.66 175.31,116.27 175.31,113.44 177.71,111.04 177.71,100.36 177.96,100.12 177.96,93.97 178.06,93.88 179.34,92.6 179.34,87.87 180.62,86.59 182.59,86.59 v4(183.07,87.07)
  BOTTOM w0.17: v4(174.92,116.69) 174.92,116.65 U50000.V6 ; v4(183.07,87.07) U51200.U13
FBD_D51: length 32.2
  L8 w0.109: v4(175.6,118.68) 175.81,118.68 176.03,118.46 176.03,117.94 176.2,117.78 176.46,117.78 176.68,117.56 176.68,116.97 178.22,115.43 178.22,115.32 179.11,114.42 179.11,112.32 180.01,111.43 180.01,94.64 180.43,94.21 180.96,94.21 181.93,93.25 181.93,91.22 v4(182.3,90.84)
  BOTTOM w0.17: v4(175.6,118.68) U50000.V9 ; v4(182.3,90.84) U51200.N13
FBD_D52: length 32.5
  L10 w0.109: v4(176.45,114.41) 176.34,114.29 176.34,113.76 177.15,112.95 177.15,103.54 178.73,101.96 178.73,93.94 178.95,93.71 178.95,93.48 179.24,93.2 179.24,89.73 180.76,88.21 183.43,88.21 v4(183.8,87.84)
  BOTTOM w0.17: v4(183.8,87.84) U51200.U12 ; v4(176.45,114.41) U50000.U4
FBD_D53: length 30
  L8 w0.109: v4(182.3,89.34) 181.93,89.71 181.33,89.71 181.06,89.98 181.06,91.15 181.19,91.28 181.19,91.86 181.1,91.94 181.1,92.19 181.1,92.2 181.1,92.48 181.1,92.48 181.1,93.27 180.99,93.38 180.47,93.38 179.52,94.33 179.52,111.25 178.65,112.12 178.04,114.23 v4(176.85,115.43)
  BOTTOM w0.17: U51200.P13 v4(182.3,89.34) ; U50000.R5 v4(176.85,115.43)
FBD_D54: length 30.4
  L10 w0.109: v4(177.7,116.57) 178.01,116.25 178.01,115.73 178.17,115.58 178.17,104.39 179.95,102.6 179.95,94.85 180.19,94.61 180.19,91.34 180.51,91.03 181.08,91.03 181.26,91.2 182.67,91.2 v4(183.05,91.59)
  BOTTOM w0.17: v4(177.7,116.57) U50000.R6 ; v4(183.05,91.59) U51200.M13
FBD_D55: length 33.9
  L10 w0.109: v4(183.05,90.09) 182.85,90.09 182.48,89.71 180.73,89.71 179.74,90.7 179.74,93.34 179.41,93.67 179.41,102.16 177.65,103.93 177.65,114.39 177.4,114.63 177.4,116.38 176.68,117.1 176.68,117.17 176.68,117.48 176.68,117.48 176.68,117.97 v4(176.48,118.17)
  BOTTOM w0.17: v4(176.48,118.17) 176,117.69 U50000.U8 ; v4(183.05,90.09) U51200.P12
FBD_D56: length 36.1
  L3 w0.109: v4(189.05,87.09) 188.85,87.29 188,87.29 186.7,88.59 186.7,94.36 186.13,94.93 185.53,94.93 184.74,95.71 183.55,95.71 183.43,95.83 183.43,96.31 183.28,96.46 182.83,96.46 182.66,96.63 182.66,100.02 181.93,100.75 181.93,103.6 179.24,106.29 177.88,110.73 177.88,114.51 178.21,114.85 178.21,115.77 v4(178.38,115.93)
  BOTTOM w0.17: v4(178.38,115.93) 178.38,116 U50000.P6 ; v4(189.05,87.09) U51200.U4
FBD_D57: length 40.1
  L8 w0.109: v4(189.8,89.34) 189.43,89.72 188.52,89.72 187.3,90.93 187.19,92.06 187.19,95.2 186.6,95.79 185.68,95.79 185.27,95.7 182.91,95.7 182.68,95.93 182.68,108.37 181.47,110.88 181.47,111.69 181.02,112.15 181.02,113.11 180.08,114.06 180.08,115.38 180.27,115.57 180.27,116.2 180.22,116.24 180.22,116.79 180.24,116.8 180.24,117.68 178.9,119.02 178.53,119.02 177.93,118.42 177.3,118.42 v4(177.06,118.66)
  BOTTOM w0.17: v4(189.8,89.34) U51200.P3 ; U50000.R9 177.34,118.38 v4(177.06,118.66)
FBD_D58: length 34
  L3 w0.109: v4(189.8,87.84) 189.43,88.21 188.11,88.21 187.7,88.62 187.7,90.67 187.18,91.19 187.18,94.52 185.7,96 185.7,96.3 185.55,96.45 184.36,96.45 184.17,96.64 184.17,97 183.95,97.22 183.51,97.22 183.41,97.32 183.41,100.08 182.65,100.83 182.65,103.55 179.64,106.56 178.57,110.55 178.57,113.47 178.33,113.72 178.33,114.23 v4(178.55,114.45)
  BOTTOM w0.17: v4(178.55,114.45) U50000.P4 ; v4(189.8,87.84) U51200.U3
FBD_D59: length 38.1
  L3 w0.109: v4(177.79,115.27) 177.42,114.9 177.42,110.38 178.58,106.16 181.09,103.66 181.09,99.6 181.87,98.82 181.87,95.87 182.04,95.7 182.48,95.7 182.68,95.5 182.68,95.17 182.87,94.97 184.82,94.97 185.71,94.09 185.71,91.29 185.77,91.23 185.77,90.95 185.75,90.92 185.75,88.82 186.71,87.85 186.71,87.85 186.94,87.63 186.94,87.63 187.99,86.57 188.59,86.57 188.73,86.71 190.18,86.71 v4(190.55,87.09)
  BOTTOM w0.17: v4(190.55,87.09) U51200.V3 ; v4(177.79,115.27) U50000.P5
FBD_D60: length 36.2
  L3 w0.109: v4(191.3,87.84) 190.93,88.21 190.93,89.49 190.71,89.72 189.54,89.72 189.44,89.82 189.44,91.35 188.64,92.15 188.64,94.47 187.73,95.38 187.72,95.38 186.67,96.43 186.67,97.02 185.77,97.92 185.77,99.26 185.57,99.45 185.13,99.45 184.95,99.64 184.95,99.98 184.07,100.86 184.07,103.57 180.78,106.86 180.57,107.46 179.82,110.04 179.82,112.9 179.56,113.17 179.56,115.48 179.46,115.58 179.46,116.75 179.86,117.15 v4(179.86,117.32)
  BOTTOM w0.17: v4(179.86,117.32) U50000.L7 ; v4(191.3,87.84) U51200.U2
FBD_D61: length 33.3
  L3 w0.109: v4(191.3,90.84) 190.93,91.21 190.93,94.07 190.78,94.21 190.38,94.21 190.18,94.42 190.18,96.29 190.03,96.44 188.72,96.44 188.59,96.57 187.96,96.57 187.64,96.89 187.64,98.3 187.18,98.76 187.18,99.59 185.81,100.96 185.81,104.14 182.06,107.89 181.84,107.89 181.44,108.29 181.43,108.36 181.01,110.31 181.01,113 180.39,113.62 180.39,114.38 180.9,114.89 180.9,115.3 180.38,115.83 180.38,116.45 v4(180.57,116.64)
  BOTTOM w0.17: v4(180.57,116.64) 180.2,116.28 U50000.L6 ; v4(191.3,90.84) U51200.N2
FBD_D62: length 32.7
  L8 w0.109: v4(190.55,90.09) 190.18,90.46 188.79,90.46 188.59,90.66 188.24,91.94 188.05,92.59 187.72,92.93 187.72,95.51 186.77,96.45 183.59,96.45 183.43,96.61 183.43,109.26 182.32,111.21 182.32,111.63 182.4,112.33 182.32,112.79 181.46,113.64 181.46,114.58 181.38,114.67 v4(180.53,115.16)
  BOTTOM w0.17: U51200.P2 v4(190.55,90.09) ; v4(180.53,115.16) U50000.L4
FBD_D63: length 30.2
  L3 w0.109: v4(179.89,115.87) 179.89,113.46 180.39,112.97 180.39,110.15 181,107.99 181.28,107.17 184.95,103.5 184.95,100.92 186.46,99.41 186.46,98.35 187.17,97.64 187.17,96.67 188.14,95.7 189.21,95.7 189.42,95.49 189.42,94.93 189.37,94.89 189.37,94.17 189.43,94.11 189.43,93.7 189.66,93.46 189.95,93.46 190.17,93.24 190.17,91.97 v4(190.55,91.59)
  BOTTOM w0.17: U50000.L5 v4(179.89,115.87) ; v4(190.55,91.59) U51200.M2
FBD_DBI0: length 25.7
  L3 w0.109: v4(168.39,111.37) 168,110.98 168,110.58 168.16,110.42 168.16,101.53 168.9,100.79 168.9,88.98 v4(168.51,88.59)
  BOTTOM w0.17: v4(168.51,88.59) U51100.D2 ; U50000.AJ1 167.99,112.39 167.99,111.76 v4(168.39,111.37)
FBD_DBI1: length 31.4
  L3 w0.109: v4(169.21,110.76) 169.24,110.74 169.24,101.84 170.38,100.7 170.38,99.25 170.38,99.24 170.38,94.69 170.59,93.35 170.59,91.54 171.86,89.65 173.44,88.07 174.14,88.07 174.29,88.21 175.85,88.21 175.85,88.21 176.16,88.21 176.39,88.44 176.39,88.97 v4(176.76,89.34)
  BOTTOM w0.17: U50000.AG1 169.6,112.18 169.6,111.16 169.24,110.8 169.24,110.79 v4(169.21,110.76) ; v4(176.76,89.34) U51100.D13
FBD_DBI2: length 23.5
  L8 w0.109: v4(172.9,117.33) 173.05,116.84 173.07,116.73 173.07,116.3 172.92,116.15 172.62,116.15 172.4,115.94 172.4,115.63 172.62,115.42 172.92,115.42 173.07,115.27 173.07,114.66 173.46,114.27 173.46,113.38 175.63,111.21 175.63,98.22 175.92,97.94 176.41,97.94 v4(176.76,97.59)
  BOTTOM w0.17: U50000.AA7 172.9,117.31 v4(172.9,117.33) ; U51100.R13 v4(176.76,97.59)
FBD_DBI3: length 22.7
  L10 w0.109: v4(170.8,115.28) 171.04,115.04 171.04,113.38 172.05,112.37 172.05,110.84 172.77,110.11 172.77,103.24 170.38,100.85 170.38,98.18 170.18,97.97 168.15,97.97 v4(167.76,97.58)
  BOTTOM w0.17: U51100.R2 v4(167.76,97.58) ; v4(170.8,115.28) U50000.AD5
FBD_DBI4: length 21
  L8 w0.109: v4(185.42,114.48) 185.79,114.08 185.79,113.64 185.96,113.47 185.96,112.72 186.51,112.18 186.51,105.35 190.93,100.92 190.93,97.21 v4(191.3,96.84)
  BOTTOM w0.17: U51200.D2 v4(191.3,96.84) ; v4(185.42,114.48) U50000.D3
FBD_DBI5: length 21.1
  L10 w0.109: v4(182.28,96.85) 182.68,97.25 182.68,97.74 182.68,97.75 182.68,97.76 182.88,97.96 182.89,97.96 182.9,97.97 183.21,97.97 183.21,97.96 183.98,97.96 184.18,98.17 184.18,103.63 181.06,106.75 181.06,112.74 181.94,113.62 v4(181.94,113.82)
  BOTTOM w0.17: v4(181.94,113.82) U50000.H3 ; v4(182.28,96.85) 182.32,96.85 U51200.D13
FBD_DBI6: length 33.5
  L8 w0.109: v4(175.7,115.88) 176.06,115.52 176.06,115.06 175.68,114.69 175.68,113.75 178.26,111.17 178.26,100.45 178.42,100.29 178.42,94.15 179.79,92.78 179.79,92.7 179.83,92.67 179.83,89.06 180.67,88.21 182.65,88.21 v4(183.03,88.59)
  BOTTOM w0.17: v4(183.03,88.59) 182.68,88.94 U51200.R13 ; v4(175.7,115.88) U50000.U5
FBD_DBI7: length 37.9
  L8 w0.109: v4(179.8,118.68) 180.73,118.29 180.8,118.21 180.98,117.73 180.98,116.98 180.92,116.92 180.92,115.69 181.69,114.92 182.19,114.92 182.41,114.69 182.41,113.86 182.93,112.78 183.3,112.41 183.3,111.56 184.17,109.52 184.17,109.52 184.17,97.3 184.28,97.19 186.87,97.19 187.44,96.95 188.47,96.47 188.68,96.26 188.68,92.15 189.61,91.21 190.78,91.21 190.93,91.06 190.93,89.71 v4(191.3,89.34)
  BOTTOM w0.17: v4(191.3,89.34) U51200.R2 ; v4(179.8,118.68) U50000.M9
FBD_DEBUG0: length 8.3
  TOP w0.102: v4(169.72,110.21) 169.72,110.22 168.88,110.22 168.78,110.32 168.78,112.43 R50420.1
  BOTTOM w0.102: 170.55,112.52 170.54,112.54 170.54,113.05 170.77,113.29 170.77,113.61 171.1,113.94 U50000.AD3
  BOTTOM w0.109: v4(169.72,110.21) 170.84,111.33 170.84,112.23 170.55,112.52
FBD_DEBUG1: length 10.5
  TOP w0.102: v1(181.9,108.47) 184.41,105.96 184.41,105.85 R50421.1
  L3 w0.102: v4(181.9,111.72) 181.56,111.38 181.56,109.91 181.85,108.51 v1(181.9,108.47)
  BOTTOM w0.102: U50000.J3 181.24,113.83 181.24,113.26 181.01,113.02 181.01,112.17 181.47,111.72 v4(181.9,111.72)
FBD_EDC0: length 32.6
  L8 w0.109: v4(167.94,113.81) 168.29,113.46 168.29,112.8 168.79,112.31 168.79,110.38 168.8,110.37 168.8,102.31 165.71,99.22 165.71,96.75 165.25,96.29 165.25,92.79 166.09,91.96 168.7,91.96 168.88,91.78 168.88,89.1 168.74,88.96 168.29,88.96 168.13,88.8 168.13,88.21 v4(167.76,87.84)
  BOTTOM w0.17: v4(167.76,87.84) U51100.C2 ; v4(167.94,113.81) U50000.AJ3
FBD_EDC1: length 29.5
  L3 w0.109: v4(176.01,88.59) 175.63,88.97 173.58,88.97 172.08,90.48 171.77,91.59 171.77,93.19 171.75,93.23 171.6,93.79 171.29,94.82 171.29,100.25 171.23,100.39 170.33,102.42 170.33,106.83 170.23,110.36 169.7,110.89 169.7,111.67 169.36,112.01 v4(169.19,112.01)
  BOTTOM w0.17: U50000.AG2 168.62,113.1 168.62,112.57 v4(169.19,112.01) ; v4(176.01,88.59) U51100.C13
FBD_EDC2: length 22.9
  L8 w0.109: v4(173.51,118.69) 173.24,118.42 173.24,117.64 173.93,116.94 173.93,113.55 176.38,111.09 176.38,98.71 v4(176.01,98.34)
  BOTTOM w0.17: v4(173.51,118.69) U50000.AA9 ; U51100.T13 v4(176.01,98.34)
FBD_EDC3: length 20.3
  L10 w0.109: v4(170.05,114.48) 170.11,114.42 170.11,113.76 171.6,112.27 171.6,110.65 172.32,109.93 172.32,103.55 169.63,100.86 169.63,98.82 169.53,98.71 168.62,98.71 168.51,98.6 v4(168.51,98.34)
  BOTTOM w0.17: U50000.AF4 170.05,114.53 v4(170.05,114.48) ; v4(168.51,98.34) U51100.T2
FBD_EDC4: length 20.1
  L8 w0.109: v4(184.71,113.87) 185.08,113.5 185.08,112.78 185.37,112.49 185.37,112.11 185.47,112.01 185.47,111.12 185.85,110.74 185.85,103.43 188.03,99.16 188.51,98.21 188.76,97.96 190.18,97.96 v4(190.55,97.59)
  BOTTOM w0.17: v4(184.71,113.87) 184.67,113.87 184.4,114.14 U50000.E3 ; U51200.C2 v4(190.55,97.59)
FBD_EDC5: length 21.3
  L10 w0.109: v4(182.94,111.36) 182.94,109.3 185.78,106.46 185.78,98.07 185.67,97.97 184.36,97.97 184.18,97.78 184.18,97.39 184,97.21 183.17,97.21 183.06,97.32 v4(183.06,97.59)
  BOTTOM w0.17: v4(183.06,97.59) 183.05,97.59 U51200.C13 ; v4(182.94,111.36) 182.78,111.36 182.47,111.67 182.47,112.24 182.69,112.47 182.69,113.08 U50000.H2
FBD_EDC6: length 35.9
  L8 w0.109: v4(182.3,87.84) 182.68,87.46 183.27,87.46 183.42,87.62 183.42,88.74 183.2,88.96 181.17,88.96 180.28,89.86 180.28,92.94 179.73,93.48 179.07,94.14 178.96,94.26 178.96,111.12 176.78,113.3 176.65,113.3 176.09,113.86 176.09,114.63 176.41,114.95 v4(176.41,116.68)
  BOTTOM w0.17: U51200.T13 v4(182.3,87.84) ; v4(176.41,116.68) U50000.U6
FBD_EDC7: length 33.5
  L3 w0.109: v4(190.55,88.59) 190.17,88.97 188.83,88.97 188.67,89.13 188.67,91.14 188.14,91.67 188.14,92.55 187.7,92.99 187.7,94.67 186.14,96.23 186.14,96.69 185.66,97.17 185.13,97.17 184.94,97.36 184.94,97.84 184.8,97.98 184.32,97.98 184.17,98.13 184.17,100.06 183.4,100.83 183.4,103.54 180.41,106.52 179.15,110.18 v4(179.15,115.23)
  BOTTOM w0.17: v4(190.55,88.59) U51200.T2 ; v4(179.15,115.23) U50000.M5
FBD_WCK01: length 35.5
  L8 w0.097: v4(170.01,88.59) 170.22,88.8 170.22,89.03 170.38,89.2 170.38,94.72 170.65,94.99 171.4,94.99 172.27,95.86 172.27,110.43 171.37,111.32 171.37,111.84 169.67,113.54 169.67,113.97 169.44,114.19 169.44,114.78 169.75,115.09 169.75,115.37 169.44,115.68 169.44,116.2 169.66,116.42 169.66,116.87 168.79,117.73 168.41,117.73 168.09,118.05 168.09,118.58 v4(168.14,118.62)
  BOTTOM w0.122: U50000.AJ8 167.74,117.82 167.74,118.03 168.08,118.37 168.08,118.57 168.14,118.62 v4(168.14,118.62) ; v4(170.01,88.59) U51100.D4
FBD_WCK01#: length 35.5
  L8 w0.097: v4(168.46,118.2) 168.7,117.96 168.88,117.96 169.88,116.96 169.88,116.32 169.67,116.11 169.67,115.77 169.98,115.46 169.98,115 169.67,114.69 169.67,114.29 169.9,114.06 169.9,113.63 171.6,111.93 171.6,111.42 172.49,110.52 172.49,95.76 171.49,94.77 170.74,94.77 170.6,94.63 170.6,89.1 170.44,88.94 170.44,88.73 170.59,88.58 v4(170.75,88.58)
  BOTTOM w0.122: U51100.D5 170.71,88.59 170.76,88.59 170.75,88.59 v4(170.75,88.58) ; v4(168.46,118.2) 168.23,118.2 167.96,117.93 167.96,117.63 U50000.AJ7
FBD_WCK23: length 25.3
  L8 w0.097: v4(170.8,117.98) 170.8,118.07 170.9,118.17 171.05,118.17 171.73,117.49 171.73,116.99 171.6,116.85 171.6,116.38 171.83,116.15 171.83,115.69 171.65,115.52 171.65,114.57 171.59,114.51 171.59,113.51 174.11,110.99 174.11,99.54 173.97,99.39 173.97,97.34 173.87,97.24 173.74,97.24 v4(173.6,97.38)
  BOTTOM w0.122: v4(170.8,117.98) U50000.AD8 ; v4(173.6,97.38) 173.64,97.42 173.8,97.58 174.52,97.58 U51100.R11
FBD_WCK23#: length 25.3
  L8 w0.097: v4(173.6,96.78) 173.83,97.02 173.97,97.02 174.19,97.24 174.19,99.3 174.34,99.45 174.34,111.08 171.81,113.6 171.81,114.42 171.88,114.48 171.88,115.43 172.05,115.6 172.05,116.24 171.82,116.47 171.82,116.76 171.95,116.89 171.95,117.58 171.14,118.39 170.9,118.39 170.8,118.49 v4(170.8,118.68)
  BOTTOM w0.122: v4(170.8,118.68) U50000.AD9 ; v4(173.6,96.78) 174.03,97.21 U51100.R10
FBD_WCK45: length 24.5
  L3 w0.097: v4(189.05,97.58) 189.05,97.63 189.14,97.73 189.35,97.73 189.45,97.63 189.45,97.35 189.29,97.2 188.85,97.2 188.63,97.42 188.63,98.44 187.98,99.1 187.98,100.42 187.81,100.59 187.81,104.2 182.44,109.56 182.44,111.17 182.56,111.29 182.56,112.72 181.52,113.76 181.52,113.93 181.64,114.05 181.64,114.73 181.4,114.96 181.4,115.9 v4(181.33,115.97)
  BOTTOM w0.122: v4(189.05,97.58) 189.41,97.21 U51200.D4 ; U50000.J6 181.33,116.01 v4(181.33,115.97)
FBD_WCK45#: length 24.5
  L3 w0.097: v4(181.29,116.66) 180.96,116.06 180.96,115.84 181.18,115.48 181.18,114.87 181.41,114.64 181.41,114.14 181.29,114.02 181.29,113.66 182.33,112.62 182.33,111.38 182.22,111.26 182.22,109.47 187.59,104.1 187.59,100.5 187.75,100.33 187.75,99 188.41,98.35 188.41,97.33 188.89,96.85 189.02,96.85 v4(189.05,96.82)
  BOTTOM w0.122: U51200.D5 189.05,96.84 v4(189.05,96.82) ; U50000.J7 181.6,116.97 v4(181.29,116.66)
FBD_WCK67: length 38.7
  L10 w0.097: v4(178.46,118.01) 178.46,117.99 177.86,117.4 177.86,116.94 178.49,116.32 179.02,116.32 179.3,116.04 179.3,115.62 179.53,115.39 179.53,115.01 179.11,114.6 179.11,113.65 178.72,113.26 178.72,105.3 180.87,103.14 180.87,94.96 181.85,93.98 184.85,93.98 185.08,94.21 185.42,94.21 185.77,93.86 186.25,93.86 186.52,93.59 186.52,90.53 186.02,90.03 186.01,90.02 185.09,89.1 184.79,89.1 v4(184.55,89.34)
  BOTTOM w0.122: U51200.R11 184.18,88.97 v4(184.55,89.34) ; v4(178.46,118.01) 178.46,117.99 U50000.P8
FBD_WCK67#: length 38.6
  L10 w0.097: v4(178.45,117.36) 178.42,117.39 178.18,117.39 178.09,117.3 178.09,117.03 178.58,116.54 179.11,116.54 179.52,116.13 179.52,115.72 179.75,115.48 179.75,114.92 179.34,114.5 179.34,113.56 178.94,113.17 178.94,105.39 181.1,103.23 181.1,95.05 181.94,94.21 184.76,94.21 184.98,94.44 185.51,94.44 185.87,94.08 186.34,94.08 186.74,93.68 186.74,90.44 186.18,89.87 186.18,89.87 185.18,88.88 184.83,88.88 v4(184.54,88.59)
  BOTTOM w0.122: v4(184.54,88.59) 184.54,88.62 184.88,88.96 U51200.R10 ; U50000.P7 178.42,117.36 v4(178.45,117.36)
FBD_WCKB01: length 36.4
  L8 w0.097: v4(169.36,118.04) 169.51,118.19 169.65,118.19 169.74,118.1 169.74,117.98 170.11,117.61 170.27,117.61 171.12,116.75 171.12,116.41 170.88,116.17 170.88,115.7 171.17,115.41 171.17,115.06 171.01,114.91 171.01,113.33 171.01,113.15 172.72,111.44 172.72,111.28 173.22,110.78 173.22,99.74 173,99.52 173,95.47 171.91,94.38 171.91,92.93 171.55,92.57 171.55,91.26 172.35,90.46 172.35,89.04 173.4,87.99 174.06,87.99 174.3,88.24 174.3,88.39 v4(174.51,88.59)
  BOTTOM w0.122: v4(169.36,118.04) U50000.AG8 ; v4(174.51,88.59) U51100.D11
FBD_WCKB01#: length 36.4
  L8 w0.097: v4(173.76,88.59) 173.96,88.59 174.08,88.47 174.08,88.33 173.96,88.22 173.49,88.22 172.57,89.13 172.57,90.55 171.77,91.35 171.77,92.48 172.13,92.84 172.13,94.29 173.22,95.38 173.22,99.42 173.44,99.64 173.44,110.87 172.94,111.37 172.94,111.54 171.24,113.24 171.24,114.81 171.39,114.97 171.39,115.51 171.11,115.79 171.11,116.07 171.35,116.32 171.35,116.84 170.36,117.83 170.21,117.83 169.97,118.07 169.97,118.19 169.74,118.42 169.49,118.42 169.38,118.53 v4(169.38,118.73)
  BOTTOM w0.122: U50000.AG9 169.03,118.38 v4(169.38,118.73) ; v4(173.76,88.59) U51100.D10
FBD_WCKB23: length 33.4
  L8 w0.097: v4(170.01,96.83) 170.01,96.75 170.55,96.22 171.03,96.22 171.36,96.55 171.36,100.31 170.79,100.88 170.79,110.33 169.79,111.32 169.79,112.25 169.27,112.77 169.2,112.77 168.94,113.04 168.94,113.98 169.18,114.22 169.18,114.82 169.07,114.92 169.07,115.47 169.12,115.52 169.12,116.09 168.83,116.38 168.19,116.38 167.77,116.8 167.77,117.14 167.78,117.15 167.78,118.78 168.1,119.1 171.53,119.1 171.83,118.81 171.83,118.8 171.84,118.79 171.84,118.61 172.06,118.39 172.44,118.16 172.45,118.16 v4(172.47,118.16)
  BOTTOM w0.122: U51100.R4 170.02,96.83 170.01,96.83 v4(170.01,96.83) ; v4(172.47,118.16) 172.45,118.15 172.45,118.12 172.22,117.88 172.14,117.75 172.14,117.55 172.1,117.47 U50000.AC7
