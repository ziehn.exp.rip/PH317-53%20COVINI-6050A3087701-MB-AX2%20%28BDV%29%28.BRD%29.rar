# Allegro board PH317-53 COVINI-6050A3087701-MB-AX2 (BDV)(.BRD).brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
HDMI_OUT_CLKN: length 4.3
  TOP w0.076: C51700.2 283.97,71.87 284.28,71.87 284.45,72.04 284.45,72.72 285.3,73.57 285.94,73.57 286.04,73.48 U56400.45
HDMI_OUT_CLKP: length 4.3
  TOP w0.076: U56400.44 286.06,73.88 285.93,73.74 285.23,73.74 284.28,72.79 284.28,72.11 284.2,72.04 283.96,72.04 C51701.2
HDMI_OUT_D0N: length 3.5
  TOP w0.076: C51702.2 283.94,73.65 284.26,73.65 284.98,74.37 286.03,74.37 286.13,74.28 U56400.43
HDMI_OUT_D0P: length 3.5
  TOP w0.076: U56400.42 286.59,74.68 286.5,74.59 286.19,74.59 286.14,74.54 284.91,74.54 284.18,73.82 283.99,73.82 C51703.2
HDMI_OUT_D1N: length 3.7
  TOP w0.076: U56400.40 286.54,75.57 286.11,75.57 285.98,75.7 285.52,75.7 284.66,76.55 284.66,76.92 284.54,77.04 284.34,77.04 C51704.2
HDMI_OUT_D1P: length 3.6
  TOP w0.076: C51705.2 284.35,77.21 284.61,77.21 284.83,76.99 284.83,76.62 285.59,75.87 286.62,75.87 U56400.39
HDMI_OUT_D2N: length 4.6
  TOP w0.076: C51706.2 284.34,78.82 284.63,78.82 285.39,78.06 285.39,76.78 285.73,76.43 286.05,76.43 286.21,76.28 U56400.38
HDMI_OUT_D2P: length 4.6
  TOP w0.076: U56400.37 286.14,76.68 286.07,76.6 285.81,76.6 285.56,76.85 285.56,78.13 284.7,78.99 284.35,78.99 C51707.2
HDMI_OUT_R_HPD: length 17.4
  TOP w0.102: v3(303.43,64.77) 303.58,64.93 R56620.1 304.16,64.96 D56652.10 D56652.1 ; v1(292.27,70.97) 291.92,70.97 291.71,71.18 U56400.12
  L8 w0.102: v1(292.27,70.97) 294.64,70.97 296.36,69.24 298.35,69.24 302.82,64.77 v3(303.43,64.77)
HDMI_RET_HPD: length 6.2
  TOP w0.102: U56400.5 288.91,70.68 288.54,70.31 288.54,69.61 288.63,69.52 288.63,68.82 288.63,68.82 288.63,67.68 288.7,67.61 R56471.2 288.57,67.16 v2(287.59,66.18)
HDMI_RET_SCL: length 21.1
  TOP w0.109: U56400.35 287.71,77.73 287.37,78.06 v1(287.02,78.06)
  L3 w0.076: v1(297.02,69.96) 295.98,71 295.98,77.45 294.08,79.35 288.31,79.35 v1(287.02,78.06)
  BOTTOM w0.109: v1(297.02,69.96) 297.25,69.73 R56674.1
HDMI_RET_SDA: length 29.3
  TOP w0.109: v1(287.96,78.08) 287.96,78.07 288.11,77.92 U56400.34 ; R56671.1 299.82,63.58 v3(299.29,63.06)
  L3 w0.076: v1(287.96,78.08) 284.17,74.29 284.17,70.06 285.29,68.94 287.17,68.94 289.23,66.88 295.21,66.88 296.58,65.51 296.59,65.51 299.04,63.06 v3(299.29,63.06)
HDMI_TXSCL: length 3.6
  TOP w0.109: U56400.29 290.11,78.67 289.6,79.18 v2(289.38,79.18) 288.85,79.71 R56411.1
HDMI_TXSDA: length 4
  TOP w0.109: U56400.30 289.72,77.36 289.72,77.88 289.78,77.94 289.78,78.29 289.43,78.64 289.2,78.64 288.34,79.51 v2(288.15,79.51) 288.13,79.51 287.96,79.68 R56410.1
HP_L: length 9
  TOP w0.254: R605.1 17.86,48.42 17.86,48.88 17.86,48.88 17.86,49.25 R606.2 17.24,49.28 v3(17.01,49.51) 16.86,49.66 C602.2 ; v1(19.99,51.95) 19.99,52.54 20.01,52.56 U500.32
  L3 w0.254: v3(17.01,49.51) 17.01,50.22 18.39,51.59 19.56,51.59 19.92,51.95 v1(19.99,51.95)
HP_R: length 11.3
  TOP w0.254: C603.2 16.84,48.44 16.87,48.41 v1(17.01,48.41) 17.01,47.53 v2(16.89,47.4) 17.58,47.4 R604.1 17.68,46.62 R607.2 ; v1(19.99,51.13) 20.04,51.13 20.51,51.61 20.51,52.19 20.41,52.29 U500.33
  L3 w0.254: v1(17.01,48.41) 17.75,49.15 17.75,50.24 18.6,51.08 19.77,51.08 19.82,51.13 v1(19.99,51.13)
HP_R_L: length 22.2
  TOP w0.254: R605.2 v2(19.55,48.39) 19.73,48.21 v1(19.73,47.73)
  BOTTOM w0.254: CN603.3 32.53,36.85 32.28,36.6 27.53,36.6 20.44,43.69 20.44,46.97 19.73,47.68 v1(19.73,47.73)
HP_R_R: length 21.9
  TOP w0.254: R604.2 18.76,47.27 19.4,47.27 19.85,46.83 v3(19.85,46.69)
  BOTTOM w0.254: v3(19.85,46.69) 19.85,46.69 19.85,43.55 27.3,36.1 32.28,36.1 32.53,36.35 CN603.2
HPGP_W_DISABLE#: length 58
  TOP w0.102: Q1312.3 289.1,24.3 289.1,24.85 v1(289.11,24.87)
  L10 w0.102: v1(289.11,24.87) 289.11,25.58 284.79,29.9 282.78,29.9 279.19,33.49 279.19,37.62 268.3,48.51 268.3,52.04 267.68,52.66 267.05,52.66 v3(266.47,53.24) 265.22,53.24 264.99,53.47 264.18,53.47 261.06,56.59 258.36,56.59 258.09,56.86 254.52,56.86 v1(254.33,57.05)
  BOTTOM w0.089: U4710.AR18 254.01,56.79 254.28,57.05 v1(254.33,57.05)
  BOTTOM w0.102: v3(266.47,53.24) 266.67,53.24 266.82,53.39 267.43,53.39 267.51,53.47 267.58,53.47 R4824.1
HPS: length 34.9
  TOP w0.102: v3(12.7,57.99) 12.85,58.15 R502.2
  L3 w0.102: v3(12.7,57.99) 15.16,57.99 16.07,57.09 16.07,48.57 18.4,46.23 20.27,46.23 27.5,38.99 v1(29.92,38.99)
  BOTTOM w0.102: v1(29.92,38.99) 32.03,38.99 32.2,39.17 32.94,39.17 33.12,39.35 CN603.8
HW_I_ADC: length 167
  L8 w0.102: v1(188.74,37.27) 182.01,30.53 173.76,30.53 172.83,29.59 159.08,29.59 158.6,30.08 139.9,30.08 139.53,29.71 128.95,29.71 120.58,38.08 103.92,38.08 103.16,38.84 103.12,38.84 100.58,41.38 91.19,41.38 88.47,44.1 66.29,44.1 60.83,49.56 54.57,49.56 v1(53.93,48.92)
  BOTTOM w0.102: R351.1 200.2,45.21 C60008.1 194.63,45.21 188.74,39.32 v1(188.74,37.27) ; C60007.1 53.93,49.53 v1(53.93,48.92) 53.93,48.56 54.48,48.01 U60000.7
I2C_CLK_LED: length 9.6
  BOTTOM w0.109: U702.25 139.04,40.92 138.2,41.76 v2(137.64,41.76) 137.6,41.76 137.54,41.82 136.97,41.82 136.57,41.41 136.57,41.27 135.16,39.86 133.78,39.86 133.36,40.27 Q700.1 132.07,40.76 R701.2
I2C_DATA_LED: length 5.9
  BOTTOM w0.109: U702.26 139.54,41.18 v2(138.98,41.74) 138.43,42.29 137.76,42.29 137.75,42.31 136.77,42.31 136.41,41.95 R700.2 135.86,41.95 135.75,42.06 Q700.4
I2C_RST#: length 100.2
  L8 w0.102: v1(129.84,46.79) 129.84,47.61 131.71,49.48 131.71,50.91 135.16,54.36 136.05,54.36 144.55,62.86 144.55,63.83 143.61,64.77 143.61,66.04 143.86,66.3 143.86,69.14 143.86,69.31 143.99,69.44 143.99,74.35 143.38,74.96 143.38,94.81 143.38,94.81 143.38,95.63 144.5,96.75 144.5,98.8 143.99,99.31 143.99,112.39 144.74,113.14 144.74,120.24 145.84,121.34 v1(145.84,124.74)
  BOTTOM w0.102: R51526.2 147.01,127.13 R51525.1 145.54,125.66 145.54,125.05 v1(145.84,124.74) ; Q51530.5 Q51530.2 135.04,45.14 134.46,44.56 v2(133.75,44.56) 133.75,44.56 132.94,43.74 131.14,43.74 130.91,43.97 130.43,43.97 130.1,44.3 Q51520.5 Q51520.2 130.1,46.54 v1(129.84,46.79)
I2CB_SCL_G: length 23.1
  TOP w0.109: v4(155.4,117.28) 154.94,116.82 152.98,116.82 152.81,116.64 152,116.64 150.06,114.69 150.06,110.63 150.5,110.18 150.5,104.27 147.74,101.51 147.74,101.36 147.75,101.35 v2(147.75,101.32) 148.26,100.81 R51500.1
  BOTTOM w0.109: v4(155.4,117.28) U50000.BG8
I2CB_SDA_G: length 22.7
  TOP w0.109: v4(156.03,117.3) 155.89,117.16 155.89,117.08 155.14,116.33 153.18,116.33 153.01,116.15 152.6,116.15 152.21,116.15 150.55,114.49 150.55,110.83 150.99,110.38 150.99,104.07 148.94,102.02 v2(148.94,100.89) 149.14,100.69 R51501.1
  BOTTOM w0.109: U50000.BF8 155.7,117.63 v4(156.03,117.3)
I2CC_SCL: length 10.9
  TOP w0.109: U67000.35 133.65,51.06 v1(133.91,50.8) 134.1,50.8 134.64,50.27 134.64,49.25 R67007.2
  L10 w0.076: v1(130.6,45.37) 130.6,46.71 133.52,49.64 133.52,50.42 v1(133.91,50.8)
  BOTTOM w0.109: Q51520.3 v1(130.6,45.37)
I2CC_SCL_G: length 91
  L8 w0.076: v1(132,46.79) 137.03,46.79 141.17,50.93 142.05,50.93 149.54,58.42 149.54,60.55 150.3,61.31 150.3,67.85 149.81,68.33 149.81,72.88 151.01,74.08 151.01,79.87 148.12,82.77 148.12,92.8 148.55,93.23 148.55,95.8 150.46,97.71 150.46,109.56 149.5,110.52 149.5,114.6 152.61,117.71 153.63,117.71 154.01,118.09 v4(154.63,118.09)
  BOTTOM w0.109: R51521.1 131.7,45.11 TP51521.1 132,46.41 v1(132,46.79) ; U50000.BG9 154.73,118.11 154.66,118.11 v4(154.63,118.09)
I2CC_SCL_R_G: length 3.7
  BOTTOM w0.109: Q51520.4 131.29,44.62 R51521.2 132.39,44.23 v2(132.48,44.33) 132.28,44.53 132.28,45.27 132.66,45.65 R51523.1
I2CC_SDA: length 11
  TOP w0.109: U67000.34 133.25,51.9 133.16,51.81 v3(133.16,50.8) 133.6,50.36 133.6,49.4 R67006.2
  L10 w0.076: v1(129.59,45.37) 129.52,45.37 129.45,45.44 129.45,47.09 v3(133.16,50.8)
  BOTTOM w0.109: v1(129.59,45.37) 129.6,45.36 Q51520.6
I2CC_SDA_G: length 90
  L8 w0.076: v1(131.34,46.82) 132.33,47.81 132.33,50.53 135.28,53.48 143.35,53.48 146.68,56.81 146.68,56.99 146.68,64.49 147.29,65.1 147.29,71.4 147.8,71.91 147.8,74 147.43,74.36 147.43,100.37 150,102.94 150,109.08 148.87,110.21 148.87,114.61 152.14,117.89 153.17,117.89 v4(154,118.72)
  BOTTOM w0.109: v4(154,118.72) 154,118.67 U50000.BH9 ; v1(131.34,46.82) 131.34,47.48 R51522.1 132.12,47.53 TP51522.1
I2CC_SDA_R_G: length 6.8
  BOTTOM w0.109: R51524.1 132.74,48.11 132.47,48.38 R51522.2 130.45,48.38 v2(130.09,48.02) 129.43,47.36 129.43,46.34 129.6,46.17 Q51520.1
I2CS_SCL_G: length 85.5
  L8 w0.076: v1(139.42,44.99) 140.35,45.92 142.82,45.92 143.86,46.96 143.86,48.82 146.69,51.66 146.69,52.79 150,56.09 150,60.36 150.26,60.63 150.78,61.15 150.78,73.21 151.47,73.89 151.47,80.06 148.57,82.96 148.57,92.61 149.03,93.07 149.03,94.56 150.92,96.44 150.92,109.99 149.96,110.95 149.96,114.41 152.14,116.6 152.14,116.99 152.53,117.38 v4(153.3,117.38)
  BOTTOM w0.109: TP51531.1 138.83,45.69 R51531.1 139.26,44.83 v1(139.42,44.99) ; v4(153.3,117.38) U50000.BJ8
I2CS_SCL_R_G: length 2.9
  BOTTOM w0.109: R51533.1 138.1,44.25 137.98,44.38 R51531.2 137.98,45.39 v2(137.69,45.67) 137.66,45.64 Q51530.4
I2CS_SDA_G: length 91.4
  L8 w0.076: v1(134.24,43.72) 139.37,43.72 141.02,45.37 142.92,45.37 144.39,46.84 144.39,48.7 147.15,51.47 147.15,52.6 150.45,55.9 150.45,60.17 151.24,60.96 151.24,73.02 151.93,73.7 151.93,80.25 149.03,83.15 149.03,92.42 149.22,92.61 149.49,92.88 149.49,94.37 151.11,95.98 151.37,96.25 151.37,110.37 150.42,111.33 150.42,114.57 152.43,116.59 153.21,116.59 v4(154,117.38)
  BOTTOM w0.109: TP51532.1 133.8,43.29 v1(134.24,43.72) 134.72,43.72 R51532.1 ; v4(154,117.38) U50000.BH8
I2CS_SDA_R_G: length 3.1
  BOTTOM w0.109: R51534.1 136.98,43.06 v2(136.47,43.56) 136.42,43.62 R51532.2 135.68,44.36 135.4,44.64 Q51530.1
I_ADP_R: length 4.9
  BOTTOM w0.102: U1.72 203.09,41.57 202.82,41.84 202.08,41.84 v2(201.55,42.37) 201.06,42.85 R351.2 C351.2
ICM_SH_01: length 3.6
  BOTTOM w0.102: U52000.32 147.87,49.18 v2(148.05,49.36) 148.65,49.36 C52010.2 R52010.2
ICM_SH_02: length 5.2
  BOTTOM w0.102: R52020.2 C52020.2 141.42,46.07 141.42,46.61 v2(141.86,47.04) 143,48.19 143.86,48.19 144.06,48.38 U52000.7
IDCHG: length 156.7
  L8 w0.102: v1(54.58,48.97) 54.97,49.36 60.72,49.36 66.18,43.89 88.39,43.89 93.65,38.63 103.07,38.63 103.83,37.87 120.49,37.87 128.87,29.5 139.61,29.5 139.99,29.87 158.28,29.87 158.76,29.39 172.91,29.39 173.85,30.33 182.44,30.33 v1(189.38,37.27)
  BOTTOM w0.102: U60000.8 55.28,47.99 54.58,48.7 v1(54.58,48.97) 54.58,49.56 C60005.1 ; v1(189.38,37.27) 189.38,38.59 v2(191.89,41.11) R307.2
IFPC_RSET: length 2.9
  TOP w0.102: R51615.2 155.51,126.97 155.7,126.78 156.21,126.78 156.4,126.59 156.4,126.01 156.49,125.92 156.66,125.92 156.84,125.74 v4(156.84,125.61)
  BOTTOM w0.102: U50000.BD20 156.84,125.82 v4(156.84,125.61)
IFPCD_PLLVDD: length 5.5
  TOP w0.254: C51616.1 156.32,125.44 v6(156.75,125.01)
  L3 w0.381: v4(155.28,127.83) 156.09,127.83 156.8,127.12 156.8,126.4 156.35,125.95 156.35,125.41 v6(156.75,125.01)
  BOTTOM w0.254: v6(156.75,125.01) 157.08,124.68 U50000.BD18
IFPE_PLLVDD: length 2.1
  TOP w0.254: v4(156.8,122.91) 157.03,123.14 157.58,123.14 157.91,123.48 C51720.1
  BOTTOM w0.3: v4(156.8,122.91) 156.8,122.88 U50000.BD15
IFPE_RSET: length 1.1
  TOP w0.102: v4(157.42,123.66) 156.98,123.66 156.87,123.77 R51721.2
  BOTTOM w0.102: U50000.BD17 v4(157.42,123.66)
ILIM_HI: length 5.8
  TOP w0.102: U2501.16 284.41,33.42 283.64,34.19 v2(283.13,34.19) 283.13,34.37 282.35,35.16 281.01,35.16 280.39,34.54 R2551.1
ILIM_LO: length 7.4
  TOP w0.102: R2552.1 280.9,35.54 283.2,35.54 284.91,33.83 U2501.15
IMVP_PSYS: length 140.6
  TOP w0.102: R66195.1 80.76,173.17 80.36,172.77 v1(80.21,172.77)
  L5 w0.102: v1(80.21,172.77) 80.21,172.19 78.57,170.55 78.57,153.01 81.12,150.45 81.12,141.89 77.98,138.74 77.98,129.93 75.82,127.77 75.82,119.38 66.8,110.37 66.8,103.32 65.55,102.07 65.55,98.38 67.28,96.65 67.28,89.79 67.66,89.41 67.66,86.13 62.54,81.02 62.54,79.79 58.94,76.19 58.48,76.19 58.24,75.95 58.24,75.49 55.37,72.62 v1(55.37,48.95)
  BOTTOM w0.102: v1(55.37,48.95) 55.58,48.73 55.58,47.81 U60000.9
INTRUDER#: length 13.2
  TOP w0.102: v1(258.64,43.67) 259.03,43.29 259.03,40.95 261.97,38 261.97,36.5 261.57,36.1 v2(261.57,34.17) 261.57,33.81 261.51,33.76 R4833.1
  BOTTOM w0.089: U4710.BB44 258.21,44.1 v1(258.64,43.67)
INV_PWM_PCH: length 240.3
  L8 w0.102: v1(37.21,58.8) 40.08,58.8 43.76,55.12 46.17,55.12 48.66,52.63 58.33,52.63 66.38,44.58 88.57,44.58 89.91,43.23 101.15,43.23 102.45,41.94 103.2,41.94 106.47,38.66 120.57,38.66 127.95,31.29 133.62,31.29 134.17,30.74 151.69,30.74 152.06,31.11 166.6,31.11 167,30.71 172.79,30.71 172.84,30.66 173.17,30.66 173.22,30.71 173.37,30.71 173.65,30.99 181.39,30.99 189.16,38.76 201.32,38.76 203.43,40.87 229.27,40.87 231.3,42.9 233.07,42.9 234.34,44.17 241.96,44.17 242.26,44.48 243.22,44.48 243.73,43.97 245.26,43.97 246.33,42.9 248.61,42.9 251.02,40.49 v1(253.44,40.49)
  BOTTOM w0.089: v1(253.44,40.49) 253.74,40.49 254.65,41.41 254.65,41.5 255.02,41.87 U4710.AU48
  BOTTOM w0.102: R3005.1 36.27,60.55 36.27,59.64 37.11,58.8 v1(37.21,58.8)
IRMT_HOLD_RST#: length 132.7
  TOP w0.102: R4823.1 266.31,50.19 v1(266.49,50.37)
  L5 w0.102: v1(266.49,50.37) 266.49,48.92 263.34,45.77 263.34,43.95 261.06,41.66 260.31,41.66 258.84,40.2 257.92,40.2 257.22,39.5 245.87,39.5 245.23,38.87 243.68,38.87 241.32,36.5 238.83,36.5 238.12,37.21 232.69,37.21 231.59,36.11 218.5,36.11 217.4,37.21 208.11,37.21 207.17,38.15 202.89,38.15 202.74,38.31 199.36,38.31 197.23,40.44 190.24,40.44 189.35,41.33 188.06,41.33 187.74,41.01 174.87,41.01 174.45,40.59 172.84,40.59 171.52,41.91 167.89,41.91 167.69,41.71 166.75,41.71 166.02,42.43 150.43,42.43 v1(149.88,41.89)
  BOTTOM w0.102: U50020.2 149.07,40.26 R50021.1 149.09,40.68 149.08,40.7 149.08,40.89 TP50021.1 149.88,41.68 v1(149.88,41.89)
ISCT_WLANPW_EN#: length 79.1
  TOP w0.102: Q1300.2 v3(270.31,24.03)
  L8 w0.102: v1(205.38,39.37) 205.99,38.76 207.51,38.76 209.22,40.47 227.78,40.47 231.31,36.94 237.82,36.94 238.53,36.22 239.95,36.22 240.69,36.96 245.64,36.96 247.09,35.51 252.85,35.51 254.76,33.61 254.76,30.48 255.8,29.44 257.4,29.44 257.71,29.75 266.21,29.75 269.16,26.8 269.16,24.82 269.95,24.03 v3(270.31,24.03)
  BOTTOM w0.102: U1.78 205.49,39.48 v1(205.38,39.37)
IST_TRIG: length 13.1
  TOP w0.102: TP4523.1 127.48,109.63 v1(127.48,117.33)
  BOTTOM w0.076: v1(127.48,117.33) 127.48,117.17 127.12,116.82 126.44,116.82 125.89,117.37 125.89,117.83 125.69,118.03 125.3,118.03 U4555.E3
ITP_PMODE: length 2.9
  TOP w0.089: v1(252.04,62.74) 251.7,62.74 251.41,63.03 v2(251.41,63.03) 250.83,63.62 R4891.2
  BOTTOM w0.089: v1(252.04,62.74) 252.04,62.94 252.25,63.15 U4710.AL3
KB_BLON: length 74.7
  L3 w0.102: v1(200.66,30.56) 200.25,30.97 192.32,30.97 192.04,30.69 179.05,30.69 178.11,29.75 177.19,29.75 174.68,27.23 161.77,27.23 160.35,27.23 v1(158.11,29.47) 139.51,29.47 v3(138.27,28.23)
  BOTTOM w0.102: Q251.G 157.11,30.47 v1(158.11,29.47) ; U1.32 200.29,26.84 200.76,27.31 200.76,28.07 200.45,28.38 200.45,29.88 200.66,30.08 v1(200.66,30.56) ; Q702.G 138.74,27.77 v3(138.27,28.23)
KB_RST#: length 71.8
  TOP w0.089: v1(261.08,46.08) 261.49,45.67 261.72,45.67
  TOP w0.102: R4723.1 265.19,46.41 v2(263.29,46.41) 263.04,46.41 262.3,45.67 261.72,45.67
  L10 w0.102: v1(212.49,29.72) 216.77,29.72 216.79,29.75 218.96,29.75 219.12,29.59 222.36,29.59 222.82,29.14 231.7,29.14 232.81,30.24 237.61,30.24 238.94,31.58 241.76,31.58 245.07,34.88 248.13,34.88 249.07,35.82 249.07,38.23 249.87,39.03 249.87,39.53 252.9,42.56 256.71,42.56 256.95,42.8 256.95,43.8 257.3,44.16 257.94,44.16 259.86,46.08 v1(261.08,46.08)
  BOTTOM w0.089: U4710.BE39 259.04,46.49 259.75,46.49 260.04,46.21 260.96,46.21 v1(261.08,46.08)
  BOTTOM w0.102: v1(212.49,29.72) 212.49,29.43 211.81,28.75 211.81,26.63 211.49,26.31 U1.4
KEYBOARD_ID: length 25.3
  L3 w0.102: v1(206.55,30.08) 206.55,29.68 207.07,29.16 210.08,29.16 212.87,26.37 v1(212.87,26.22)
  BOTTOM w0.102: R392.2 215.45,22.4 215.27,22.58 R393.2 214.88,23.45 213.94,24.39 v2(213.94,24.72) 213.94,25 212.87,26.06 v1(212.87,26.22) ; U1.86 208.69,39.89 207.92,39.12 207.92,36.94 206.88,35.9 206.88,33.9 206.82,33.84 206.82,33.5 206.88,33.44 206.88,30.41 v1(206.55,30.08)
LAN_DEBUG: length 3.7
  TOP w0.102: R405.1 284.23,95.07 283.82,95.48 v2(283.71,95.48) 283.87,95.63 283.87,96.8 283.68,96.99 U400.5
LAN_LED2: length 3.2
  TOP w0.102: TP401.1 283.98,105.69 R419.1 284.88,104.8 U400.23
LAN_MDI0N: length 8.8
  TOP w0.089: v3(291.85,98.14) 291.65,97.94 291.4,97.94 291.07,98.27 290.75,98.27 290.63,98.39 D402.2 D402.9 288.7,98.39 288.58,98.27 288.14,98.27 287.42,98.99 287.23,98.99 287.11,99.11 U400.12
  BOTTOM w0.089: v3(291.85,98.14) 291.65,97.94 290.77,97.94 290.68,98.03 290.68,98.36 290.59,98.45 U401.2
LAN_MDI0P: length 8.7
  TOP w0.089: U400.11 287.02,98.71 287.04,98.73 287.31,98.73 288.04,98.01 288.58,98.01 288.7,97.89 D402.10 D402.1 290.59,97.89 290.71,98.01 290.97,98.01 291.29,97.68 291.65,97.68 v1(291.85,97.48)
  BOTTOM w0.089: U401.1 290.59,97.18 290.68,97.27 290.68,97.6 290.77,97.68 291.65,97.68 v1(291.85,97.48)
LAN_MDI1N: length 11.7
  TOP w0.089: v3(292.13,100.07) 291.89,99.83 290.69,99.83 290.63,99.89 D402.5 D402.6 288.7,99.89 288.59,99.77 288.09,99.77 287.61,100.26 286.94,100.26 286.89,100.31 U400.15
  BOTTOM w0.089: U401.6 290.07,103.53 290.58,103.02 291.14,103.02 291.56,102.59 291.56,99.95 291.65,99.87 291.93,99.87 v3(292.13,100.07)
LAN_MDI1P: length 11.7
  TOP w0.089: U400.14 287.08,99.91 287.15,99.98 287.52,99.98 287.98,99.52 288.57,99.52 288.7,99.39 D402.7 D402.4 290.63,99.39 290.81,99.57 291.97,99.57 v1(292.13,99.41)
  BOTTOM w0.089: v1(292.13,99.41) 291.93,99.61 291.55,99.61 291.31,99.85 291.31,102.49 291.03,102.76 290.59,102.76 290.08,102.26 U401.5
LAN_MDI2N: length 14.7
  TOP w0.089: v1(291.57,105.76) 291.37,105.56 291.25,105.56 291.08,105.73 291.08,107.14 290.72,107.5 289.76,107.5 289.24,106.98 289.24,106.58 289.12,106.45 D403.2 D403.9 289.12,104.53 289.22,104.42 289.22,103.96 289.35,103.83 289.35,102.14 289.04,101.83 287.94,101.83 287.57,101.45 287.09,101.45 287.03,101.51 U400.18
  BOTTOM w0.089: U401.8 290.07,106.07 290.58,105.56 291.37,105.56 v1(291.57,105.76)
LAN_MDI2P: length 14.7
  TOP w0.089: U400.17 287.07,101.11 287.16,101.2 287.68,101.2 288.05,101.57 289.14,101.57 289.61,102.04 289.61,103.94 289.48,104.07 289.48,104.39 289.62,104.53 D403.10 D403.1 289.62,106.45 289.5,106.58 289.5,106.88 289.86,107.25 290.61,107.25 290.82,107.03 290.82,105.62 291.14,105.3 291.37,105.3 v3(291.57,105.1)
  BOTTOM w0.089: v3(291.57,105.1) 291.37,105.3 290.54,105.3 290.03,104.8 U401.7
LAN_MDI3N: length 13.2
  TOP w0.089: v1(291.39,110.84) 291.19,110.64 290.51,110.64 287.75,107.88 287.75,106.53 287.62,106.4 D403.5 D403.6 287.62,104.66 287.7,104.58 287.7,104.03 287.31,103.64 286.6,103.64 286.03,103.06 U400.21
  BOTTOM w0.089: v1(291.39,110.84) 291.19,110.64 290.53,110.64 290.02,111.15 U401.12
LAN_MDI3P: length 13.2
  TOP w0.089: v1(291.39,110.18) 291.19,110.38 290.62,110.38 288.01,107.78 288.01,106.53 288.12,106.42 D403.4 D403.7 288.12,104.68 287.96,104.52 287.96,103.92 287.41,103.38 286.71,103.38 286.43,103.1 U400.20
  BOTTOM w0.089: v1(291.39,110.18) 291.19,110.38 290.56,110.38 290.06,109.88 U401.11
LAN_PPS: length 1.7
  TOP w0.102: TP400.1 284.48,103.72 U400.24
LAN_TRD0_CN_DN: length 7.6
  BOTTOM w0.089: U401.23 299.04,98.45 299.54,97.94 300.32,97.94 300.94,98.56 300.94,103.4 JACK400.2
LAN_TRD0_CN_DP: length 7.6
  BOTTOM w0.089: JACK400.1 301.57,102.39 301.19,102.01 301.19,98.45 300.43,97.68 299.51,97.68 299,97.18 U401.24
LAN_TRD1_CN_DN: length 9
  L3 w0.085: JACK400.6 300.92,106.54 299.7,105.32 299.32,105.32 298.22,104.22 298.22,103.46 297.95,103.19 296.9,103.19 v1(296.84,103.25)
  BOTTOM w0.089: U401.19 298.21,103.53 297.71,103.03 297.06,103.03 v1(296.84,103.25)
LAN_TRD1_CN_DP: length 9
  L3 w0.085: v3(296.84,102.59) 297.2,102.95 298.05,102.95 298.46,103.36 298.46,103.56 298.46,103.56 298.46,104.12 299.42,105.08 300.1,105.08 300.75,104.43 JACK400.3
  BOTTOM w0.089: v3(296.84,102.59) 297.02,102.77 297.71,102.77 298.22,102.26 U401.20
LAN_TRD2_CN_DN: length 4.2
  BOTTOM w0.089: JACK400.5 301.19,106.47 301.03,106.63 300.27,106.63 299.89,106.26 299.89,105.93 299.64,105.67 299.38,105.67 298.99,106.07 U401.17
LAN_TRD2_CN_DP: length 4.2
  BOTTOM w0.089: U401.18 299,104.8 299.62,105.41 299.74,105.41 300.15,105.82 300.15,106.15 300.37,106.38 300.92,106.38 301.09,106.21 301.09,105.62 JACK400.4
LAN_TRD3_CN_DN: length 5.2
  BOTTOM w0.089: JACK400.8 301.19,109.26 301.19,108.86 301.03,108.69 301.03,108.69 300.97,108.64 300.5,108.64 300.01,109.14 300.01,110.4 299.77,110.64 299.54,110.64 299.04,111.15 U401.13
LAN_TRD3_CN_DP: length 5.2
  BOTTOM w0.089: JACK400.7 301.21,108.51 301.08,108.38 300.4,108.38 299.75,109.03 299.75,109.24 299.75,110.3 299.66,110.38 299.53,110.38 299.02,109.88 U401.14
LCM_BKLTEN: length 261.5
  TOP w0.102: v1(204.37,31.14) 204.37,30.43 203.9,29.97 R349.2
  L8 w0.102: v1(255.32,43.51) 255.28,43.56 251.94,43.56 251.04,44.46 248.87,44.46 248.36,44.97 248.36,45.48 247.46,46.38 246.44,46.38 246.22,46.6 244.02,46.6 243.16,45.74 241.45,45.74 240.09,44.38 234.25,44.38 232.98,43.11 231.22,43.11 229.19,41.08 202.84,41.08 v1(200.94,39.17) 200.73,38.97 189.07,38.97 181.3,31.19 177.04,31.19 176.2,32.03 168.98,32.03 168.32,31.37 152.04,31.37 151.61,30.94 134.25,30.94 133.7,31.49 128.03,31.49 120.65,38.87 113.16,38.87 111.89,40.14 105.29,40.14 103.28,42.14 102.53,42.14 95.55,49.13 62.12,49.13 58.41,52.84 48.74,52.84 46.25,55.32 43.96,55.32 39.82,59.46 v3(37.22,59.46)
  BOTTOM w0.089: v1(255.32,43.51) 255.53,43.31 U4710.AV46
  BOTTOM w0.102: v3(37.22,59.46) R3013.1 ; v1(200.94,39.17) 200.94,38.26 201.42,37.77 204.82,37.77 205.13,37.47 205.13,33.43 204.37,32.67 v1(204.37,31.14) 204.37,30.74 203.53,29.9 203.53,29.06 203.1,28.63 203.1,27.21 203.7,26.6 204.42,26.6 205.09,25.93 U1.20
LCM_VDDEN: length 286.3
  L8 w0.102: v1(255.51,44.11) 255.33,44.11 254.98,43.76 252.02,43.76 251.12,44.66 250.41,44.66 247.88,47.19 244.32,47.19 243.08,45.94 241.36,45.94 240,44.58 234.17,44.58 232.9,43.31 231.14,43.31 229.1,41.28 201.27,41.28 199.16,39.17 187.89,39.17 186.69,37.97 186.69,37.11 180.97,31.4 177.12,31.4 176.28,32.24 168.9,32.24 168.24,31.58 151.95,31.58 151.52,31.14 134.33,31.14 133.78,31.69 128.11,31.69 120.74,39.07 113.74,39.07 111.02,41.79 105.14,41.79 97.59,49.33 62.21,49.33 58.5,53.04 48.82,53.04 46.28,55.58 44.07,55.58 39.52,60.13 37.19,60.13 36.67,59.61 36.67,58.47 36.22,58.02 34.34,58.02 33.83,58.53 33.83,61.28 31.94,63.17 25.4,63.17 24.74,62.51 24.74,61.22 24.3,60.79 22.54,60.79 21.65,59.9 16.43,59.9 15.21,61.12 15.21,68.74 16.71,70.23 16.71,74.55 v3(16.02,75.24)
  BOTTOM w0.089: U4710.AV44 255.72,43.89 v1(255.51,44.11)
  BOTTOM w0.102: v3(16.02,75.24) 16.32,75.24 16.53,75.45 R40.2
LED_A_B: length 14.1
  BOTTOM w0.203: U702.5 143.91,37.5 v2(144.55,36.86) 144.62,36.78 144.62,35.74 142.87,33.99 142.87,32.67 142.47,32.26 142.47,30.71 143.61,29.57 145.69,29.57 146.36,30.24 CN252.10
LED_A_G: length 13.8
  BOTTOM w0.203: CN252.11 145.86,30.25 145.49,29.88 145.25,29.88 145.25,29.87 143.74,29.87 143.23,30.38 143.23,30.39 143.02,30.59 v2(143.02,32.01) 143.2,32.19 143.2,33.89 145.11,35.79 145.11,37.16 144.68,37.6 144.29,37.6 143.89,38 U702.4
LED_A_R: length 13.1
  BOTTOM w0.203: U702.3 143.75,38.5 143.94,38.31 144.6,38.31 v2(144.75,38.15) 145.49,37.42 145.49,35.74 143.61,33.86 143.61,30.46 143.88,30.19 145.16,30.19 145.36,30.39 CN252.12
LED_ACT: length 14.2
  TOP w0.102: v1(273.43,95.25) 272.8,95.25 R418.2 ; U400.38 280.58,99.51 280.41,99.34 280.35,99.34 280.34,99.33 v1(280.34,99.33)
  L10 w0.102: v1(273.43,95.25) 273.71,94.97 274.32,94.97 274.55,95.2 274.55,97.31 276.91,99.67 277.15,99.67 277.15,99.67 277.49,99.67 277.72,99.44 278.96,99.44 279.08,99.33 v1(280.34,99.33)
  BOTTOM w0.102: v1(280.34,99.33) 281.01,99.33 TP403.1
LED_B_B: length 17.5
  BOTTOM w0.203: U702.10 142.04,34.58 v2(141.44,33.99) 141.02,33.56 141.02,31.13 141.22,30.93 141.22,27.23 141.63,26.83 144.29,26.83 147.86,30.39 CN252.7
LED_B_G: length 16.5
  BOTTOM w0.203: U702.9 142.54,34.62 142.14,34.22 142.14,33.27 v2(141.59,32.73) 141.35,32.48 141.35,31.23 141.53,31.05 141.53,27.36 141.75,27.13 144.12,27.13 147.36,30.37 CN252.8
LED_B_R: length 12.6
  BOTTOM w0.203: CN252.9 146.86,30.31 145.82,29.26 143.46,29.26 141.88,30.84 v2(141.88,31.45) 142.11,31.68 142.11,32.44 142.52,32.85 142.52,34.17 143.26,34.91 U702.8
LED_C_B: length 21.1
  BOTTOM w0.203: CN252.4 149.36,30.16 148.33,29.14 148.01,29.14 144.79,25.91 141.25,25.91 140.31,26.85 140.31,30.53 139.44,31.4 139.44,33.71 v2(139.15,33.99) 139.15,34 139.04,34.11 U702.16
LED_C_G: length 20
  BOTTOM w0.203: U702.15 139.54,34.5 140.1,33.94 v2(140.1,33.15) 139.9,32.95 139.9,31.37 140.61,30.66 140.61,26.98 141.37,26.22 141.63,26.22 144.66,26.22 147.89,29.44 148.08,29.44 148.86,30.22 CN252.5
LED_C_R: length 18.7
  BOTTOM w0.203: U702.14 140.04,34.49 140.66,33.86 140.66,32.13 v2(140.43,31.91) 140.43,31.27 140.92,30.79 140.92,27.11 141.5,26.52 144.52,26.52 148.36,30.36 CN252.6
LED_D_B: length 31.8
  BOTTOM w0.203: CN252.1 150.86,29.71 150.21,29.06 150.21,25.99 149.22,25 145.17,25 140.87,25 139.39,26.47 139.39,30.15 138.53,31.02 138.53,31.52 138.53,32.62 136.14,35.01 136.14,37.19 v2(136.95,38) U702.21
LED_D_G: length 30
  BOTTOM w0.203: CN252.2 150.36,29.64 149.91,29.19 149.91,26.11 149.09,25.3 145.04,25.3 141,25.3 139.7,26.6 139.7,30.28 138.83,31.14 138.83,31.4 138.83,31.4 138.83,32.87 137.41,34.29 v2(137.41,34.7) 136.45,35.66 136.45,36.78 137.16,37.5 U702.20
LED_D_R: length 25.8
  BOTTOM w0.203: U702.19 137.25,37 137,36.75 v2(137,35.94) 137,35.92 138.12,34.8 138.12,34.13 139.14,33.11 139.14,31.27 140,30.41 140,26.73 141.12,25.61 144.91,25.61 148.14,28.83 148.46,28.83 149.86,30.23 CN252.3
LED_LINK: length 16.3
  TOP w0.102: R417.2 v1(271.74,93.17) ; TP402.1 276.15,94.82 v1(275.54,94.82) ; U400.39 280.84,99.11 280.57,98.83 280.43,98.83 v1(280.34,98.74)
  L10 w0.102: v1(280.34,98.74) 280.14,98.94 279.1,98.94 278.94,98.78 276.4,98.78 275.13,97.51 275.13,95.23 v1(275.54,94.82)
  BOTTOM w0.102: v1(271.74,93.17) 271.93,93.17 273.58,94.82 v1(275.54,94.82)
LID_SW#: length 342.1
  TOP w0.102: C253.1 194.93,161.91 U250.OUTPUT 194.85,161.96 193.93,161.04 v1(193.93,160.79)
  L3 w0.102: v1(209.11,45.23) 208.64,44.75 167.46,44.75 166.26,43.56 160.84,43.56 160.45,43.95 154.28,43.95 153.26,42.93 v1(129.77,42.93) 129.36,42.52 107.08,42.52 105.41,44.2 96.85,44.2 96.16,43.51 90.42,43.51 88.06,45.88 v1(71.07,45.88)
  L5 w0.102: v1(193.93,160.79) 193.06,161.65 188.66,161.65 181.65,154.64 153.39,154.64 147.11,148.36 147.11,141.63 144.85,139.37 144.85,126.55 143.56,125.25 143.56,122.2 143.94,121.82 143.94,119.69 v1(145.28,118.34) ; v1(56.6,29.92) 58.65,29.92 59.69,30.97 59.69,34.93 70.63,45.88 v1(71.07,45.88)
  L8 w0.102: v1(129.77,42.93) 129.77,43.79 130.19,44.22 130.19,45.77 130.45,46.03 130.45,47.93 131.91,49.39 131.91,50.83 135.24,54.16 136.13,54.16 144.75,62.78 144.75,62.94 144.75,62.95 144.75,63.92 143.84,64.83 143.84,64.92 143.84,65.92 143.92,66 143.92,66.06 144.07,66.21 144.07,69.23 144.19,69.35 144.19,74.43 143.58,75.04 143.58,91.04 143.58,94.9 143.58,95.55 144.7,96.67 144.7,98.88 144.19,99.39 144.19,112.3 145.74,113.85 145.74,117.88 v1(145.28,118.34)
  BOTTOM w0.102: v1(209.11,45.23) 209.37,44.97 R302.2 209.81,45.09 212.03,45.09 R28.1 ; CN254.3 v1(56.6,29.92)
LID_SW#_R: length 4.4
  BOTTOM w0.102: U1.84 207.89,41.43 208.21,41.76 208.97,41.76 209.72,42.51 v2(209.72,42.9) 209.37,43.26 R302.1
LID_SW#_S: length 8
  TOP w0.102: U50.OUTPUT 257.99,98.53 258.25,98.27 v2(259.29,98.27) 259.31,98.27 260.68,96.9 C50.1 261.68,95.28 CN1.3
LID_SW_LCM#: length 194.1
  L8 w0.102: v1(39.9,58.22) 39.9,57.64 42.67,54.87 46.13,54.87 48.57,52.43 58.25,52.43 66.37,44.3 88.56,44.3 91.12,41.74 102.66,41.74 105.99,38.41 120.54,38.41 129.04,29.91 139.44,29.91 139.82,30.28 158.68,30.28 159.17,29.8 172.74,29.8 173.68,30.74 181.57,30.74 189.13,38.31 208.89,38.31 209.14,38.56 211.75,38.56 v1(212.69,39.5)
  BOTTOM w0.102: R3014.2 39.85,58.27 v1(39.9,58.22) D3000.1 ; v1(212.69,39.5) U1.96 213.43,40.73 213.75,41.05 R336.2
LINE1_L: length 11.2
  TOP w0.254: U500.22 15.98,55.12 15.73,54.87 15.73,54.05 14.99,53.31 12.86,53.31 12.26,52.71 12.26,49.97 12.7,49.53 13.69,49.53 v2(13.71,49.56) 13.81,49.66 C602.1
LINE1_R: length 13.2
  TOP w0.254: C603.1 v2(12.87,48.44) 11.73,49.58 11.73,52.96 12.61,53.84 14.81,53.84 15.34,54.37 15.34,55.01 15.85,55.52 U500.21
LINE1_REF_L: length 5.3
  TOP w0.254: U500.31 19.61,52.31 19.46,52.16 19.46,50.62 19.68,50.4 v2(19.68,49.69) 19.28,49.28 R606.1
LINE1_REF_R: length 8
  TOP w0.254: U500.30 19.21,52.54 18.95,52.28 18.95,50.74 v3(18.68,50.47) ; v1(19.19,46.69) 18.61,46.69 R607.1
  L3 w0.254: v1(19.19,46.69) 19.19,49.97 v3(18.68,50.47)
LOCAL_SHUTDOWN#: length 103.9
  L5 w0.102: v1(263.93,69.57) 263.93,59.39 262.51,57.97 262.51,45.95 260.17,43.62 260.17,42.7 259.2,41.74 258.29,41.74 257.76,42.27 241.15,42.27 240.38,41.5 238.94,41.5 237.36,43.08 230.91,43.08 229,41.18 212.09,41.18 211.2,42.07 196.07,42.07 v1(195.63,42.51)
  BOTTOM w0.102: U1.66 200.69,41.43 200.41,41.71 199.34,41.71 v2(199.16,41.53) 198.71,41.08 C321.2 197.36,41.08 C65.1 196.47,41.08 R25.2 195.63,41.92 v1(195.63,42.51) ; R26.1 v1(263.93,69.57)
LP#: length 24.5
  L8 w0.102: v3(66.11,90.3) 66.11,90.67 67.66,92.22 67.66,98.71 68.93,99.98 68.93,100.54 66.54,102.92 66.54,105.99 67.28,106.73 67.28,107.52 67.76,108 69.08,108 v1(69.17,108.1)
  BOTTOM w0.102: R7068.1 66.16,90.35 v3(66.11,90.3) ; U60500.6 69.25,108.01 69.17,108.09 v1(69.17,108.1) 69.17,108.12 69.42,108.38 R60522.2
LPC_AD<0>: length 68.9
  TOP w0.102: R4846.2 264.54,32.16 v2(262.25,29.87) v1(257.1,29.87)
  TOP w0.109: CN301.2 209.32,30.21 209.11,30 v1(209.11,29.75)
  L3 w0.102: v1(209.11,29.75) 209.85,30.48 212.93,30.48 214.61,28.81 221.9,28.81 226.48,24.23 228.98,24.23 229.79,25.05 231.16,25.05 231.24,24.96 238.26,24.96 241.24,27.94 246.62,27.94 248.03,29.35 255.36,29.35 256.29,30.28 256.69,30.28 v1(257.1,29.87)
  BOTTOM w0.109: v1(209.11,29.75) 209.11,29.59 209.98,28.73 210.27,28.73 210.38,28.62 210.38,27.2 209.09,25.91 U1.10
LPC_AD<1>: length 66.4
  TOP w0.102: v1(256.46,29.87) 256.87,30.28 257.26,30.28 257.43,30.11 261.55,30.11 v2(262.71,31.28) 262.99,31.55 R4847.2
  TOP w0.109: CN301.3 209.82,29.94 209.7,29.82 v1(209.7,29.72)
  L3 w0.102: v1(209.7,29.72) 210.26,30.28 212.85,30.28 214.52,28.6 221.82,28.6 226.39,24.03 229.2,24.03 229.4,24.22 230.62,24.22 231.16,24.76 238.34,24.76 241.33,27.74 246.7,27.74 248.11,29.15 255.74,29.15 v1(256.46,29.87)
  BOTTOM w0.109: v1(209.7,29.72) 210.59,28.83 210.59,27.11 209.49,26 U1.9
LPC_AD<2>: length 70
  TOP w0.102: R4848.2 266.8,32.57 v2(264.08,29.85) 262.3,28.07 v1(262.3,28.07) ; v1(210.32,29.72) 210.32,30.23
  TOP w0.109: 210.32,30.23 CN301.4
  L3 w0.102: v1(210.32,29.72) 213.01,27.03 222.34,27.03 225.74,23.62 229.37,23.62 229.57,23.82 230.79,23.82 231.33,24.35 238.51,24.35 241.5,27.33 246.87,27.33 248.17,28.64 257.74,28.64 258.72,27.66 261.9,27.66 v1(262.3,28.07)
  BOTTOM w0.109: U1.8 209.89,26.1 210.8,27.01 210.8,29.24 v1(210.32,29.72)
LPC_AD<3>: length 67
  TOP w0.102: v1(261.62,28.07) 261.62,28.23 v2(264.59,31.2) R4849.2
  TOP w0.109: CN301.5 210.82,30.12 210.79,30.09 210.79,29.93 v1(210.99,29.72)
  L3 w0.102: v1(261.62,28.07) 259.36,28.07 258.59,28.84 248.09,28.84 246.78,27.54 241.41,27.54 238.43,24.55 231.24,24.55 230.71,24.02 229.48,24.02 229.29,23.83 225.83,23.83 222.37,27.28 213.18,27.28 210.99,29.47 v1(210.99,29.72)
  BOTTOM w0.109: v1(210.99,29.72) 211.05,29.67 211.05,26.93 210.29,26.17 U1.7
LPC_ESPI_CLK: length 24.2
  TOP w0.109: R4852.1 269.74,33.2 270.17,33.63 R4850.1 270.61,33.73 270.61,36.93 268.4,39.14 267.03,39.14 266.49,39.68 266.49,41.68 265.31,42.87 263.51,42.87 263.51,42.86 263.21,42.86 262.26,43.81 262.26,44.44 261.92,44.78 261.01,44.78 v2(259.27,46.52) 258.98,46.82 257.97,46.82 v1(257.73,47.05)
  BOTTOM w0.109: U4710.BB36 257.65,47.13 v1(257.73,47.05)
LPC_ESPI_IO0: length 25.2
  TOP w0.102: v2(264.61,33.94) 264.54,33.86 R4846.1
  TOP w0.109: v2(264.61,33.94) 264.92,34.25 269.49,34.25 269.71,34.46 269.71,36.56 268.07,38.2 267.05,38.2 266.71,38.2 265.18,39.73 265.18,40.85 264.06,41.97 262.6,41.97 261.77,42.8 261.63,42.8 259.7,44.73 258.8,44.73 v1(257.96,45.57)
  BOTTOM w0.109: v1(257.96,45.57) 258,45.75 U4710.BB39
LPC_ESPI_IO1: length 28.2
  TOP w0.102: v1(256.94,45.37) 257.3,45.37 258.13,44.54 259.62,44.54 262.4,41.76 263.97,41.76 264.97,40.76 264.97,39.64 266.62,37.99 267.13,37.99 267.99,37.99 269.47,36.51 269.47,34.67 269.24,34.45 263.63,34.45 v2(263.12,33.94) 262.99,33.81 R4847.1
  BOTTOM w0.109: v1(256.94,45.37) 256.84,45.47 256.84,45.6 256.7,45.74 256.7,45.97 256.67,45.99 256.67,46.09 256.66,46.1 256.66,46.86 U4710.AW37
LPC_ESPI_IO2: length 25.9
  TOP w0.089: v2(256.56,46.18) 256.13,46.61 v1(256.13,46.71)
  TOP w0.102: v2(256.56,46.18) 256.77,46.38 258.61,46.38 260.55,44.45 261.52,44.45 261.78,44.19 261.78,43.6 263,42.38 264.23,42.38 265.59,41.02 265.59,40.85 265.59,40.85 265.59,39.9 266.88,38.61 268.24,38.61 270.12,36.73 270.12,34.29 269.66,33.84 267.72,33.84 R4848.1
  BOTTOM w0.109: U4710.AV37 256.13,46.92 v1(256.13,46.71)
LPC_ESPI_IO3: length 25.9
  TOP w0.102: R4849.1 265.43,33.23 v2(265.86,33.66) 266.24,34.04 269.58,34.04 269.92,34.38 269.92,36.65 268.16,38.41 266.96,38.41 266.79,38.41 265.38,39.82 265.38,40.93 264.14,42.18 262.75,42.18 261.77,43.16 261.57,43.16 258.65,46.08 257.68,46.08 257.37,45.77 v1(257.37,45.77)
  BOTTOM w0.109: U4710.BA38 256.99,46.14 v1(257.37,45.77)
LPC_FRAME#: length 68.7
  TOP w0.102: v1(211.65,29.72) 211.65,29.95 211.82,30.12 CN301.7
  L10 w0.102: v1(211.65,29.72) 212.06,29.32 212.85,29.32 212.88,29.34 214.18,29.34 214.62,28.9 220.91,28.9 221.36,28.45 223.92,28.45 224.43,27.94 230.8,27.94 232.83,29.98 234.97,29.98 235.05,29.9 239.92,29.9 241.4,31.37 241.85,31.37 245.15,34.67 249.01,34.67 252.52,38.19 252.52,38.91 255.69,42.07 256.51,42.07 257.15,42.72 257.15,43.72 257.39,43.96 258.03,43.96 259.29,45.22 260.83,45.22 261.92,46.31 v3(261.92,46.47)
  BOTTOM w0.089: v3(261.92,46.47) 260.06,46.47 259.86,46.67 259.39,46.67 U4710.BE38
  BOTTOM w0.102: v1(211.65,29.72) 211.3,29.37 211.3,26.8 210.69,26.19 U1.6
M2_SSD1_DET#: length 185.9
  TOP w0.102: v1(249.96,45.72) 249.35,46.33 248.82,46.33 247.65,47.5 246.94,47.5 R4707.2
  L10 w0.102: v1(249.96,45.72) 249.35,46.33 248.42,46.33 247.56,47.19 244.65,47.19 243.24,45.77 241.67,45.77 240.63,44.73 238.15,44.73 237.54,44.13 231.71,44.13 230.09,42.5 229.86,42.27 220.12,42.27 218.27,44.12 212.75,44.12 212.26,43.64 198.4,43.64 198.09,43.95 183.11,43.95 178.66,39.5 171.41,39.5 167.66,35.75 156.08,35.75 154.79,37.04 136.95,37.04 136.14,37.85 110.77,37.85 101.39,47.23 v1(93.09,47.23)
  BOTTOM w0.089: U4710.AJ43 250.57,44.53 249.96,45.14 v1(249.96,45.72)
  BOTTOM w0.102: Q1900.3 92.23,54.11 92.27,54.06 R1906.1 92.75,54.06 93.09,53.72 v2(93.09,52.45) v1(93.09,47.23)
M2_SSD1_SUSCLK: length 220.8
  L3 w0.076: v1(67.84,50.93) 67.84,49.86 68.94,48.76 68.94,41.04 70.65,39.34 84.79,39.34 87.69,36.44 133.14,36.44 134.39,35.2 147.19,35.2 147.72,35.73 158.95,35.73 160.47,34.2 168.87,34.2 169.28,33.8 174.38,33.8 176.44,35.86 186.68,35.86 188.89,38.07 206.46,38.07 206.91,37.61 221.67,37.61 222.64,38.57 229.83,38.57 230.84,37.56 235.88,37.56 238.66,40.34 243.26,40.34 244.64,41.72 247.07,41.72 249.99,38.81 263.81,38.81 264.64,37.98 266.11,37.98 v1(266.99,37.1)
  BOTTOM w0.109: v1(266.99,37.1) 266.54,37.54 R4750.2 ; CN1901.68 68.02,51.8 67.84,51.62 v1(67.84,50.93)
M2_SSD2_SUSCLK: length 113.2
  L3 w0.076: v3(174.6,23.8) 182.22,23.8 183.8,25.39 194.4,25.39 195.81,26.8 203.73,26.8 205.69,24.84 212.77,24.84 215.97,21.64 216.68,21.64 218,20.32 221.64,20.32 223.09,21.77 230.06,21.77 231.71,23.42 238.9,23.42 238.92,23.45 238.93,23.45 241.89,26.41 247.25,26.41 248.56,27.71 256.41,27.71 258.28,25.85 261.45,25.85 263.45,27.84 263.45,28.17 263.8,28.53 264.33,28.53 269.59,33.79 269.59,35.79 269.01,36.38 268.4,36.38 v1(267.74,37.04)
  BOTTOM w0.109: v3(174.6,23.8) 175.09,24.3 CN1900.68 ; R4710.2 267.74,37.6 v1(267.74,37.04)
M2_WLAN_SUSCLK: length 21.5
  L8 w0.076: v3(278.86,31.96) 273.78,37.04 v1(268.32,37.04)
  BOTTOM w0.109: v3(278.86,31.96) 281.28,31.96 284.2,29.03 284.2,27.64 CN1300.50 ; R4706.2 v1(268.32,37.04)
M.2_W_DISABLE1#: length 5
  TOP w0.102: R1350.2 287.89,25.99 v3(286.74,25.99) 286.74,25.3 287.1,24.94 Q1312.2
  BOTTOM w0.102: CN1300.56 285.7,26.39 286.1,25.99 v3(286.74,25.99)
M.2_W_DISABLE2#: length 6.9
  TOP w0.102: v1(284.76,24.05) 284.74,24.07 Q1313.2 ; v2(283.66,25) 283.81,24.85 Q1313.2 ; Q1313.2 284.74,25.63 R1351.2
  BOTTOM w0.102: v1(284.76,24.05) 285.2,24.5 CN1300.54
M_A_A_0: length 50.6
  L10 w0.076: 106.55,108.65 106.55,113.47 v1(106.15,113.87)
  L10 w0.109: v3(118.17,78.58) 118.48,78.89 118.58,79.14 118.62,79.35 118.62,79.88 117.39,82.86 117.39,83.67 106.67,94.38 106.02,95.96 106.02,103.67 106.55,106.31 106.55,108.65
  BOTTOM w0.076: v1(106.15,113.87) 106.66,114.39 106.66,114.72 107.32,115.38 107.32,118.7 U4555.AH3
  BOTTOM w0.17: v3(118.17,78.58) 116.41,75.3 CN4100.144
M_A_A_1: length 51.4
  L10 w0.076: 101.92,108.16 101.92,115.69 v1(101.28,116.33)
  L10 w0.109: v3(113.49,81.45) 110.61,84.34 110.61,84.77 109.45,85.92 109.45,87.01 101.89,94.57 101.89,102.51 101.78,102.61 101.38,102.61 101.27,102.72 101.27,102.92 101.38,103.03 101.78,103.03 101.89,103.14 101.89,103.33 101.78,103.44 101.38,103.44 101.27,103.55 101.27,103.75 101.38,103.86 101.78,103.86 101.89,103.97 101.89,104.21 101.78,104.32 101.39,104.32 101.28,104.43 101.28,104.62 101.39,104.73 101.78,104.73 101.89,104.84 101.89,105.03 101.78,105.14 101.39,105.14 101.28,105.25 101.28,105.45 101.39,105.56 101.78,105.56 101.89,105.67 101.89,105.86 101.78,105.97 101.39,105.97 101.28,106.08 101.28,106.28 101.39,106.39 101.78,106.39 101.89,106.5 101.89,106.69 101.78,106.8 101.39,106.8 101.28,106.91 101.28,107.1 101.39,107.21 101.78,107.21 101.89,107.32 101.89,108.14 101.92,108.16
  BOTTOM w0.076: U4555.AP4 101.75,119.64 101.46,119.35 101.46,119.13 101.4,119.07 101.4,116.45 v1(101.28,116.33)
  BOTTOM w0.17: CN4100.133 113.75,83.03 113.75,81.71 v3(113.49,81.45)
M_A_A_2: length 50.5
  L10 w0.109: v3(112.85,77.05) 112.86,77.05 113.39,77.57 113.99,79.02 113.99,81.55 111.02,84.51 111.02,84.94 109.87,86.1 109.87,87.18 102.31,94.74 102.31,111.76 102.34,112.12 102.86,117.26 v1(103.2,119.24)
  BOTTOM w0.076: U4555.AN4 v1(103.2,119.24)
  BOTTOM w0.17: v3(112.85,77.05) 113.31,75.78 113.31,74.77 CN4100.132
M_A_A_3: length 50.2
  L10 w0.076: 101.65,108.44 101.65,115.38 v1(101.28,115.75)
  L10 w0.109: v3(113.52,80.09) 113.15,80.46 113.15,81.21 110.19,84.17 110.19,84.6 109.04,85.75 109.04,86.84 101.48,94.4 101.48,101.9 100.83,102.55 100.83,107.62 101.65,108.44
  BOTTOM w0.076: v1(101.28,115.75) 101.68,116.15 101.68,117.27 101.56,117.4 101.56,119.01 101.86,119.32 102.21,119.32 102.39,119.49 102.39,120 102.11,120.29 U4555.AP5
  BOTTOM w0.17: v3(113.52,80.09) 113.05,80.56 113.05,81.79 113.16,81.91 CN4100.131
M_A_A_4: length 50
  L10 w0.076: 101.4,108.8 101.4,114.53 v1(101.14,114.79)
  L10 w0.109: 101.4,108.8 100.41,107.81 100.41,102.38 101.06,101.73 101.06,94.22 108.49,86.8 108.49,85.02 112.73,80.78 v3(112.73,78.39)
  BOTTOM w0.076: U4555.AP2 101.71,118.05 101.71,117.52 101.88,117.35 101.88,115.54 v1(101.14,114.79)
  BOTTOM w0.17: CN4100.128 112.39,74.69 112.39,76.84 112.31,77.07 112.31,77.96 v3(112.73,78.39)
M_A_A_5: length 50
  L10 w0.076: v1(101.02,114.19) 101.13,114.07 101.13,109.12
  L10 w0.109: v3(111.43,77.28) 111.88,77.28 112.14,77.54 112.14,78.8 112.32,78.98 112.32,80.61 107.48,85.45 107.48,87.23 100.65,94.05 100.65,101.5 100,102.15 100,107.98 101.13,109.12
  BOTTOM w0.076: v1(101.02,114.19) 101.11,114.19 102.09,115.16 102.09,117.6 U4555.AP1
  BOTTOM w0.17: CN4100.126 111.91,76.64 111.43,77.13 v3(111.43,77.28)
M_A_A_6: length 51.6
  L10 w0.076: v1(100.75,113.23) 100.81,113.16 100.81,109.4
  L10 w0.109: 100.81,109.4 100.81,109.33 99.59,108.11 99.59,101.98 100.24,101.33 100.24,93.88 106.04,88.08 106.04,86.05 111.91,80.18 111.91,79.15 111.46,78.71 v3(111.46,78.69)
  BOTTOM w0.076: v1(100.75,113.23) 102.29,114.76 102.29,118.7 U4555.AP3
  BOTTOM w0.17: CN4100.127 112.16,79.41 111.46,78.71 v3(111.46,78.69)
M_A_A_7: length 49.9
  L10 w0.076: v1(100.14,111.7) 100.13,111.7
  L10 w0.109: 100.13,111.7 99.45,111.01 98.84,109.55 98.34,108.34 98.34,101.47 98.99,100.81 98.99,93.37 102.96,89.4 102.96,87.37 109.97,80.36 v3(109.97,79.27)
  BOTTOM w0.076: v1(100.14,111.7) 100.21,111.7 102.74,114.22 U4555.AN1
  BOTTOM w0.17: v3(109.97,79.27) 110.7,78.54 110.7,76.26 110.91,76.04 CN4100.122
M_A_A_8: length 50.7
  L10 w0.076: 100.52,110.05 100.52,112.62 v1(100.43,112.71)
  L10 w0.109: 100.52,110.05 100.52,109.61 99.17,108.26 99.17,101.81 99.82,101.16 99.82,93.71 104.17,89.36 104.17,89.21 103.92,88.97 103.92,88.81 104.06,88.67 104.22,88.67 104.46,88.92 104.61,88.92 104.75,88.78 104.75,88.62 104.51,88.38 104.51,88.23 104.65,88.09 104.8,88.09 105.05,88.33 105.2,88.33 105.62,87.91 105.62,85.88 v3(111.43,80.07)
  BOTTOM w0.076: U4555.AN3 102.44,118.69 102.44,117.46 102.52,117.39 102.52,114.43 100.79,112.71 v1(100.43,112.71)
  BOTTOM w0.17: CN4100.125 111.66,80.3 v3(111.43,80.07)
M_A_A_9: length 51.6
  L10 w0.076: v1(100.64,119.33) 100.65,119.33
  L10 w0.109: v3(108.58,78.84) 109.04,79.29 109.04,80.71 102.54,87.2 102.54,89.05 98.51,93.08 98.51,100.55 97.87,101.18 97.87,108.21 98.7,110.65 99.96,114.17 100.29,115.26 100.96,116.87 101.06,117.39 101.06,118.74 100.96,118.98 100.8,119.18 100.65,119.33
  BOTTOM w0.076: U4555.AT4 v1(100.64,119.33)
  BOTTOM w0.17: v3(108.58,78.84) 109.13,79.38 109.13,80.01 110.66,81.55 CN4100.121
M_A_A_10: length 51
  L10 w0.076: v1(106.14,115.86) 106.65,115.35 106.65,114.94 107.12,114.48 107.12,108.7
  L10 w0.109: 107.12,108.7 107.41,108.41 107.41,104.09 107.03,103.71 107.03,95.69 107.31,95.02 118.43,83.9 119.28,83.9 119.69,83.48 119.69,81.23 119.23,80.76 119.23,77.72 118.83,77.32 v3(118.68,77.32)
  BOTTOM w0.076: v1(106.14,115.86) 106.74,116.46 106.74,118.04 U4555.AH2
  BOTTOM w0.17: v3(118.68,77.32) 118.68,75.72 118.91,75.49 CN4100.146
M_A_A_11: length 50.5
  L10 w0.109: v3(109.99,77.76) 110.46,78.23 110.46,80.45 103.37,87.54 103.37,89.57 99.41,93.54 99.41,100.99 98.76,101.64 98.76,108.31 99.76,110.73 v1(100.06,111.03)
  BOTTOM w0.076: v1(100.06,111.03) 102.83,113.8 103.03,114.29 103.03,117.78 102.85,118.22 U4555.AN2
  BOTTOM w0.17: v3(109.99,77.76) 110.22,77.52 110.22,76.06 110.41,75.87 CN4100.120
M_A_A_12: length 49.4
  L10 w0.109: v3(108.54,80.17) 108.43,80.06 107.56,80.06 106.01,81.62 106.01,82.44 101.6,86.85 101.6,88.82 96.79,93.63 96.79,108.58 97.87,111.19 99.14,114.25 99.14,115.8 v1(98.82,116.12)
  BOTTOM w0.076: v1(98.82,116.12) 98.85,116.47 98.95,118.5 99.38,119.53 U4555.AU4
  BOTTOM w0.17: v3(108.54,80.17) 110.16,81.79 CN4100.119
M_A_A_13: length 51.7
  L10 w0.109: v3(122.14,76.12) 122.48,76.12 122.84,76.48 122.84,77.37 123.46,77.99 123.46,85.2 111.97,96.7 111.97,109.31 110.05,111.23 109.69,112.09 109.69,114.5 v1(108.75,115.45)
  BOTTOM w0.076: v1(108.75,115.45) 108.75,115.66 109.83,116.74 109.83,118.7 U4555.AE3
  BOTTOM w0.17: v3(122.14,76.12) 121.91,75.89 CN4100.158
M_A_ACT#: length 49.9
  L10 w0.109: v1(98.6,114.89) 98.3,113.38 97.47,111.38 97.47,111.37 96.34,108.64 96.34,93.46 101.19,88.61 101.19,86.68 105.59,82.27 105.59,81.44 106.32,80.72 v3(108.45,77.52)
  BOTTOM w0.076: U4555.AU3 99.38,118.88 99.2,118.44 99.2,115.49 v1(98.6,114.89)
  BOTTOM w0.17: CN4100.114 108.84,75.53 108.8,75.81 v3(108.45,77.52)
M_A_ALERT#: length 56.3
  L10 w0.109: v1(99.08,119.97) 99.08,118.33 96.88,116.13 96.88,113.89 95.11,112.12 95.11,111.12 94.35,109.7 94.35,92.64 99.05,87.94 99.05,85.02 100.79,83.27 102.08,81.7 102.08,80.18 106.61,75.64 108.65,75.64 v3(109.28,76.27)
  BOTTOM w0.076: v1(99.08,119.97) 99.4,120.29 U4555.AU5
  BOTTOM w0.17: CN4100.116 109.41,76.13 v3(109.28,76.27)
M_A_BG0: length 50.8
  L10 w0.109: v1(96.16,112.09) 96.16,111.63 95.92,111.06 95.09,109.51 95.09,92.94 99.79,88.25 99.79,85.49 100.56,84.72 101.33,83.79 101.35,83.77 102.83,81.96 102.83,81.96 104.5,79.92 104.95,79.41 105.19,79.18 105.75,78.94 v3(105.78,78.94)
  BOTTOM w0.076: v1(96.16,112.09) 96.16,112.44 96.31,112.79 96.77,113.25 98.83,114.28 99.11,114.56 99.21,114.71 99.39,115.1 99.49,115.51 U4555.AU1
  BOTTOM w0.17: v3(105.78,78.94) 105.79,78.94 107.76,80.24 108.42,80.9 108.86,81.56 109.08,81.97 109.08,82.91 CN4100.115
M_A_BG1: length 48.7
  L10 w0.109: v1(97.09,112.95) 97.09,112.49 96.87,111.95 96.76,111.76 96.6,111.45 95.51,109.41 95.51,93.12 100.35,88.28 100.35,86.33 103.87,82.04 v3(105.53,80.21)
  BOTTOM w0.076: U4555.AU2 99.82,117.71 99.82,117.44 99.74,115.6 99.6,114.94 99.51,114.71 99.34,114.43 98.83,113.92 v1(97.09,112.95)
  BOTTOM w0.17: CN4100.113 108.59,82.37 108.59,82.15 108.48,81.89 108.1,81.32 107.4,80.62 106.6,80.38 105.77,80.21 v3(105.53,80.21)
M_A_BS0: length 55.7
  L10 w0.076: 107.42,108.93 107.42,114.82 106.96,115.28 106.96,117.73 106.71,117.98 106.01,117.98 105.75,117.72 105.75,116.9 v1(106.14,116.5)
  L10 w0.109: v3(120.1,76.33) 120.01,76.42 119.82,76.88 119.82,80.74 120.11,81.03 120.11,83.66 107.83,95.93 107.83,108.52 107.42,108.93
  BOTTOM w0.076: v1(106.14,116.5) 106.53,116.9 106.53,119.79 U4555.AH5
  BOTTOM w0.17: v3(120.1,76.33) 119.91,76.15 CN4100.150
M_A_BS1: length 48.8
  L10 w0.076: 106.84,108.34 106.84,113.9 v1(106.14,114.6)
  L10 w0.109: 106.84,108.34 106.99,108.18 106.99,104.4 106.57,103.97 106.57,95.73 107.03,94.62 118,83.64 118,82.49 118.16,82.34 118.45,82.34 118.65,82.53 118.65,83.35 118.78,83.48 119.11,83.48 119.28,83.31 119.28,81.45 118.91,81.07 v3(118.73,81.07)
  BOTTOM w0.076: v1(106.14,114.6) 107.03,115.49 U4555.AH1
  BOTTOM w0.17: v3(118.73,81.07) 118.23,81.07 118.03,81.27 118.03,82.96 118.18,83.12 CN4100.145
M_A_CAS#: length 51.8
  L10 w0.109: v3(121.9,77.41) 121.05,77.41 120.9,77.56 120.9,78.05 121.06,78.21 121.66,78.21 121.82,78.37 121.82,79.32 122.64,80.14 122.64,84.86 110.47,97.02 110.47,101.16 110.74,101.43 110.74,109.55 109.46,110.83 109.13,111.63 109.13,112.8 109,113.11 v1(108.74,113.37)
  BOTTOM w0.076: U4555.AD1 110.43,117.53 110.43,115.06 v1(108.74,113.37)
  BOTTOM w0.17: CN4100.156 121.41,76.92 v3(121.9,77.41)
M_A_DQ<0>: length 54.5
  L10 w0.076: v1(84.91,120.5) 84.76,120.64 82.59,120.64 82.33,120.38 82.32,120.38 78.71,116.77 78.71,96.67 78.23,96.19 78.23,91.43 77.84,91.03 77.84,82.71 80.92,79.63 80.92,76.61 81.41,76.12 v3(81.61,76.12)
  BOTTOM w0.076: U4555.BR6 86.8,120.82 85.93,120.82 85.74,121.02 85.27,121.02 84.91,120.65 v1(84.91,120.5)
  BOTTOM w0.109: v3(81.61,76.12) 81.6,76.12 81.41,75.93 CN4100.4
M_A_DQ<1>: length 54.3
  L10 w0.076: v3(80.98,81.44) 79.96,81.44 78.42,82.97 78.42,89.18 78.56,89.32 78.77,89.32 78.86,89.41 78.86,89.67 78.78,89.74 78.5,89.74 78.42,89.82 78.42,90.05 78.5,90.13 78.79,90.13 78.86,90.19 78.86,90.44 78.79,90.51 78.5,90.51 78.42,90.58 78.42,90.81 78.5,90.89 78.78,90.89 78.86,90.96 78.86,91.84 78.94,91.92 79.19,91.92 79.27,92 79.27,92.28 79.19,92.36 78.89,92.36 78.81,92.43 78.81,92.66 78.89,92.74 79.19,92.74 79.27,92.82 79.27,93.04 79.19,93.12 78.89,93.12 78.81,93.2 78.81,93.43 78.89,93.5 79.19,93.5 79.27,93.58 79.27,93.81 79.19,93.88 78.89,93.88 78.81,93.96 78.81,94.19 78.89,94.26 79.19,94.26 79.27,94.34 79.27,94.57 79.19,94.64 78.89,94.64 78.81,94.72 78.81,94.95 78.89,95.03 79.19,95.03 79.27,95.1 79.27,95.33 79.19,95.41 78.89,95.41 78.81,95.48 78.81,95.71 78.89,95.79 79.19,95.79 79.27,95.86 79.27,116.52 81.66,118.91 82.29,119.17 v1(83.51,119.17)
  BOTTOM w0.076: U4555.BT6 86.07,121.4 85.01,121.4 83.51,119.89 v1(83.51,119.17)
  BOTTOM w0.109: v3(80.98,81.44) 81.58,81.44 82.16,82.02 CN4100.7
M_A_DQ<2>: length 53.5
  L10 w0.076: v1(85.19,118.42) 85.19,117.85 81.58,114.24 81.58,92.4 81.94,92.04 82.27,92.04 82.37,91.93 82.37,91.6 82.3,91.52 81.68,91.52 81.61,91.44 81.61,91.22 81.68,91.14 82.35,91.14 82.43,91.06 82.43,90.84 82.35,90.76 81.68,90.76 81.61,90.68 81.61,90.45 81.68,90.38 82.35,90.38 82.43,90.3 82.43,90.07 82.35,90 81.68,90 81.61,89.92 81.61,89.69 81.68,89.62 82.35,89.62 82.43,89.54 82.43,89.31 82.35,89.24 81.68,89.24 81.61,89.16 81.61,88.93 81.68,88.85 82.35,88.85 82.43,88.78 82.43,88.55 82.35,88.47 81.68,88.47 81.61,88.4 81.61,88.17 81.68,88.09 82.35,88.09 82.43,88.02 82.43,85.79 82.08,85.45 82.08,85.13 82.43,84.78 82.43,83.4 83.82,82.01 83.82,81.1 v3(84.08,80.83)
  BOTTOM w0.076: U4555.BP3 87.26,119.39 86.7,119.39 86.67,119.36 85.82,119.36 85.72,119.26 85.49,119.26 85.19,118.96 v1(85.19,118.42)
  BOTTOM w0.109: v3(84.08,80.83) 84.66,81.41 CN4100.17
M_A_DQ<3>: length 52.8
  L10 w0.076: v3(84.07,76.66) 82.98,77.75 82.98,81.66 80.34,84.3 80.34,87.42 80.74,87.82 80.74,88.2 80.67,88.28 80.44,88.28 80.37,88.36 80.37,88.59 80.44,88.66 80.67,88.66 80.74,88.74 80.74,88.97 80.67,89.04 80.44,89.04 80.37,89.12 80.37,89.35 80.44,89.42 80.67,89.42 80.74,89.5 80.74,89.73 80.67,89.8 80.44,89.8 80.37,89.88 80.37,90.11 80.44,90.19 80.67,90.19 80.74,90.26 80.74,90.49 80.67,90.57 80.44,90.57 80.37,90.64 80.37,90.87 80.44,90.95 80.67,90.95 80.74,91.02 80.74,115.74 82.04,117.03 82.65,117.03 83.64,118.02 84.68,118.02 v1(84.73,117.97)
  BOTTOM w0.076: U4555.BR3 86.38,118.61 86.02,118.61 85.37,117.97 v1(84.73,117.97)
  BOTTOM w0.109: v3(84.07,76.66) 84.41,76.32 CN4100.16
M_A_DQ<4>: length 54.7
  L10 w0.076: v1(83.01,118.64) 81.8,118.64 79.55,116.39 79.55,91.89 79.13,91.47 79.13,88.95 79.06,88.87 78.79,88.87 78.71,88.79 78.71,88.57 78.79,88.49 79.06,88.49 79.13,88.41 79.13,88.18 79.06,88.11 78.79,88.11 78.71,88.03 78.71,87.8 78.79,87.73 79.06,87.73 79.13,87.65 79.13,87.42 79.06,87.35 78.79,87.35 78.71,87.27 78.71,87.04 78.79,86.97 79.06,86.97 79.13,86.89 79.13,86.66 79.06,86.58 78.79,86.58 78.71,86.51 78.71,86.28 78.79,86.2 79.06,86.2 79.13,86.13 79.13,85.9 79.06,85.82 78.79,85.82 78.71,85.75 78.71,85.52 78.79,85.44 79.06,85.44 79.13,85.37 79.13,85.14 79.06,85.06 78.79,85.06 78.71,84.98 78.71,84.76 78.79,84.68 79.06,84.68 79.13,84.6 79.13,84.37 79.06,84.3 78.79,84.3 78.71,84.22 78.71,83.99 78.79,83.92 79.06,83.92 79.13,83.84 79.13,83.61 79.06,83.54 78.79,83.54 78.71,83.46 78.71,83.23 78.79,83.16 79.06,83.16 79.13,83.08 79.13,82.66 79.66,82.13 v3(79.88,82.13)
  BOTTOM w0.076: v1(83.01,118.64) 83.06,118.69 83.06,119.74 84.91,121.58 86.46,121.58 86.56,121.48 87.44,121.48 87.82,121.1 87.82,120.64 U4555.BN5
  BOTTOM w0.109: v3(79.88,82.13) 80.16,81.85 80.93,81.85 81.08,82 81.08,83.03 CN4100.3
