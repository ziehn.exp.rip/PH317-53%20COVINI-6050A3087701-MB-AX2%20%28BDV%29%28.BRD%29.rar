# Allegro board PH317-53 COVINI-6050A3087701-MB-AX2 (BDV)(.BRD).brd (continued)
## Nets (continued)
DGND_CHASSIS1: C7579.2(B) C7580.2(B) C7581.2(B) C7582.2(B) CN56200.G1 CN56200.G3 CN56600.G2 CN56600.G4
DGND_CHASSIS2: C7553.1(A) C7554.1(A) C7555.1(A) C7583.1(A) CN2500.G1 CN2500.G2 CN2500.G3 CN2501.G1 CN2501.G3
DGND_CHASSIS4: C7558.1(A) C7559.1(A) C7569.1(A) C7574.1(A) CN2400.G2 CN2400.G4 CN2401.G1 CN2401.G3
DGND_CHASSIS5: C7575.1(A) C7576.1(A) C7577.1(A) C7578.1(A) CN2400.G1 CN2400.G3 JACK400.G2 JACK400.G4
DVDDL: C411.2(B) C412.2(B) C436.1(A) C437.1(A) C438.1(A) L400.2(INB) L401.1(INA) U400.37
GND_A: CN2.1 CN2.4 CN2.G1(G) CN2.G2(G_1) D1.1 S33.1 S34.1 SW1.1 SW1.2
GND_A1: C50.2(B) C51.1(A) CN1.4 CN1.G1(G) CN1.G2(G_1) S28.1 U50.GND
GND_ALG: C16.2(B) C19.2(B) C23.2(B) C24.2(B) C25.1(A) C612.2(B) C613.2(B) C614.2(B) CN601.47 CN601.50 D7521.1 D7522.1 D7523.1 D7533.1 D7534.1 JACK600.5 JACK600.MS R610.2(B)
GND_PB: C401.2(B) C404.2(B) C406.1(A) C407.2(B) C408.1(A) C409.2(B) C410.2(B) C411.1(A) C412.1(A) C413.2(B) C414.2(B) C415.2(B) C416.2(B) C417.2(B) C418.2(B) C419.2(B) C420.2(B) C421.2(B) C422.1(A) C423.1(A) C424.2(B) C425.2(B) C427.2(B) C428.2(B) C433.2(B) C436.2(B) C437.2(B) C438.2(B) C478.2(B) C479.2(B) C608.2(B) C609.2(B) C610.2(B) C611.2(B) C612.1(A) C613.1(A) C614.1(A) C2400.2(B) C2401.2(B) C2404.2(B) C2407.2(B) C2408.2(B) C2409.2(B) C2414.2(B) C2415.2(B) C2416.2(B) C2419.2(B) C2424.2(B) C2425.2(B) C7558.2(B) C7559.2(B) C7569.2(B) C7574.2(B) C7575.2(B) C7576.2(B) C7577.2(B) C7578.2(B) CN600.G1(G) CN600.G2(G_1) CN601.8 CN601.11 CN601.14 CN601.17 CN601.20 CN601.23 CN601.26 CN601.29 CN601.G1 CN601.G2 CN602.1 CN602.G1(G) CN602.G2(G_1) CN2400.4 CN2400.7 CN2401.4 CN2401.7 CN2401.G2 CN2401.G4 D402.3 D402.8 D403.3 D403.8 D608.2 D609.2 D610.2 D611.2 D2400.2 D2401.3 D2401.8 D2402.2 D2403.3 D2403.8 JACK400.G1 JACK400.G3 Q101.1(S1) Q101.4(S2) Q102.S Q401.S R104.2(B) R107.2(B) R109.2(B) R407.1(A) R2414.2(B) R2419.2(B) S12.1 S13.1 S14.1 ST1900.1 U400.27 U400.41 U2400.2 U2401.10 U2401.21 U2401.25 U2403.10 U2403.21 U2403.25 X400.2 X400.4
P0V6S: C4101.1(A) C4102.1(A) C4103.1(A) C4125.1(A) C4126.1(A) C4127.1(A) C4128.1(A) C4138.1(A) C60352.1(A) CN4100.258(VTT) CN4125.258(VTT) PAD60350.2 TP60350.1
P0V6S_DIMM0_VREF_CA: C34.1(A) C4111.1(A) C4171.1(A) CN4100.164(VREFCA) R4150.2(B) R4152.1(A) R4153.2(B)
P0V6S_DIMM1_VREF_DQ: C4144.1(A) C4145.1(A) C4167.1(A) CN4125.164(VREFCA) R4144.2(B) R4145.1(A) R4148.2(B)
P1V0S_DGPU: C50030.1(A) C50031.1(A) C50032.1(A) C50033.1(A) C50034.1(A) C50035.1(A) C50036.1(A) C50037.1(A) C50038.1(A) C50039.1(A) C50040.1(A) C50041.1(A) C50042.1(A) C50050.1(A) C50051.1(A) C50052.1(A) C50053.1(A) C50054.1(A) C50055.1(A) C50056.1(A) C50057.1(A) C50058.1(A) C50059.1(A) C50060.1(A) C51000.1(A) C51600.1(A) C51601.1(A) C51602.1(A) C51610.1(A) C51611.1(A) C51612.1(A) C51730.1(A) C51731.1(A) C51732.1(A) C51733.1(A) C51800.1(A) C51801.1(A) C51802.1(A) C51803.1(A) C51804.1(A) C51900.2(B) C51901.2(B) PAD67600.2 R55225.2(B) R55226.2(B) R55227.2(B) R55228.2(B) TP67600.1 U50000.AR10(NVHS_CVDD_1) U50000.AT11(NVHS_CVDD_2) U50000.BB17(IFP_IOVDD_1) U50000.BB18(IFP_IOVDD_2) U50000.BB20(IFP_IOVDD_3) U50000.BB21(IFP_IOVDD_4) U50000.BB23(IFP_IOVDD_5) U50000.BB33(PEX_CVDD_1) U50000.BB35(PEX_DVDD_1) U50000.BB36(PEX_DVDD_2) U50000.BC17(IFP_IOVDD_6) U50000.BC18(IFP_IOVDD_7) U50000.BC20(IFP_IOVDD_8) U50000.BC21(IFP_IOVDD_9) U50000.BC23(IFP_IOVDD_10) U50000.BC33(PEX_CVDD_2) U50000.BC35(PEX_DVDD_3) U50000.BC36(PEX_DVDD_4) U50000.BD33(PEX_DVDD_5) U50000.BD36(PEX_DVDD_6)
P1V0S_HDMI: C56422.2(B) C56441.1(A) C56442.1(A) C56443.1(A) L56401.1(INA) L56402.1(INA) L56405.2(INB) L56407.2(INB) R56440.2(B) U56400.28(IVDD10) U56400.48(IVDD10_1)
P1V2: C35.1(A) C36.1(A) C37.1(A) C4106.1(A) C4107.1(A) C4108.1(A) C4109.1(A) C4113.1(A) C4114.1(A) C4115.1(A) C4116.1(A) C4117.1(A) C4118.1(A) C4119.1(A) C4120.1(A) C4121.1(A) C4123.1(A) C4139.1(A) C4140.1(A) C4141.1(A) C4142.1(A) C4143.1(A) C4146.1(A) C4147.1(A) C4148.1(A) C4149.1(A) C4150.1(A) C4151.1(A) C4152.1(A) C4153.1(A) C4154.1(A) C4155.1(A) C4156.1(A) C4157.1(A) C4165.1(A) C4170.1(A) C4508.1(A) C4700.1(A) C4701.1(A) C4732.1(A) C4763.1(A) C4764.1(A) C4765.1(A) C4768.1(A) C4769.1(A) C4770.1(A) C4771.1(A) C4772.1(A) C4773.1(A) C4774.1(A) C4775.1(A) C4776.1(A) C7041.1(A) C7572.1(A) CN4100.12(DM0#/DBI0#) CN4100.33(DM1#/DBI1#) CN4100.54(DM2#/DBI2#) CN4100.75(DM3#/DBI3#) CN4100.96(DM8#/DBI8#) CN4100.111(VDD) CN4100.112(VDD_1) CN4100.117(VDD_2) CN4100.118(VDD_3) CN4100.123(VDD_4) CN4100.124(VDD_5) CN4100.129(VDD_6) CN4100.130(VDD_7) CN4100.135(VDD_8) CN4100.136(VDD_9) CN4100.141(VDD_10) CN4100.142(VDD_11) CN4100.147(VDD_12) CN4100.148(VDD_13) CN4100.153(VDD_14) CN4100.154(VDD_15) CN4100.159(VDD_16) CN4100.160(VDD_17) CN4100.163(VDD_18) CN4100.178(DM4#/DBI4#) CN4100.199(DM5#/DBI5#) CN4100.220(DM6#/DBI6#) CN4100.241(DM7#/DBI7#) CN4125.12(DM0#/DBI0#) CN4125.33(DM1#/DBI1#) CN4125.54(DM2#/DBI2#) CN4125.75(DM3#/DBI3#) CN4125.96(DM8#/DBI8#) CN4125.111(VDD) CN4125.112(VDD_1) CN4125.117(VDD_2) CN4125.118(VDD_3) CN4125.123(VDD_4) CN4125.124(VDD_5) CN4125.129(VDD_6) CN4125.130(VDD_7) CN4125.135(VDD_8) CN4125.136(VDD_9) CN4125.141(VDD_10) CN4125.142(VDD_11) CN4125.147(VDD_12) CN4125.148(VDD_13) CN4125.153(VDD_14) CN4125.154(VDD_15) CN4125.159(VDD_16) CN4125.160(VDD_17) CN4125.163(VDD_18) CN4125.178(DM4#/DBI4#) CN4125.199(DM5#/DBI5#) CN4125.220(DM6#/DBI6#) CN4125.241(DM7#/DBI7#) PAD60300.2 Q7007.D R4144.1(A) R4150.1(A) R4200.1(A) R4201.1(A) R4771.2(B) R56453.1(A) TP60300.1 U4555.AA6(VDDQ1) U4555.AE12(VDDQ2) U4555.AF5(VDDQ3) U4555.AF6(VDDQ4) U4555.AG5(VDDQ5) U4555.AG9(VDDQ6) U4555.AJ12(VDDQ7) U4555.AL11(VDDQ8) U4555.AP6(VDDQ9) U4555.AP7(VDDQ10) U4555.AR6(VDDQ12) U4555.AR12(VDDQ11) U4555.AT12(VDDQ13) U4555.AW6(VDDQ14) U4555.AY6(VDDQ15) U4555.J5(VDDQ16) U4555.J6(VDDQ17) U4555.K6(VDDQ19) U4555.K12(VDDQ18) U4555.L6(VDDQ21) U4555.L12(VDDQ20) U4555.R6(VDDQ22) U4555.T6(VDDQ23) U4555.W6(VDDQ24) U4555.Y12(VDDQ25)
P1V05A: C3.1(A) C10.1(A) C100.2(B) C4843.1(A) C4844.1(A) C4847.1(A) C4848.1(A) C4849.1(A) C4850.1(A) C4851.1(A) C4852.1(A) C4853.1(A) C4854.1(A) C4855.1(A) C4858.1(A) C4860.1(A) C4861.1(A) C4862.1(A) C4863.1(A) C4864.1(A) C4865.1(A) C4866.1(A) C4890.1(A) C4891.1(A) C4892.1(A) C7037.1(A) C7038.1(A) C7550.1(A) PAD60900.2 PAD60900.4 R4851.2(B) R4864.2(B) R4872.1(A) R4876.2(B) R4879.2(B) R4880.2(B) R4890.2(B) R4891.1(A) TP60900.1 U4710.AA22(VCCPRIM_1P051) U4710.AA23(VCCPRIM_1P052) U4710.AB20(VCCPRIM_1P053) U4710.AB22(VCCPRIM_1P054) U4710.AB23(VCCPRIM_1P055) U4710.AB27(VCCPRIM_1P056) U4710.AB28(VCCPRIM_1P057) U4710.AB30(VCCPRIM_1P058) U4710.AD20(VCCPRIM_1P059) U4710.AD23(VCCPRIM_1P0510) U4710.AD27(VCCPRIM_1P0511) U4710.AD28(VCCPRIM_1P0512) U4710.AD30(VCCPRIM_1P0513) U4710.AD31(VCCPRIM_1P0514) U4710.AE17(VCCPRIM_1P0515) U4710.AF23(VCCPRIM_1P0516) U4710.AF27(VCCPRIM_1P0517) U4710.AF30(VCCPRIM_1P0518) U4710.AF31(VCCPRIM_1P0519) U4710.AG31(VCCPRIM_1P0520) U4710.B1(VCCAPLL_1P051) U4710.B2(VCCAPLL_1P052) U4710.B3(VCCAPLL_1P053) U4710.C1(VCCAPLL_1P054) U4710.C2(VCCAPLL_1P055) U4710.D1(VCCPRIM_1P0521) U4710.E1(VCCPRIM_1P0522) U4710.U26(VCCPRIM_1P0523) U4710.U29(VCCPRIM_1P0524) U4710.V19(VCCA_BCLK_1P05) U4710.V25(VCCPRIM_1P0525) U4710.V27(VCCPRIM_1P0526) U4710.V28(VCCPRIM_1P0527) U4710.V30(VCCPRIM_1P0528) U4710.V31(VCCPRIM_1P0529) U4710.W19(VCCA_SRC_1P051) U4710.W20(VCCA_SRC_1P052) U4710.W22(VCCDUSB_1P051) U4710.W23(VCCDUSB_1P052) U4710.W31(VCCPRIM_MPHY_1P05) U7003.1 U7003.2 U7003.6 U7003.7
P1V8_MAIN: PAD55300.1 U55300.7(VOUT<1>) U55300.8(VOUT<0>)
P1V8_MAIN_CT: C55302.1(A) U55300.6(CT)
P1V8A: C4.1(A) C7020.1(A) PAD60600.2 R4601.1(A) R4724.2(B) R4725.2(B) R4731.2(B) R4732.2(B) R4824.2(B) R4900.2(B) R4924.2(B) R7066.2(B) R67005.1(A) TP60600.1 U7002.6 U7002.7
P1V8A_1P: C5.1(A) C4830.1(A) R4920.1(A) R4924.1(A) U4710.AN15(VCCPRIM_1P85) U4710.AR15(VCCPRIM_1P86) U4710.BB11(VCCPRIM_1P87)
P1V8S: R515.1(A) R3002.1(A) U7002.8 U7002.9
P1V8S_AON1: C50020.1(A) C50546.1(A) C50547.1(A) C50548.1(A) C50549.1(A) C50550.1(A) C50646.1(A) C50647.1(A) C50648.1(A) C50649.1(A) C50650.1(A) C50746.1(A) C50747.1(A) C50748.1(A) C50749.1(A) C50750.1(A) C50846.1(A) C50847.1(A) C50848.1(A) C50849.1(A) C50850.1(A) C50946.1(A) C50947.1(A) C50948.1(A) C50949.1(A) C50950.1(A) C51046.1(A) C51047.1(A) C51048.1(A) C51049.1(A) C51050.1(A) C51146.1(A) C51147.1(A) C51148.1(A) C51149.1(A) C51150.1(A) C51246.1(A) C51247.1(A) C51248.1(A) C51249.1(A) C51250.1(A) C51400.1(A) C52100.2(B) C55301.2(B) L52110.1(INA) PAD67400.2 PAD67400.4 Q51545.G Q51550.G R50011.2(B) R51400.2(B) R51424.2(B) R51430.1(A) R51432.1(A) R51434.1(A) R51436.1(A) R51438.1(A) R51440.1(A) R51500.2(B) R51501.2(B) R51510.2(B) R51523.2(B) R51524.2(B) R51533.2(B) R51534.2(B) R51540.2(B) R51545.2(B) R51550.2(B) R51560.2(B) R51561.2(B) R51562.2(B) R51563.2(B) R51564.2(B) R51565.2(B) R51566.2(B) R51567.2(B) R51568.2(B) R51569.2(B) R51583.2(B) R51586.2(B) R51752.1(A) R56690.2(B) R56691.2(B) R56692.2(B) TP67400.1 U50020.5 U50500.A5(VPP_2) U50500.A10(VPP_1) U50500.V5(VPP_4) U50500.V10(VPP_3) U50600.A5(VPP_2) U50600.A10(VPP_1) U50600.V5(VPP_4) U50600.V10(VPP_3) U50700.A5(VPP_2) U50700.A10(VPP_1) U50700.V5(VPP_4) U50700.V10(VPP_3) U50800.A5(VPP_2) U50800.A10(VPP_1) U50800.V5(VPP_4) U50800.V10(VPP_3) U50900.A5(VPP_2) U50900.A10(VPP_1) U50900.V5(VPP_4) U50900.V10(VPP_3) U51000.A5(VPP_2) U51000.A10(VPP_1) U51000.V5(VPP_4) U51000.V10(VPP_3) U51100.A5(VPP_2) U51100.A10(VPP_1) U51100.V5(VPP_4) U51100.V10(VPP_3) U51200.A5(VPP_2) U51200.A10(VPP_1) U51200.V5(VPP_4) U51200.V10(VPP_3) U51400.3(WP#) U51400.7(HOLD#) U51400.8(VCC) U55300.1(VIN<0>) U55300.2(VIN<1>) UU52100.A2 UU52100.B2
P1V8S_AON2: C52001.1(A) C52300.1(A) C52301.1(A) C52302.1(A) C52310.1(A) C52311.1(A) C52312.1(A) C52320.1(A) C52321.1(A) C52322.1(A) L52110.2(INB) U50000.BA10(1V8_AON_1) U50000.BB14(1V8_AON_2) U50000.BC14(1V8_AON_3)
P1V8S_AUDIO: C513.1(A) R515.2(B) U500.40(AVDD2)
P1V8S_MAIN1: C50070.1(A) C50071.1(A) C50072.1(A) C50073.1(A) C50074.1(A) C50075.1(A) C50076.1(A) C50077.1(A) C50078.1(A) C50079.1(A) C50080.1(A) C50081.1(A) C50082.1(A) C50083.1(A) C50084.1(A) C50085.1(A) C50086.1(A) C50087.1(A) C55303.1(A) C55304.1(A) L50100.1(INA) L51300.1(INA) PAD55300.2 R50010.2(B) R50090.2(B) R51525.2(B) U50000.BB26(PEX_HVDD_1) U50000.BB27(PEX_HVDD_2) U50000.BB29(PEX_HVDD_3) U50000.BB32(PEX_HVDD_4) U50000.BC26(PEX_HVDD_5) U50000.BC27(PEX_HVDD_6) U50000.BC29(PEX_HVDD_7) U50000.BC30(PEX_HVDD_8) U50000.BC32(PEX_HVDD_9) U50000.BD27(PEX_HVDD_10) U50000.BD30(PEX_HVDD_11)
P1V35S_FBVDDQ: C7500.2(B) C7501.2(B) C7502.2(B) C7503.2(B) C7506.2(B) C7507.2(B) C7508.2(B) C50510.2(B) C50511.2(B) C50512.2(B) C50513.2(B) C50514.2(B) C50515.2(B) C50516.1(A) C50517.1(A) C50518.1(A) C50519.1(A) C50520.1(A) C50521.1(A) C50522.1(A) C50523.1(A) C50524.1(A) C50525.1(A) C50526.1(A) C50527.1(A) C50528.1(A) C50529.1(A) C50530.1(A) C50531.1(A) C50532.1(A) C50533.1(A) C50534.1(A) C50535.1(A) C50536.1(A) C50537.1(A) C50538.1(A) C50539.1(A) C50540.1(A) C50541.1(A) C50542.1(A) C50543.1(A) C50544.1(A) C50545.1(A) C50551.1(A) C50552.1(A) C50553.1(A) C50554.1(A) C50555.1(A) C50556.1(A) C50557.1(A) C50558.1(A) C50559.1(A) C50560.1(A) C50561.1(A) C50562.1(A) C50610.2(B) C50611.2(B) C50612.2(B) C50613.2(B) C50614.2(B) C50615.2(B) C50616.1(A) C50617.1(A) C50618.1(A) C50619.1(A) C50620.1(A) C50621.1(A) C50622.1(A) C50623.1(A) C50624.1(A) C50625.1(A) C50626.1(A) C50627.1(A) C50628.1(A) C50629.1(A) C50630.1(A) C50631.1(A) C50632.1(A) C50633.1(A) C50634.1(A) C50635.1(A) C50636.1(A) C50637.1(A) C50638.1(A) C50639.1(A) C50640.1(A) C50641.1(A) C50642.1(A) C50643.1(A) C50644.1(A) C50645.1(A) C50651.1(A) C50652.1(A) C50653.1(A) C50654.1(A) C50655.1(A) C50656.1(A) C50657.1(A) C50658.1(A) C50659.1(A) C50660.1(A) C50661.1(A) C50662.1(A) C50710.2(B) C50711.2(B) C50712.2(B) C50713.2(B) C50714.2(B) C50715.2(B) C50716.1(A) C50717.1(A) C50718.1(A) C50719.1(A) C50720.1(A) C50721.1(A) C50722.1(A) C50723.1(A) C50724.1(A) C50725.1(A) C50726.1(A) C50727.1(A) C50728.1(A) C50729.1(A) C50730.1(A) C50731.1(A) C50732.1(A) C50733.1(A) C50734.1(A) C50735.1(A) C50736.1(A) C50737.1(A) C50738.1(A) C50739.1(A) C50740.1(A) C50741.1(A) C50742.1(A) C50743.1(A) C50744.1(A) C50745.1(A) C50751.1(A) C50752.1(A) C50753.1(A) C50754.1(A) C50755.1(A) C50756.1(A) C50757.1(A) C50758.1(A) C50759.1(A) C50760.1(A) C50761.1(A) C50762.1(A) C50810.2(B) C50811.2(B) C50812.2(B) C50813.2(B) C50814.2(B) C50815.2(B) C50816.1(A) C50817.1(A) C50818.1(A) C50819.1(A) C50820.1(A) C50821.1(A) C50822.1(A) C50823.1(A) C50824.1(A) C50825.1(A) C50826.1(A) C50827.1(A) C50828.1(A) C50829.1(A) C50830.1(A) C50831.1(A) C50832.1(A) C50833.1(A) C50834.1(A) C50835.1(A) C50836.1(A) C50837.1(A) C50838.1(A) C50839.1(A) C50840.1(A) C50841.1(A) C50842.1(A) C50843.1(A) C50844.1(A) C50845.1(A) C50851.1(A) C50852.1(A) C50853.1(A) C50854.1(A) C50855.1(A) C50856.1(A) C50857.1(A) C50858.1(A) C50859.1(A) C50860.1(A) C50861.1(A) C50862.1(A) C50910.2(B) C50911.2(B) C50912.2(B) C50913.2(B) C50914.2(B) C50915.2(B) C50916.1(A) C50917.1(A) C50918.1(A) C50919.1(A) C50920.1(A) C50921.1(A) C50922.1(A) C50923.1(A) C50924.1(A) C50925.1(A) C50926.1(A) C50927.1(A) C50928.1(A) C50929.1(A) C50930.1(A) C50931.1(A) C50932.1(A) C50933.1(A) C50934.1(A) C50935.1(A) C50936.1(A) C50937.1(A) C50938.1(A) C50939.1(A) C50940.1(A) C50941.1(A) C50942.1(A) C50943.1(A) C50944.1(A) C50945.1(A) C50951.1(A) C50952.1(A) C50953.1(A) C50954.1(A) C50955.1(A) C50956.1(A) C50957.1(A) C50958.1(A) C50959.1(A) C50960.1(A) C50961.1(A) C50962.1(A) C51010.2(B) C51011.2(B) C51012.2(B) C51013.2(B) C51014.2(B) C51015.2(B) C51016.1(A) C51017.1(A) C51018.1(A) C51019.1(A) C51020.1(A) C51021.1(A) C51022.1(A) C51023.1(A) C51024.1(A) C51025.1(A) C51026.1(A) C51027.1(A) C51028.1(A) C51029.1(A) C51030.1(A) C51031.1(A) C51032.1(A) C51033.1(A) C51034.1(A) C51035.1(A) C51036.1(A) C51037.1(A) C51038.1(A) C51039.1(A) C51040.1(A) C51041.1(A) C51042.1(A) C51043.1(A) C51044.1(A) C51045.1(A) C51051.1(A) C51052.1(A) C51053.1(A) C51054.1(A) C51055.1(A) C51056.1(A) C51057.1(A) C51058.1(A) C51059.1(A) C51060.1(A) C51061.1(A) C51062.1(A) C51110.2(B) C51111.2(B) C51112.2(B) C51113.2(B) C51114.2(B) C51115.2(B) C51116.1(A) C51117.1(A) C51118.1(A) C51119.1(A) C51120.1(A) C51121.1(A) C51122.1(A) C51123.1(A) C51124.1(A) C51125.1(A) C51126.1(A) C51127.1(A) C51128.1(A) C51129.1(A) C51130.1(A) C51131.1(A) C51132.1(A) C51133.1(A) C51134.1(A) C51135.1(A) C51136.1(A) C51137.1(A) C51138.1(A) C51139.1(A) C51140.1(A) C51141.1(A) C51142.1(A) C51143.1(A) C51144.1(A) C51145.1(A) C51151.1(A) C51152.1(A) C51153.1(A) C51154.1(A) C51155.1(A) C51156.1(A) C51157.1(A) C51158.1(A) C51159.1(A) C51160.1(A) C51161.1(A) C51162.1(A) C51210.2(B) C51211.2(B) C51212.2(B) C51213.2(B) C51214.2(B) C51215.2(B) C51216.1(A) C51217.1(A) C51218.1(A) C51219.1(A) C51220.1(A) C51221.1(A) C51222.1(A) C51223.1(A) C51224.1(A) C51225.1(A) C51226.1(A) C51227.1(A) C51228.1(A) C51229.1(A) C51230.1(A) C51231.1(A) C51232.1(A) C51233.1(A) C51234.1(A) C51235.1(A) C51236.1(A) C51237.1(A) C51238.1(A) C51239.1(A) C51240.1(A) C51241.1(A) C51242.1(A) C51243.1(A) C51244.1(A) C51245.1(A) C51251.1(A) C51252.1(A) C51253.1(A) C51254.1(A) C51255.1(A) C51256.1(A) C51257.1(A) C51258.1(A) C51259.1(A) C51260.1(A) C51261.1(A) C51262.1(A) C53000.1(A) C53001.1(A) C53002.1(A) C53003.1(A) C53004.1(A) C53005.1(A) C53006.1(A) C53007.1(A) C53008.1(A) C53009.1(A) C53010.1(A) C53011.1(A) C53012.1(A) C53013.1(A) C53014.1(A) C53015.1(A) C53016.1(A) C53017.1(A) C53018.1(A) C53019.1(A) C53020.1(A) C53021.1(A) C53022.1(A) C53023.1(A) C53024.1(A) C53025.1(A) C53026.1(A) C53027.1(A) C53028.1(A) C53029.1(A) C53030.1(A) C53031.1(A) C53032.1(A) C53033.1(A) C53034.1(A) C53035.1(A) C53036.1(A) C53037.1(A) C53038.1(A) C53039.1(A) C53040.1(A) C53041.1(A) C53042.1(A) C53043.1(A) C53044.1(A) C53045.1(A) C53046.1(A) C53047.1(A) C53050.1(A) C53051.1(A) C53052.1(A) C53053.1(A) C53054.1(A) C53055.1(A) C53056.1(A) C53057.1(A) C53060.1(A) C53061.1(A) C53062.1(A) C53063.1(A) C53070.1(A) C53071.1(A) C53072.1(A) C53073.1(A) C53074.1(A) C53075.1(A) C53076.1(A) C53077.1(A) C53078.1(A) C67200.1(A) C67201.1(A) C67202.1(A) C67203.1(A) C67204.1(A) L67210.2 L67210.4 L67220.2 L67220.4 R50120.2(B) R50121.2(B) R50220.2(B) R50221.2(B) R50320.2(B) R50321.2(B) R50420.2(B) R50421.2(B) R50505.2(B) R50605.2(B) R50705.2(B) R50805.2(B) R50905.2(B) R51005.2(B) R51105.2(B) R51205.2(B) R52210.2(B) R55235.2(B) R55236.2(B) R55237.2(B) R55238.2(B) R67200.1(A) TP67200.1 U50000.AA10(FBVDDQ_01) U50000.AA11(FBVDDQ_02) U50000.AA42(FBVDDQ_03) U50000.AA43(FBVDDQ_04) U50000.AC10(FBVDDQ_05) U50000.AC11(FBVDDQ_06) U50000.AC42(FBVDDQ_07) U50000.AC43(FBVDDQ_08) U50000.AD10(FBVDDQ_09) U50000.AD11(FBVDDQ_10) U50000.AD42(FBVDDQ_11) U50000.AD43(FBVDDQ_12) U50000.AF10(FBVDDQ_13) U50000.AF43(FBVDDQ_14) U50000.AG10(FBVDDQ_15) U50000.AG11(FBVDDQ_16) U50000.AG42(FBVDDQ_17) U50000.AG43(FBVDDQ_18) U50000.AJ10(FBVDDQ_19) U50000.AJ11(FBVDDQ_20) U50000.AJ42(FBVDDQ_21) U50000.AJ43(FBVDDQ_22) U50000.AK10(FBVDDQ_23) U50000.AK11(FBVDDQ_24) U50000.AK42(FBVDDQ_25) U50000.AK43(FBVDDQ_26) U50000.AM42(FBVDDQ_27) U50000.AM43(FBVDDQ_28) U50000.AN43(FBVDDQ_29) U50000.AR42(FBVDDQ_30) U50000.AR43(FBVDDQ_31) U50000.AT43(FBVDDQ_32) U50000.K12(FBVDDQ_33) U50000.K14(FBVDDQ_34) U50000.K15(FBVDDQ_35) U50000.K17(FBVDDQ_36) U50000.K18(FBVDDQ_37) U50000.K20(FBVDDQ_38) U50000.K21(FBVDDQ_39) U50000.K23(FBVDDQ_40) U50000.K24(FBVDDQ_41) U50000.K26(FBVDDQ_42) U50000.K27(FBVDDQ_43) U50000.K29(FBVDDQ_44) U50000.K30(FBVDDQ_45) U50000.K32(FBVDDQ_46) U50000.K33(FBVDDQ_47) U50000.K35(FBVDDQ_48) U50000.K36(FBVDDQ_49) U50000.K38(FBVDDQ_50) U50000.K39(FBVDDQ_51) U50000.K41(FBVDDQ_52) U50000.L14(FBVDDQ_53) U50000.L15(FBVDDQ_54) U50000.L18(FBVDDQ_55) U50000.L20(FBVDDQ_56) U50000.L21(FBVDDQ_57) U50000.L23(FBVDDQ_58) U50000.L24(FBVDDQ_59) U50000.L26(FBVDDQ_60) U50000.L27(FBVDDQ_61) U50000.L30(FBVDDQ_62) U50000.L32(FBVDDQ_63) U50000.L33(FBVDDQ_64) U50000.L35(FBVDDQ_65) U50000.L36(FBVDDQ_66) U50000.L39(FBVDDQ_67) U50000.M10(FBVDDQ_68) U50000.M43(FBVDDQ_69) U50000.P10(FBVDDQ_70) U50000.P11(FBVDDQ_71) U50000.P42(FBVDDQ_72) U50000.P43(FBVDDQ_73) U50000.R10(FBVDDQ_74) U50000.R11(FBVDDQ_75) U50000.R42(FBVDDQ_76) U50000.R43(FBVDDQ_77) U50000.U10(FBVDDQ_78) U50000.U11(FBVDDQ_79) U50000.U43(FBVDDQ_80) U50000.V10(FBVDDQ_81) U50000.V42(FBVDDQ_82) U50000.V43(FBVDDQ_83) U50000.Y10(FBVDDQ_84) U50000.Y11(FBVDDQ_85) U50000.Y42(FBVDDQ_86) U50000.Y43(FBVDDQ_87) U50500.A1(VDD_1) U50500.A14(VDD_2) U50500.B5(VDDQ_2) U50500.B10(VDDQ_1) U50500.C1(VDDQ_3) U50500.C4(VDDQ_6) U50500.C11(VDDQ_4) U50500.C14(VDDQ_5) U50500.E1(VDDQ_7) U50500.E5(VDD_4) U50500.E10(VDD_3) U50500.E14(VDDQ_8) U50500.F4(VDDQ_10) U50500.F11(VDDQ_9) U50500.H1(VDDQ_11) U50500.H2(VDD_6) U50500.H13(VDD_5) U50500.H14(VDDQ_12) U50500.J2(VDDQ_14) U50500.J13(VDDQ_13) U50500.K2(VDDQ_16) U50500.K13(VDDQ_15) U50500.L1(VDDQ_17) U50500.L2(VDD_8) U50500.L13(VDD_7) U50500.L14(VDDQ_18) U50500.N4(VDDQ_20) U50500.N11(VDDQ_19) U50500.P1(VDDQ_21) U50500.P5(VDD_10) U50500.P10(VDD_9) U50500.P14(VDDQ_22) U50500.T1(VDDQ_23) U50500.T4(VDDQ_26) U50500.T11(VDDQ_24) U50500.T14(VDDQ_25) U50500.U5(VDDQ_28) U50500.U10(VDDQ_27) U50500.V1(VDD_11) U50500.V14(VDD_12) U50600.A1(VDD_1) U50600.A14(VDD_2) U50600.B5(VDDQ_2) U50600.B10(VDDQ_1) U50600.C1(VDDQ_3) U50600.C4(VDDQ_6) U50600.C11(VDDQ_4) U50600.C14(VDDQ_5) U50600.E1(VDDQ_7) U50600.E5(VDD_4) U50600.E10(VDD_3) U50600.E14(VDDQ_8) U50600.F4(VDDQ_10) U50600.F11(VDDQ_9) U50600.H1(VDDQ_11) U50600.H2(VDD_6) U50600.H13(VDD_5) U50600.H14(VDDQ_12) U50600.J2(VDDQ_14) U50600.J13(VDDQ_13) U50600.K2(VDDQ_16) U50600.K13(VDDQ_15) U50600.L1(VDDQ_17) U50600.L2(VDD_8) U50600.L13(VDD_7) U50600.L14(VDDQ_18) U50600.N4(VDDQ_20) U50600.N11(VDDQ_19) U50600.P1(VDDQ_21) U50600.P5(VDD_10) U50600.P10(VDD_9) U50600.P14(VDDQ_22) U50600.T1(VDDQ_23) U50600.T4(VDDQ_26) U50600.T11(VDDQ_24) U50600.T14(VDDQ_25) U50600.U5(VDDQ_28) U50600.U10(VDDQ_27) U50600.V1(VDD_11) U50600.V14(VDD_12) U50700.A1(VDD_1) U50700.A14(VDD_2) U50700.B5(VDDQ_2) U50700.B10(VDDQ_1) U50700.C1(VDDQ_3) U50700.C4(VDDQ_6) U50700.C11(VDDQ_4) U50700.C14(VDDQ_5) U50700.E1(VDDQ_7) U50700.E5(VDD_4) U50700.E10(VDD_3) U50700.E14(VDDQ_8) U50700.F4(VDDQ_10) U50700.F11(VDDQ_9) U50700.H1(VDDQ_11) U50700.H2(VDD_6) U50700.H13(VDD_5) U50700.H14(VDDQ_12) U50700.J2(VDDQ_14) U50700.J13(VDDQ_13) U50700.K2(VDDQ_16) U50700.K13(VDDQ_15) U50700.L1(VDDQ_17) U50700.L2(VDD_8) U50700.L13(VDD_7) U50700.L14(VDDQ_18) U50700.N4(VDDQ_20) U50700.N11(VDDQ_19) U50700.P1(VDDQ_21) U50700.P5(VDD_10) U50700.P10(VDD_9) U50700.P14(VDDQ_22) U50700.T1(VDDQ_23) U50700.T4(VDDQ_26) U50700.T11(VDDQ_24) U50700.T14(VDDQ_25) U50700.U5(VDDQ_28) U50700.U10(VDDQ_27) U50700.V1(VDD_11) U50700.V14(VDD_12) U50800.A1(VDD_1) U50800.A14(VDD_2) U50800.B5(VDDQ_2) U50800.B10(VDDQ_1) U50800.C1(VDDQ_3) U50800.C4(VDDQ_6) U50800.C11(VDDQ_4) U50800.C14(VDDQ_5) U50800.E1(VDDQ_7) U50800.E5(VDD_4) U50800.E10(VDD_3) U50800.E14(VDDQ_8) U50800.F4(VDDQ_10) U50800.F11(VDDQ_9) U50800.H1(VDDQ_11) U50800.H2(VDD_6) U50800.H13(VDD_5) U50800.H14(VDDQ_12) U50800.J2(VDDQ_14) U50800.J13(VDDQ_13) U50800.K2(VDDQ_16) U50800.K13(VDDQ_15) U50800.L1(VDDQ_17) U50800.L2(VDD_8) U50800.L13(VDD_7) U50800.L14(VDDQ_18) U50800.N4(VDDQ_20) U50800.N11(VDDQ_19) U50800.P1(VDDQ_21) U50800.P5(VDD_10) U50800.P10(VDD_9) U50800.P14(VDDQ_22) U50800.T1(VDDQ_23) U50800.T4(VDDQ_26) U50800.T11(VDDQ_24) U50800.T14(VDDQ_25) U50800.U5(VDDQ_28) U50800.U10(VDDQ_27) U50800.V1(VDD_11) U50800.V14(VDD_12) U50900.A1(VDD_1) U50900.A14(VDD_2) U50900.B5(VDDQ_2) U50900.B10(VDDQ_1) U50900.C1(VDDQ_3) U50900.C4(VDDQ_6) U50900.C11(VDDQ_4) U50900.C14(VDDQ_5) U50900.E1(VDDQ_7) U50900.E5(VDD_4) U50900.E10(VDD_3) U50900.E14(VDDQ_8) U50900.F4(VDDQ_10) U50900.F11(VDDQ_9) U50900.H1(VDDQ_11) U50900.H2(VDD_6) U50900.H13(VDD_5) U50900.H14(VDDQ_12) U50900.J2(VDDQ_14) U50900.J13(VDDQ_13) U50900.K2(VDDQ_16) U50900.K13(VDDQ_15) U50900.L1(VDDQ_17) U50900.L2(VDD_8) U50900.L13(VDD_7) U50900.L14(VDDQ_18) U50900.N4(VDDQ_20) U50900.N11(VDDQ_19) U50900.P1(VDDQ_21) U50900.P5(VDD_10) U50900.P10(VDD_9) U50900.P14(VDDQ_22) U50900.T1(VDDQ_23) U50900.T4(VDDQ_26) U50900.T11(VDDQ_24) U50900.T14(VDDQ_25) U50900.U5(VDDQ_28) U50900.U10(VDDQ_27) U50900.V1(VDD_11) U50900.V14(VDD_12) U51000.A1(VDD_1) U51000.A14(VDD_2) U51000.B5(VDDQ_2) U51000.B10(VDDQ_1) U51000.C1(VDDQ_3) U51000.C4(VDDQ_6) U51000.C11(VDDQ_4) U51000.C14(VDDQ_5) U51000.E1(VDDQ_7) U51000.E5(VDD_4) U51000.E10(VDD_3) U51000.E14(VDDQ_8) U51000.F4(VDDQ_10) U51000.F11(VDDQ_9) U51000.H1(VDDQ_11) U51000.H2(VDD_6) U51000.H13(VDD_5) U51000.H14(VDDQ_12) U51000.J2(VDDQ_14) U51000.J13(VDDQ_13) U51000.K2(VDDQ_16) U51000.K13(VDDQ_15) U51000.L1(VDDQ_17) U51000.L2(VDD_8) U51000.L13(VDD_7) U51000.L14(VDDQ_18) U51000.N4(VDDQ_20) U51000.N11(VDDQ_19) U51000.P1(VDDQ_21) U51000.P5(VDD_10) U51000.P10(VDD_9) U51000.P14(VDDQ_22) U51000.T1(VDDQ_23) U51000.T4(VDDQ_26) U51000.T11(VDDQ_24) U51000.T14(VDDQ_25) U51000.U5(VDDQ_28) U51000.U10(VDDQ_27) U51000.V1(VDD_11) U51000.V14(VDD_12) U51100.A1(VDD_1) U51100.A14(VDD_2) U51100.B5(VDDQ_2) U51100.B10(VDDQ_1) U51100.C1(VDDQ_3) U51100.C4(VDDQ_6) U51100.C11(VDDQ_4) U51100.C14(VDDQ_5) U51100.E1(VDDQ_7) U51100.E5(VDD_4) U51100.E10(VDD_3) U51100.E14(VDDQ_8) U51100.F4(VDDQ_10) U51100.F11(VDDQ_9) U51100.H1(VDDQ_11) U51100.H2(VDD_6) U51100.H13(VDD_5) U51100.H14(VDDQ_12) U51100.J2(VDDQ_14) U51100.J13(VDDQ_13) U51100.K2(VDDQ_16) U51100.K13(VDDQ_15) U51100.L1(VDDQ_17) U51100.L2(VDD_8) U51100.L13(VDD_7) U51100.L14(VDDQ_18) U51100.N4(VDDQ_20) U51100.N11(VDDQ_19) U51100.P1(VDDQ_21) U51100.P5(VDD_10) U51100.P10(VDD_9) U51100.P14(VDDQ_22) U51100.T1(VDDQ_23) U51100.T4(VDDQ_26) U51100.T11(VDDQ_24) U51100.T14(VDDQ_25) U51100.U5(VDDQ_28) U51100.U10(VDDQ_27) U51100.V1(VDD_11) U51100.V14(VDD_12) U51200.A1(VDD_1) U51200.A14(VDD_2) U51200.B5(VDDQ_2) U51200.B10(VDDQ_1) U51200.C1(VDDQ_3) U51200.C4(VDDQ_6) U51200.C11(VDDQ_4) U51200.C14(VDDQ_5) U51200.E1(VDDQ_7) U51200.E5(VDD_4) U51200.E10(VDD_3) U51200.E14(VDDQ_8) U51200.F4(VDDQ_10) U51200.F11(VDDQ_9) U51200.H1(VDDQ_11) U51200.H2(VDD_6) U51200.H13(VDD_5) U51200.H14(VDDQ_12) U51200.J2(VDDQ_14) U51200.J13(VDDQ_13) U51200.K2(VDDQ_16) U51200.K13(VDDQ_15) U51200.L1(VDDQ_17) U51200.L2(VDD_8) U51200.L13(VDD_7) U51200.L14(VDDQ_18) U51200.N4(VDDQ_20) U51200.N11(VDDQ_19) U51200.P1(VDDQ_21) U51200.P5(VDD_10) U51200.P10(VDD_9) U51200.P14(VDDQ_22) U51200.T1(VDDQ_23) U51200.T4(VDDQ_26) U51200.T11(VDDQ_24) U51200.T14(VDDQ_25) U51200.U5(VDDQ_28) U51200.U10(VDDQ_27) U51200.V1(VDD_11) U51200.V14(VDD_12)
P2V5: C4100.1(A) C4131.1(A) C4132.1(A) C4133.1(A) C4134.1(A) C4135.1(A) C4136.1(A) C4137.1(A) CN4100.257(VPP) CN4100.259(VPP_1) CN4125.257(VPP) CN4125.259(VPP_1) PAD60400.2 TP60400.1
P3V3_NV_SEQ: C53500.1(A) C53520.1(A) C53540.1(A) C53550.1(A) C53570.1(A) C53580.1(A) C53590.1(A) R51592.1(A) R51593.2(B) R51595.1(A) R51596.2(B) R53510.1(A) R53511.1(A) R53530.1(A) R53541.2(B) R55600.2(B) U53500.5 U53520.5 U53540.5 U53550.5 U53555.5 U53570.5 U53580.5 U53585.5 U53590.5
P3V3_RTC: C4712.1(A) C4875.1(A) C4876.1(A) D4700.3(C) R4762.2(B) R4764.1(A) R4833.2(B) U4710.BC49(VCCRTC1) U4710.BD49(VCCRTC2)
P3V3A: C33.1(A) C309.1(A) C1300.1(A) C3501.1(A) C3502.1(A) C4813.1(A) C4815.1(A) C4816.1(A) C4817.1(A) C4829.1(A) C4867.1(A) C4868.1(A) C4869.1(A) C4870.1(A) C4872.1(A) C7010.1(A) CN603.48 PAD282.1 PAD7003.2 Q701.3 Q3000.1(G) R7.1(A) R24.1(A) R41.2(B) R55.2(B) R56.2(B) R149.1(A) R282.2(B) R304.2(B) R306.2(B) R330.1(A) R354.1(A) R705.1(A) R1300.2(B) R1325.1(A) R2403.2(B) R3500.2(B) R3501.2(B) R3502.2(B) R4116.2(B) R4699.2(B) R4702.2(B) R4708.2(B) R4711.2(B) R4713.2(B) R4717.2(B) R4720.2(B) R4726.2(B) R4727.2(B) R4728.2(B) R4733.2(B) R4742.1(A) R4747.2(B) R4760.2(B) R4767.2(B) R4774.2(B) R4783.2(B) R4802.1(A) R4803.1(A) R4810.1(A) R4812.1(A) R4819.1(A) R4820.1(A) R4825.1(A) R4826.1(A) R4827.1(A) R4828.1(A) R4834.2(B) R4882.1(A) R4906.2(B) R4908.2(B) R4909.2(B) R4911.1(A) R4912.2(B) R4913.1(A) R4915.2(B) R7006.1(A) R7008.1(A) R7016.1(A) R7017.1(A) R7043.1(A) R7065.2(B) R60522.1(A) U300.8 U1300.1(VIN<0>) U1300.2(VIN<1>) U1300.4(VBIAS) U3500.1(VSB) U4700.5 U4710.AC35(VCCPGPPHK1) U4710.AC36(VCCPGPPHK2) U4710.AE35(VCCPGPPEF1) U4710.AE36(VCCPGPPEF2) U4710.AN21(VCCPGPPG_3P3) U4710.AN26(VCCPGPPBC1) U4710.AN44(VCCSPI) U4710.AP26(VCCPGPPBC2) U4710.AT44(VCCPRIM_3P31) U4710.AW9(VCCPRIM_3P32) U4710.AY8(VCCPRIM_3P33) U4710.BB7(VCCPRIM_3P34) U4710.V23(VCCPRIM_3P35) XU300.8(VDD)
P3V3A_5A_PWEN: D7005.3(A1) R148.1(A) R314.2(B) R7003.1(A) U1.25(PWM1/GPA1) U2.3
P3V3A_KBLED: C700.2(B) C701.1(A) C706.1(A) Q700.2(G1) Q700.5(G2) Q701.2 R700.1(A) R701.1(A) R703.2(B) U702.27(VCC) U702.31(A0)
P3V3A_LAN: C413.1(A) C414.1(A) C415.1(A) C418.1(A) C419.1(A) C426.1(A) C427.1(A) C428.1(A) Q400.2 R400.1(A) R402.2(B) R405.2(B) R406.2(B) R416.2(B) R417.1(A) R418.1(A) R419.2(B) U400.1 U400.16
P3V3A_PB: C2408.1(A) C2409.1(A) C2419.1(A) C2425.1(A) CN601.3 R2404.1(A) R2405.1(A) R2406.1(A) R2407.1(A) R2408.1(A) R2409.2(B) R2412.1(A) R2413.1(A) R2415.2(B) R2416.2(B) R2417.2(B) R2418.2(B) R2420.2(B) R2421.2(B) R2422.1(A) R2423.1(A) R2424.1(A) R2426.2(B) R2427.2(B) R2428.2(B) U2401.1 U2401.13 U2403.1 U2403.13
P3V3A_WLAN: C1310.1(A) C1312.1(A) C1313.1(A) C1314.1(A) C1315.1(A) C1316.1(A) C1317.1(A) C1318.1(A) C1319.1(A) CN1300.2(3P3VAUX1) CN1300.4(3P3VAUX2) CN1300.72(3P3VAUX3) CN1300.74(3P3VAUX4) Q1312.1(G) Q1313.1(G) R1325.2(B) R1350.1(A) R1351.1(A) R1357.1(A) R1359.2(B) R1360.2(B) U1300.7(VOUT<1>) U1300.8(VOUT<0>)
P3V3AL: C62.1(A) C254.2(B) C306.1(A) C307.1(A) C308.1(A) CN254.1 CN254.2 D300.3(A1) L1.1(INA) PAD60191.2 R28.2(B) R255.1(A) R314.1(A) R321.1(A) R324.1(A) R326.1(A) R336.1(A) R337.1(A) R343.2(B) R348.1(A) R359.1(A) R360.1(A) R361.1(A) R362.1(A) R367.2(B) R392.1(A) R514.2(B) R4751.1(A) R7014.1(A) R7015.2(B) R7603.2(B) R52072.2(B) R52074.1(A) R60007.2(B) R60013.2(B) TP60191.1 U1.26(VSTBY_1) U1.50(VSTBY_2) U1.92(VSTBY_3) U1.114(VSTBY_4) U1.121(VSTBY_5) U250.VDD
P3V3AL_EC_AVCC: C310.1(A) R326.2(B) U1.74(AVCC)
P3V3AL_EC_FSPI: C313.1(A) R24.2(B) U1.106(VSTBY_FSPI)
P3V3AL_EC_VSTBY_PLL: C316.1(A) L1.2(INB) U1.127(VSTBY<0>)
P3V3AL_RTC_BAT: D4711.3(A1) R4769.2(B) R4832.2(B)
P3V3AL_RTC_BAT_BOT: CN4700.1 D4711.1(A2) R4832.1(A) TP16.1
P3V3AL_RTC_BAT_R: D4700.1(A1) R4769.1(A)
P3V3AL_SM: C51.2(B) CN1.1 CN1.2 U50.VDD
P3V3DS: C4824.1(A) C4825.1(A) C7017.1(A) C7019.1(A) C7570.1(A) CN603.49 CN603.50 PAD60100.2 PAD60610.1 R4793.2(B) R4804.1(A) R4805.1(A) R67006.1(A) R67007.1(A) R67014.1(A) TP60100.1 U2.1 U2.2 U2.6 U2.7 U2502.5 U4710.BE48(VCCDSW_3P31) U4710.BE49(VCCDSW_3P32)
P3V3DS_PB: CN601.1 CN601.2 Q400.3 R406.1(A) R408.1(A)
P3V3S: C508.1(A) C509.1(A) C516.1(A) C517.1(A) C532.1(A) C1711.1(A) C1712.1(A) C1713.1(A) C1714.1(A) C1715.1(A) C3000.1(A) C4104.1(A) C4105.1(A) C4129.1(A) C4130.1(A) C4450.1(A) C7018.1(A) C7551.1(A) C7552.1(A) C56250.2(B) CN301.1 CN4100.255(VDDSPD) CN4125.255(VDDSPD) FUSE3001.1(A) PAD1901.2 PAD1902.2 PAD3500.1 PAD7002.2 Q303.2(G1) Q303.5(G2) Q4702.2(G1) Q4702.5(G2) Q7003.G R25.1(A) R317.1(A) R318.1(A) R319.1(A) R325.1(A) R327.1(A) R328.1(A) R329.1(A) R344.1(A) R504.2(B) R525.1(A) R1701.1(A) R1702.1(A) R1703.1(A) R1704.1(A) R1705.1(A) R1706.1(A) R1707.1(A) R1708.1(A) R1709.1(A) R1718.1(A) R1903.1(A) R1904.1(A) R1905.2(B) R4210.1(A) R4212.1(A) R4214.1(A) R4216.1(A) R4218.1(A) R4220.1(A) R4300.1(A) R4301.1(A) R4302.1(A) R4305.1(A) R4452.1(A) R4453.1(A) R4705.1(A) R4707.1(A) R4714.1(A) R4715.1(A) R4749.1(A) R4754.1(A) R4755.1(A) R4757.1(A) R4761.1(A) R4763.1(A) R4765.1(A) R4766.1(A) R4768.1(A) R4773.1(A) R4775.1(A) R4779.2(B) R4780.2(B) R4781.2(B) R4782.2(B) R4784.2(B) R4806.2(B) R4807.2(B) R4808.2(B) R4809.2(B) R4811.2(B) R4815.1(A) R4818.2(B) R4822.1(A) R4831.1(A) R4837.1(A) R4839.1(A) R4842.1(A) R4916.2(B) R4919.2(B) R4935.2(B) R7010.1(A) R50012.2(B) R51511.2(B) R52070.2(B) R52073.1(A) R53505.2(B) R55600.1(A) R55602.1(A) R55820.1(A) R55821.1(A) R56282.2(B) R56290.2(B) R56450.1(A) R56451.1(A) R66602.2(B) U500.1(DVDD) U500.9(DVDD-IO) U500.36(CPVDD) U1700.1(VDD) U1700.10(VDD_1) U1700.16(VDD_2) U1700.25(VDD_3) U3000.5 U4450.1 U56250.5
P3V3S_DP: C55820.1(A) C55821.1(A) C55822.1(A) C55823.1(A) C55824.1(A) C55825.1(A) C55826.1(A) C55827.1(A) R55810.2(B) R55820.2(B) R55821.2(B) R55830.2(B) R55831.2(B) R55832.2(B) U55800.3(VDD) U55800.9(VDD_1) U55800.15(VDD_2) U55800.24(VDD_3) U55800.27(VDD_4) U55800.33(VDD_5) U55800.36(VDD_6)
P3V3S_DPP: C56200.1(A) C56201.1(A) C56202.1(A) C56251.1(A) C56252.1(A) CN56200.20 D56222.2 PAD56250.2 R51630.2(B)
P3V3S_EC_VCC: C304.1(A) R354.2(B) U1.11(VCC)
P3V3S_HDMI: C56420.1(A) C56421.2(B) L56400.1(INA) L56408.2(INB) R56410.2(B) R56411.2(B) R56413.2(B) R56414.2(B) R56430.2(B) R56432.2(B) R56436.2(B) R56450.2(B) R56451.2(B) R56452.1(A) R56472.2(B) R56670.2(B) R56672.2(B) R56675.2(B) U56400.3(MCUVDD) U56400.7(OVDD33) U56400.8(I2CEN) U56400.31(OVDD33_1)
P3V3S_LCDVDD2: C3001.1(A) C3002.1(A) CN5.36 CN5.37 CN5.38 PAD3000.2
P3V3S_SENSOR: R52000.2(B) R52006.2(B) R52036.2(B) R52037.2(B) R52038.2(B) R52039.2(B) R52061.2(B) R52073.2(B) R52074.2(B)
P3V3S_TP: CN280.1 PAD282.2 Q281.2(G1) Q281.5(G2) R285.2(B) R287.2(B) R288.2(B)
P5V0: CN604.1 CN604.2 CN604.3 PAD60250.2 PAD60250.4 TP60250.1
P5V0A_PB: C2407.1(A) C2424.1(A) CN602.2 CN602.3 CN602.4 D101.1(IN) D102.2(A2) U2400.5
P5V0A_USB1: C2400.1(A) C2401.1(A) C2404.1(A) C2414.1(A) C2415.1(A) C2416.1(A) CN2400.1 CN2401.1 D2400.5 D2402.5 U2400.1
P5V0DS: C2402.1(A) C2403.1(A) C2505.1(A) C2506.1(A) C2549.1(A) C7016.1(A) C7547.1(A) C67609.1(A) PAD60200.2 PAD60410.1 PAD67610.1 R143.2(B) R145.2(B) R2401.2(B) R2402.2(B) R2500.1(A) R2501.1(A) R2557.2(B) R2559.1(A) R7038.2(B) R7039.2(B) R55210.2(B) R55220.2(B) R55230.2(B) TP60200.1 U2.4 U8.3(IN) U2500.6 U2501.1 U7002.1 U7002.2 U7002.4 U7003.4 U7006.5 U67600.8
P5V0S: C137.1(A) C519.1(A) C522.1(A) C55300.2(B) C56610.1(A) D501.1(A1) PAD1.2 PAD1700.1 PAD4300.1 PAD4301.1 Q250.3 R251.1(A) R500.1(A) R513.1(A) R51671.2(B) R51672.2(B) R51681.2(B) R51682.2(B) U55300.4(VBIAS) U56610.3
P5V0S_AUDIO_AVDD: C504.1(A) C505.1(A) R500.2(B) U500.26(AVDD1)
P5V0S_FAN1: C4303.1(A) C4304.1(A) CN4300.1 PAD4300.2 TP4300.1
P5V0S_FAN2: C4307.1(A) C4308.1(A) CN4301.1 PAD4301.2 TP4301.1
P5V0S_HDMI: CN56600.18 D56610.2 R56678.2(B) R56680.2(B) U56610.2
P5V0S_KBLED: C250.1(A) C252.1(A) C255.2(B) CN251.2 CN251.4 CN252.13 CN252.14 Q250.2
P5V0S_PVDD: C514.1(A) C515.1(A) C520.1(A) C521.1(A) R513.2(B) U500.41(PVDD1) U500.46(PVDD2)
P5VDS_EN: R348.2(B) R6901.2(B) U1.97(ID4/GPH4)
PVBAT: C7545.1(A) C7548.1(A) C7549.1(A) C7560.1(A) C7561.1(A) C7562.1(A) C7563.1(A) C7565.1(A) CN253.G1(G) CN253.G2(G_1) D60000.2(A2) PAD3001.1 PAD60000.2 PAD60110.1 PAD60210.1 PAD60260.1 PAD60310.1 PAD60510.1 PAD60910.1 PAD66010.1 PAD66310.1 PAD66610.1 PAD67410.1 Q5000.1(S0) Q5000.2(S1) Q5000.3(S2) Q60012.5(D3) Q60012.6(D2) Q60012.7(D1) Q60012.8(D0) R5000.1(A) R60000.2 TP60000.1
PVBAT_CPU: C66010.1(A) C66011.1(A) C66020.1(A) C66021.1(A) C66030.1(A) C66031.1(A) C66040.1(A) C66041.1(A) C66296.1(A) C66297.1(A) C66298.1(A) C66299.1(A) PAD66010.2 R66199.1(A) U66010.8(VIN_3) U66010.9(VIN) U66010.10(VIN_1) U66010.11(VIN_2) U66020.8(VIN_3) U66020.9(VIN) U66020.10(VIN_1) U66020.11(VIN_2) U66030.8(VIN_3) U66030.9(VIN) U66030.10(VIN_1) U66030.11(VIN_2) U66040.8(VIN_3) U66040.9(VIN) U66040.10(VIN_1) U66040.11(VIN_2)
PVBAT_GT: C66310.1(A) C66311.1(A) C66312.1(A) C66598.1(A) C66599.1(A) PAD66310.2 Q66310.2 Q66310.3 Q66310.4 Q66311.2 Q66311.3 Q66311.4
PVBAT_IMON: Q5000.5(D3) Q5000.6(D2) Q5000.7(D1) Q5000.8(D0) R67099.1
PVBAT_SA: C66610.1(A) C66611.1(A) PAD66610.2 Q66610.2 Q66610.3 Q66610.4
PVBAT_VRAM_DGPU: C67210.1(A) C67211.1(A) C67212.1(A) C67220.1(A) C67221.1(A) C67222.1(A) C67298.1(A) C67299.1(A) PAD67210.2 Q67210.2 Q67210.3 Q67210.4 Q67220.2 Q67220.3 Q67220.4 R67218.1(A)
PVCCGT: C4554.1(A) C4555.1(A) C4580.1(A) C4581.1(A) C4582.1(A) C4583.1(A) C4584.1(A) C4585.1(A) C4588.1(A) C4589.1(A) C4600.1(A) C4602.1(A) C4627.1(A) C4628.1(A) C4629.1(A) C4630.1(A) C4631.1(A) C4656.1(A) C4657.1(A) C4658.1(A) C4659.1(A) C4660.1(A) C4661.1(A) C4662.1(A) C4663.1(A) C4668.1(A) C4680.1(A) C4681.1(A) C4682.1(A) C4683.1(A) C4687.1(A) C4688.1(A) C4760.1(A) C4761.1(A) C4785.1(A) C4797.1(A) C7509.2(B) C7510.2(B) C7511.2(B) C66300.1(A) C66301.1(A) C66303.1(A) C66306.1(A) C66307.1(A) C66308.1(A) C66309.1(A) L66310.2 R4525.2(B) TP66300.1 U4555.AT14(VCCGT1) U4555.AT31(VCCGT2) U4555.AT32(VCCGT3) U4555.AT33(VCCGT4) U4555.AT34(VCCGT5) U4555.AT35(VCCGT6) U4555.AT36(VCCGT7) U4555.AT37(VCCGT8) U4555.AT38(VCCGT9) U4555.AU14(VCCGT10) U4555.AU29(VCCGT11) U4555.AU30(VCCGT12) U4555.AU31(VCCGT13) U4555.AU32(VCCGT14) U4555.AU35(VCCGT15) U4555.AU36(VCCGT16) U4555.AU37(VCCGT17) U4555.AU38(VCCGT18) U4555.AV29(VCCGT19) U4555.AV30(VCCGT20) U4555.AV31(VCCGT21) U4555.AV32(VCCGT22) U4555.AV33(VCCGT23) U4555.AV34(VCCGT24) U4555.AV35(VCCGT25) U4555.AV36(VCCGT26) U4555.AW14(VCCGT27) U4555.AW31(VCCGT28) U4555.AW32(VCCGT29) U4555.AW33(VCCGT30) U4555.AW34(VCCGT31) U4555.AW35(VCCGT32) U4555.AW36(VCCGT33) U4555.AW37(VCCGT34) U4555.AW38(VCCGT35) U4555.AY29(VCCGT36) U4555.AY30(VCCGT37) U4555.AY31(VCCGT38) U4555.AY32(VCCGT39) U4555.AY35(VCCGT40) U4555.AY36(VCCGT41) U4555.AY37(VCCGT42) U4555.AY38(VCCGT43) U4555.BA13(VCCGT44) U4555.BA14(VCCGT45) U4555.BA29(VCCGT46) U4555.BA30(VCCGT47) U4555.BA31(VCCGT48) U4555.BA32(VCCGT49) U4555.BA33(VCCGT50) U4555.BA34(VCCGT51) U4555.BA35(VCCGT52) U4555.BA36(VCCGT53) U4555.BB13(VCCGT54) U4555.BB14(VCCGT55) U4555.BB31(VCCGT56) U4555.BB32(VCCGT57) U4555.BB33(VCCGT58) U4555.BB34(VCCGT59) U4555.BB35(VCCGT60) U4555.BB36(VCCGT61) U4555.BB37(VCCGT62) U4555.BB38(VCCGT63) U4555.BC29(VCCGT64) U4555.BC30(VCCGT65) U4555.BC31(VCCGT66) U4555.BC32(VCCGT67) U4555.BC35(VCCGT68) U4555.BC36(VCCGT69) U4555.BC37(VCCGT70) U4555.BC38(VCCGT71) U4555.BD13(VCCGT72) U4555.BD14(VCCGT73) U4555.BD29(VCCGT74) U4555.BD30(VCCGT75) U4555.BD31(VCCGT76) U4555.BD32(VCCGT77) U4555.BD33(VCCGT78) U4555.BD34(VCCGT79) U4555.BD35(VCCGT80) U4555.BD36(VCCGT81) U4555.BE31(VCCGT82) U4555.BE32(VCCGT83) U4555.BE33(VCCGT84) U4555.BE34(VCCGT85) U4555.BE35(VCCGT86) U4555.BE36(VCCGT87) U4555.BE37(VCCGT88) U4555.BE38(VCCGT89) U4555.BF13(VCCGT90) U4555.BF14(VCCGT91) U4555.BF29(VCCGT92) U4555.BF30(VCCGT93) U4555.BF31(VCCGT94) U4555.BF32(VCCGT95) U4555.BF35(VCCGT96) U4555.BF36(VCCGT97) U4555.BF37(VCCGT98) U4555.BF38(VCCGT99) U4555.BG29(VCCGT100) U4555.BG30(VCCGT101) U4555.BG31(VCCGT102) U4555.BG32(VCCGT103) U4555.BG33(VCCGT104) U4555.BG34(VCCGT105) U4555.BG35(VCCGT106) U4555.BG36(VCCGT107) U4555.BH33(VCCGT108) U4555.BH34(VCCGT109) U4555.BH35(VCCGT110) U4555.BH36(VCCGT111) U4555.BH37(VCCGT112) U4555.BH38(VCCGT113) U4555.BJ16(VCCGT114) U4555.BJ17(VCCGT115) U4555.BJ19(VCCGT116) U4555.BJ20(VCCGT117) U4555.BJ21(VCCGT118) U4555.BJ23(VCCGT119) U4555.BJ24(VCCGT120) U4555.BJ26(VCCGT121) U4555.BJ27(VCCGT122) U4555.BJ37(VCCGT123) U4555.BJ38(VCCGT124) U4555.BK16(VCCGT125) U4555.BK17(VCCGT126) U4555.BK19(VCCGT127) U4555.BK20(VCCGT128) U4555.BK21(VCCGT129) U4555.BK23(VCCGT130) U4555.BK24(VCCGT131) U4555.BK26(VCCGT132) U4555.BK27(VCCGT133) U4555.BL15(VCCGT134) U4555.BL16(VCCGT135) U4555.BL17(VCCGT136) U4555.BL23(VCCGT137) U4555.BL24(VCCGT138) U4555.BL25(VCCGT139) U4555.BL26(VCCGT140) U4555.BL27(VCCGT141) U4555.BL28(VCCGT142) U4555.BL36(VCCGT143) U4555.BL37(VCCGT144) U4555.BM15(VCCGT145) U4555.BM16(VCCGT146) U4555.BM17(VCCGT147) U4555.BM36(VCCGT148) U4555.BM37(VCCGT149) U4555.BN15(VCCGT150) U4555.BN16(VCCGT151) U4555.BN17(VCCGT152) U4555.BN36(VCCGT153) U4555.BN37(VCCGT154) U4555.BN38(VCCGT155) U4555.BP15(VCCGT156) U4555.BP16(VCCGT157) U4555.BP17(VCCGT158) U4555.BP37(VCCGT159) U4555.BP38(VCCGT160) U4555.BR15(VCCGT161) U4555.BR16(VCCGT162) U4555.BR17(VCCGT163) U4555.BR37(VCCGT164) U4555.BT15(VCCGT165) U4555.BT16(VCCGT166) U4555.BT17(VCCGT167) U4555.BT37(VCCGT168)
PVCCIO: C4731.1(A) C4733.1(A) C4783.1(A) C7571.1(A) PAD60500.2 R4501.1(A) R4524.2(B) R4535.2(B) R4544.2(B) TP60500.1 U4555.AG12(VCCIO1) U4555.G15(VCCIO2) U4555.G17(VCCIO3) U4555.G19(VCCIO4) U4555.G21(VCCIO5) U4555.H15(VCCIO6) U4555.H16(VCCIO7) U4555.H17(VCCIO8) U4555.H19(VCCIO9) U4555.H20(VCCIO10) U4555.H21(VCCIO11) U4555.H26(VCCIO12) U4555.H27(VCCIO13) U4555.J15(VCCIO14) U4555.J16(VCCIO15) U4555.J17(VCCIO16) U4555.J19(VCCIO17) U4555.J20(VCCIO18) U4555.J21(VCCIO19) U4555.J26(VCCIO20) U4555.J27(VCCIO21)
PVCCSA: C4703.1(A) C4706.1(A) C4708.1(A) C4709.1(A) C4716.1(A) C4717.1(A) C4718.1(A) C4719.1(A) C4778.1(A) C4779.1(A) C4780.1(A) C4781.1(A) C4782.1(A) C4787.1(A) C4789.1(A) C4790.1(A) C4791.1(A) C7546.1(A) C66600.1(A) C66601.1(A) C66602.1(A) C66603.1(A) C66604.1(A) L66610.2 R4517.2(B) TP66600.1 U4555.J30(VCCSA1) U4555.K29(VCCSA2) U4555.K30(VCCSA3) U4555.K31(VCCSA4) U4555.K32(VCCSA5) U4555.K33(VCCSA6) U4555.K34(VCCSA7) U4555.K35(VCCSA8) U4555.L31(VCCSA9) U4555.L32(VCCSA10) U4555.L35(VCCSA11) U4555.L36(VCCSA12) U4555.L37(VCCSA13) U4555.L38(VCCSA14) U4555.M29(VCCSA15) U4555.M30(VCCSA16) U4555.M31(VCCSA17) U4555.M32(VCCSA18) U4555.M33(VCCSA19) U4555.M34(VCCSA20) U4555.M35(VCCSA21) U4555.M36(VCCSA22)
PVCCST: C4540.1(A) C4541.1(A) C4729.1(A) C4730.1(A) C66100.1(A) R4509.1(A) R4533.1(A) R4538.1(A) R4570.2(B) R4736.2(B) R4739.1(A) R4743.1(A) R4786.2(B) R66100.1(A) R66101.1(A) R66104.1(A) U4555.H28(VCCPLL1) U4555.H30(VCCST) U4555.J28(VCCPLL2)
PVCCSTG: C4766.1(A) C7205.1(A) R4507.1(A) R4510.2(B) R4515.2(B) R4516.2(B) R7034.2(B) U4555.G30(VCCSTG1) U4555.H29(VCCSTG2) U7003.13 U7003.14
PVCCSTG_DIS: Q9.3(D2) R7034.1(A)
PVCCSTG_DISCHARGE_EN: Q9.5(G2) Q9.6(D1) R145.1(A) R146.2(B)
PVCCSTG_EN: C7034.1(A) Q9.2(G1) R7030.2(B) R7070.2(B) U7003.3
VBUS_EN: U8.4(VBUS_EN/ATTACHED) U2502.2
VCC_XTAL: C4809.1(A) C4845.1(A) C4846.1(A) C4877.1(A) R4864.1(A) U4710.P2(VCCA_XTAL_1P051) U4710.P3(VCCA_XTAL_1P052)
VCCAMPHYPLL: C4856.1(A) C4857.1(A) C4873.1(A) C4874.1(A) R4851.1(A) U4710.C49(VCCAMPHYPLL_1P051) U4710.D49(VCCAMPHYPLL_1P052) U4710.E49(VCCAMPHYPLL_1P053)
VCCDPHY_1P243: C6.1(A) U4710.BG5(VCCDPHY_1P243)
VCCDSW_1P5: C4859.1(A) U4710.BG45(VCCDSW_1P051) U4710.BG46(VCCDSW_1P052)
VCCHDA: C4827.1(A) R4915.1(A) R4916.1(A) U4710.BB14(VCCHDA)
VCCIO_PG: R7016.2(B) R7018.1(A) U60500.13
VCCIO_VCCSENSE: R4524.1(A) U4555.H14(VCCIO_SENSE) U60500.12
VCCIO_VSSSENSE: C60509.2(B) R4522.1(A) R60526.1(A) U4555.J14(VSSIO_SENSE) U60500.11
VCCMPHY_SENSE: R4874.2(B)
VCCMPHY_SENSE_L: R4872.2(B) R4874.1(A) U4710.K47(VCCMPHY_SENSE)
VCCPLL_OC: C4726.1(A) C4786.1(A) C7042.2(B) Q7007.S R7035.2(B) U4555.BH13(VCCPLL_OC1) U4555.BJ13(VCCPLL_OC2) U4555.G11(VCCPLL_OC3)
VCCPLL_OC_DIS: Q10.3(D2) R7035.1(A)
VCCPLL_OC_DISCHARGE_EN: Q10.5(G2) Q10.6(D1) R143.1(A) R144.2(B)
VCCPLL_OC_EN: C7039.1(A) Q10.2(G1) Q7006.5(G2) R7069.2(B)
VCCPRIM_1P2: C7.1(A) C8.1(A) C9.1(A) U4710.AJ22(VCCDPHY_1P241) U4710.AJ23(VCCDPHY_1P242) U4710.AK22(VCCPRIM_1P241) U4710.AK23(VCCPRIM_1P242)
VCCSA_VCCSENSE: R4517.1(A) R66680.1(A) U4555.M38(VCCSA_SENSE)
VCCSA_VSSSENSE: R4521.1(A) R66681.1(A) U4555.M37(VSSSA_SENSE)
VCCSENSE: R21.1(A) R66180.1(A) U4555.AG37(VCC_SENSE)
VCCSFR: C2990.1(A) R4570.1(A) U7003.8 U7003.9
VCCST_PWRGD: C4702.1(A) Q4751.6(D1) R4722.1(A) R4739.2(B)
VCCST_PWRGD_CPU: R4722.2(B) U4555.H13(VCCST_PWRGD)
VDDQ_PG: R7008.2(B) U60300.12
VSS: TP4713.1 U4710.AL37(VSS)
VSSMPHY_SENSE: R4875.2(B)
VSSMPHY_SENSE_L: R4870.1(A) R4875.1(A) U4710.K46(VSSMPHY_SENSE)
VSSSENSE: R4531.1(A) R66181.1(A) U4555.AG38(VSS_SENSE)
A20GATE: R317.2(B) U1.126(GA20/GPB5<3>)
AC_LED: CN603.14 R341.1(A) U1.29(PWM3/GPA3)
ACDRV: C60002.2(B) C60003.1(A) Q60003.3(D2) Q60010.4(G) Q60011.4(G) R60004.2(B) R60026.1(A)
ACIN: U60000.13
ACIN_OK#: U60000.14
ACPRES: Q60002.2(G1) R60007.1(A) U1.35(RTS1#/GPE5) U60000.5
ACPRESENT: D4801.1(A2) R4805.2(B) U4710.BG42(GPD1/ACPRESENT)
ADC_IN_N: C52009.1(A) R52008.2(B) U50000.BJ11(ADC_IN*)
ADC_IN_P: C52008.1(A) R52009.2(B) U50000.BJ9(ADC_IN)
ADC_IN_R_N: R52008.1(A) U52000.19(DIFF_OUT*)
ADC_IN_R_P: R52009.1(A) U52000.20(DIFF_OUT_P)
ADC_MUX_R_SEL: R52003.1(A) U52000.29(MUX_SEL)
ALERT_PCH#: R4820.2(B) U4710.BB26(GPP_B15/GSPI0_CS0#)
ALL_PG_REQ: Q50010.G R50010.1(A)
ALL_POWER_GOOD: R345.1(A) R53540.2(B) TP53540.1 U53540.4
ALL_PWGD_IN: C300.1(A) D7002.3(A1) R7004.1(A) U1.124(TMRI1/GPC6<3>)
ALL_PWGD_INTO_EC: R7018.2(B) U1.48(TACH1A/TMA1/GPD7<3>)
ALWAYS_PW_EN: R7012.2(B) R7015.1(A) U1.120(TMRI0/GPC4<3>)
AMP_EN: R334.1(A) R525.2(B) U1.3(GPH7) U500.47(PDB)
AUD_CPU_SCLK: C4594.1(A) R4930.1(A) U4555.G27(PROC_AUDIO_CLK)
AUD_CPU_SCLK_R: R4930.2(B) U4710.AM3(HDACPU_SCLK)
AUD_CPU_SDI: R4927.1(A) U4555.G25(PROC_AUDIO_SDI)
AUD_CPU_SDOP: R4928.1(A) U4555.G29(PROC_AUDIO_SDO)
AUD_PCH_SDI: R4928.2(B) U4710.AN3(HDACPU_SDI)
AUD_PCH_SDO: R4927.2(B) U4710.AM2(HDACPU_SDO)
B/I: CN6050.6 R7601.2(B)
BATPRES#: R7501.1(A) R60022.2(B) U60000.15
BATT_CLK: C7602.1(A) CN6050.4 D7602.2 R6050.2(B)
BATT_IN#: R7501.2(B) R7602.1(A) U1.71(ADC5/DCD1#/GPI5<3>)
BRD_ID0: R4842.2(B) R4843.2(B) U4710.BE34(GPP_A20/ISH_GP2)
BRD_ID1: R4839.2(B) R4841.2(B) U4710.BA33(GPP_A21/ISH_GP3)
BRD_ID2: R4837.2(B) R4838.2(B) U4710.AW32(GPP_A22/ISH_GP4)
BRD_ID3: R4831.2(B) R4836.2(B) U4710.AV34(GPP_A23/ISH_GP5)
BUF_PLT_RST#: CN301.6 CN603.18 CN1300.52(PERSTO*) CN1900.50(PERST#/NC_50) CN1901.50(PERST#/NC_50) R347.1(A) R4729.1(A) R4776.1(A) U3500.17(RESET#) U4700.4
CATERR_N: R4533.2(B) U4555.BM30(CATERR#)
CFG<0>: R4535.1(A) U4555.BN25(CFG_0)
CFG<1>: TP4512.1 U4555.BN27(CFG_1)
CFG<2>: R4529.1(A) U4555.BN26(CFG_2)
CFG<3>: TP4513.1 U4555.BN28(CFG_3)
CFG<4>: R4523.1(A) U4555.BR20(CFG_4)
CFG<5>: R4528.1(A) U4555.BM20(CFG_5)
CFG<6>: R4526.1(A) U4555.BT20(CFG_6)
CFG<7>: R4530.1(A) U4555.BP20(CFG_7)
CFG<8>: TP4503.1 U4555.BR23(CFG_8)
CFG<9>: R4534.1(A) U4555.BR22(CFG_9)
CFG<10>: TP4504.1 U4555.BT23(CFG_10)
CFG<11>: TP4505.1 U4555.BT22(CFG_11)
CFG<12>: TP4506.1 U4555.BM19(CFG_12)
CFG<13>: TP4507.1 U4555.BR19(CFG_13)
CFG<14>: TP4508.1 U4555.BP19(CFG_14)
CFG<15>: TP4509.1 U4555.BT19(CFG_15)
CFG<16>: TP4511.1 U4555.BP23(CFG_16)
CFG<17>: TP4510.1 U4555.BN23(CFG_17)
CFG<18>: TP4502.1 U4555.BN22(CFG_18)
CFG<19>: TP4501.1 U4555.BP22(CFG_19)
CFG_RCOMP: R4519.1(A) U4555.BT25(CFG_RCOMP)
CHARGE_USBPWR_EN: R2555.1(A) U1.85(PS2CLK0/CEC/TMB0/GPF0)
CHG_LED: CN603.15 R342.1(A) U1.16(PWUREQ#/BBO/SMCLK2ALT/GPC7<3>)
CL_CLK1: R1347.2(B) U4710.AR2(CL_CLK)
CL_DATA1: R1346.2(B) U4710.AT5(CL_DATA)
CL_RST#1: R1345.2(B) U4710.AU4(CL_RST#)
CLINKCLK: CN1300.42(RSRVD3) R1347.1(A)
CLINKDAT: CN1300.40(RSRVD2) R1346.1(A)
CLINKRST#: CN1300.38(RSRVD1) R1345.1(A)
CLK_CPU_DN: U4555.A32(BCLKN) U4710.C8(CLKOUT_CPUBCLK*)
CLK_CPU_DP: U4555.B31(BCLKP) U4710.B8(CLKOUT_CPUBCLK_P)
CLK_CPU_PCIBCLK_DN: U4555.C36(PCI_BCLKN) U4710.B6(CLKOUT_CPUPCIBCLK*)
CLK_CPU_PCIBCLK_DP: U4555.D35(PCI_BCLKP) U4710.A6(CLKOUT_CPUPCIBCLK_P)
CLK_CPUNSSC_DN: U4555.D31(CLK24N) U4710.C6(CLKOUT_CPUNSSC*)
CLK_CPUNSSC_DP: U4555.E31(CLK24P) U4710.D7(CLKOUT_CPUNSSC_P)
CLK_LAN_DN: CN603.20 U4710.AA1(CLKOUT_PCIE_N13)
CLK_LAN_DP: CN603.21 U4710.Y2(CLKOUT_PCIE_P13)
CLK_LPC_DEBUG_R: CN301.9 R4852.2(B)
CLK_LPC_EC: R331.1(A) R4850.2(B)
CLK_PCIE_DGPU_100MHZ_N: U4710.AH9(CLKOUT_PCIE_N1) U50000.BM27(PEX_REFCLK*)
CLK_PCIE_DGPU_100MHZ_P: U4710.AH10(CLKOUT_PCIE_P1) U50000.BM26(PEX_REFCLK)
CLK_PCIE_SSD1_DN: CN1901.53(REFCLKN) U4710.AE14(CLKOUT_PCIE_N2)
CLK_PCIE_SSD1_DP: CN1901.55(REFCLKP) U4710.AE15(CLKOUT_PCIE_P2)
CLK_PCIE_SSD2_DN: CN1900.53(REFCLKN) U4710.AE6(CLKOUT_PCIE_N3)
CLK_PCIE_SSD2_DP: CN1900.55(REFCLKP) U4710.AE7(CLKOUT_PCIE_P3)
CLK_WLAN_DN: CN1300.49(REFCLKN0) U4710.T2(CLKOUT_PCIE_N14)
CLK_WLAN_DP: CN1300.47(REFCLKP0) U4710.T1(CLKOUT_PCIE_P14)
CLKIN_XTAL: R1342.2(B) R1352.1(A) U4710.R6(CLKIN_XTAL)
CLKREQ0#: R4755.2(B) U4710.BF31(GPP_B5/SRCCLKREQ0#)
CLKREQ4#: R4714.2(B) U4710.BA30(GPP_B9/SRCCLKREQ4#)
CLKREQ5#: R4715.2(B) U4710.AN29(GPP_B10/SRCCLKREQ5#)
CLKREQ6#: R4754.2(B) U4710.AE47(GPP_H0/SRCCLKREQ6#)
CLKREQ7#: R4757.2(B) U4710.AC48(GPP_H1/SRCCLKREQ7#)
CLKREQ8#: R4763.2(B) U4710.AE41(GPP_H2/SRCCLKREQ8#)
CLKREQ9#: R4761.2(B) U4710.AF48(GPP_H3/SRCCLKREQ9#)
CLKREQ10#: R4765.2(B) U4710.AC41(GPP_H4/SRCCLKREQ10#)
CLKREQ11#: R4766.2(B) U4710.AC39(GPP_H5/SRCCLKREQ11#)
CLKREQ12#: R4768.2(B) U4710.AE39(GPP_H6/SRCCLKREQ12#)
CLKREQ13_LAN#: CN603.16 U4710.AB48(GPP_H7/SRCCLKREQ13#)
CLKREQ14_WLAN#: CN1300.53(CLKEQ0*) R1358.2(B) U4710.AC44(GPP_H8/SRCCLKREQ14#)
CLKREQ15#: R4773.2(B) U4710.AC43(GPP_H9/SRCCLKREQ15#)
CLKREQ_SSD1#: R1901.2(B) R1904.2(B) U4710.AR32(GPP_B7/SRCCLKREQ2#)
CLKREQ_SSD2#: R1902.2(B) R1903.2(B) U4710.BB30(GPP_B8/SRCCLKREQ3#)
CN_MIC: C23.1(A) D7521.2 JACK600.4 L600.1(INA) R610.1(A)
CNV_BRI_DT: R1364.1(A) R4603.1(A) R4724.1(A) U4710.AV4(GPP_J_4_CNV_BRI_DT_UART0_RTSB)
CNV_BRI_DT_R: CN1300.36(UART_RTS) R1364.2(B)
CNV_BRI_RSP: R1320.1(A) R4725.1(A) U4710.AY2(GPP_J5/CNV_BRI_RSP/UART0_RXD)
CNV_BRI_RSP_R: CN1300.22(UART_RX) R1320.2(B)
CNV_CLKREQ: R4772.1(A) U4710.BA17(GPP_D6/I2S2_TXD/MODEM_CLKREQ)
CNV_PA_BLANKING: R1361.1(A) U4710.AV6(GPP_J0/CNV_PA_BLANKING)
CNV_PA_BLANKING_R: CN1300.44(COEX3) R1361.2(B)
CNV_RF_RESET#: R4748.1(A) R4777.1(A) U4710.BE16(GPP_D5/I2S2_SFRM/CNV_RF_RESET#)
CNV_RF_RESET#_R: CN1300.10(PCM_SYNC) R1335.2(B) R4777.2(B)
CNV_RGI_DT: R1321.1(A) R4604.1(A) R4731.1(A) U4710.BA4(GPP_J6/CNV_RGI_DT/UART0_TXD)
CNV_RGI_DT_R: CN1300.32(UART_TX) R1321.2(B)
CNV_RGI_RSP: R1365.1(A) R4732.1(A) U4710.AV3(GPP_J7/CNV_RGI_RSP/UART0_CTS#)
CNV_RGI_RSP_R: CN1300.34(UART_CTS) R1365.2(B)
CNV_UART_RXD: R1363.1(A) U4710.AW2(GPP_J8/CNV_MFUART2_RXD)
CNV_UART_RXD_R: CN1300.48(COEX1) R1363.2(B)
CNV_UART_TXD: R1362.1(A) R4601.2(B) R4602.2(B) U4710.AU9(GPP_J9/CNV_MFUART2_TXD)
CNV_UART_TXD_R: CN1300.46(COEX2) R1362.2(B)
CNV_WR_CLKN_R: CN1300.21(SDIO_WAKE) R1338.2(B)
CNV_WR_CLKP_R: CN1300.23(SDIO_RESET) R1337.2(B)
CNV_WR_D0N_R: CN1300.15(SDIO_DAT1) R1366.2(B)
CNV_WR_D0P_R: CN1300.17(SDIO_DAT2) R1324.2(B)
CNV_WR_D1N_R: CN1300.9(SDIO_CLK) R1328.2(B)
CNV_WR_D1P_R: CN1300.11(SDIO_CMD) R1329.2(B)
CNV_WT_CLKN_R: CN1300.71(RSRVD7) R1354.2(B)
CNV_WT_CLKP_R: CN1300.73(RSRVD8) R1353.2(B)
CNV_WT_D0N_R: CN1300.65(RESERVED_2ND_PERP1) R1330.2(B)
CNV_WT_D0P_R: CN1300.67(RESERVED_2ND_PERN1) R1331.2(B)
CNV_WT_D1N_R: CN1300.59(RESERVED_2ND_PETP1) R1367.2(B)
CNV_WT_D1P_R: CN1300.61(RESERVED_2ND_PETN1) R1368.2(B)
CORE_PWEN: C301.2(B) D7004.3(A1) R37.1(A) R38.1(A) R320.2(B) R5001.1(A) R7024.2(B) R7029.1(A) R7054.1(A) U1.112 U7006.2
CORE_PWEN_RC: R7024.1(A) U2.5
CPU2PCH_TRIGGER: R4840.1(A) U4710.AK2(TRIGGER_IN)
CPU_C10_PWR_GATE#: Q7010.2(E) U4710.AY3(GPP_J1/CPU_VCCIO_PWR_GATE#)
CPU_C10_PWR_GATE#_R: Q7010.3(C) R7063.1(A) R7065.1(A)
CPU_C10_PWR_GATE_BASE: Q7010.1(B) R7066.1(A)
CPU_EDP_AUX_DN: C3019.1(A) CN5.14
CPU_EDP_AUX_DP: C3020.1(A) CN5.13
CPU_EDP_TX0_DN: C3014.1(A) CN5.11
CPU_EDP_TX0_DP: C3013.1(A) CN5.10
CPU_EDP_TX1_DN: C3016.1(A) CN5.8
CPU_EDP_TX1_DP: C3017.1(A) CN5.7
CPU_EDP_TX2_DN: C3027.1(A) CN5.5
CPU_EDP_TX2_DP: C3026.1(A) CN5.4
CPU_EDP_TX3_DN: C3029.1(A) CN5.2
CPU_EDP_TX3_DP: C3028.1(A) CN5.1
CPU_PROCHOT#: C4612.2(B) R339.2(B) R4505.1(A) R4507.2(B) R60021.1(A) R66104.2(B) R66105.2(B)
CPU_PROCHOT#_R: R4505.2(B) U4555.BR30(PROCHOT#)
CPU_THERMTRIP#: Q4758.2(E) R4736.1(A) U4555.J31(THERMTRIP#)
CPU_TRIGOUT: R4840.2(B) U4555.J23(PROC_TRIGOUT)
CTL1: R2554.2(B) U2501.6
CTL2: R2553.2(B) U2501.7
CTL3: R2557.1(A) R2558.2(B) U2501.8
DB_AC_LED: CN601.37 Q101.5(G2) R107.1(A)
DB_BUF_PLT_RST#: CN601.33 U400.2
DB_CHG_LED: CN601.36 Q101.2(G1) R104.1(A)
DB_CLK_LAN_DN: CN601.31 U400.32
DB_CLK_LAN_DP: CN601.30 U400.33
DB_CLKREQ13_LAN#: CN601.35 R404.2(B) U400.4
DB_HP_R_L: C16.1(A) CN601.48 D7534.2 JACK600.1
DB_HP_R_R: C19.1(A) CN601.49 D7533.2 JACK600.2
DB_HPS: CN601.43 D7522.2 JACK600.6
DB_LAN_CLKREQ13#: R400.2(B) R404.1(A)
DB_LAN_PCIE_WAKE#: Q402.2(E) R402.1(A) U400.3
DB_MIC2_REF: CN601.44 R600.2(B) R601.2(B)
DB_PCH_WAKE#: CN601.34 Q402.3(C)
DB_PCIE_LAN_C_TX13N: C402.2(B) CN601.25
DB_PCIE_LAN_C_TX13P: C400.2(B) CN601.24
DB_PCIE_LAN_RX13N: CN601.28 U400.29
DB_PCIE_LAN_RX13P: CN601.27 U400.30
DB_PWR_LED: CN601.38 Q102.G R109.1(A)
DB_RING2: CN601.46 L601.2(INB) R601.1(A)
DB_SLEEVE: CN601.45 L600.2(INB) R600.1(A)
DB_SPK_OUT_R_L_N: C606.1(A) C610.1(A) CN600.2 CN601.40 D610.1
DB_SPK_OUT_R_L_P: C606.2(B) C611.1(A) CN600.1 CN601.39 D611.1
DB_SPK_OUT_R_R_N: C607.2(B) C609.1(A) CN600.3 CN601.41 D609.1
DB_SPK_OUT_R_R_P: C607.1(A) C608.1(A) CN600.4 CN601.42 D608.1
DB_USB3_RX4N: C2413.1(A) CN601.16
DB_USB3_RX4P: C2412.1(A) CN601.15
DB_USB3_RX5N: C2423.1(A) CN601.22
DB_USB3_RX5P: C2422.1(A) CN601.21
DB_USB3_TX4N: C2411.1(A) CN601.13
DB_USB3_TX4P: C2410.1(A) CN601.12
DB_USB3_TX5N: C2421.1(A) CN601.19
DB_USB3_TX5P: C2420.1(A) CN601.18
DB_USB_P4_DN: CN601.7 L2400.2(INA)
DB_USB_P4_DP: CN601.6 L2400.1(INC)
DB_USB_P5_DN: CN601.10 L2403.2(INA)
DB_USB_P5_DP: CN601.9 L2403.1(INC)
DB_USBPWR_EN: CN601.5 U2400.4
