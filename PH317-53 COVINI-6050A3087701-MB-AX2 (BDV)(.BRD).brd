# Allegro board PH317-53 COVINI-6050A3087701-MB-AX2 (BDV)(.BRD).brd (continued)
## Placement (name value [footprint] x y rotation side) (continued)
S34  -  [SCREW500_900_NP_1P]  267.6 151.56 180 top
S35  -  [SCREW280_900_700_1P]  66.2 25.7 0 top
ST1300  STANDOFF_3.2_6.0  [STD_R_FF45031_D30007_M20375_SN]  281.2 53.61 180 bottom
ST1900  STANDOFF_3.2_6.0  [STD_R_FF45031_D30007_M20375_SN]  285.2 109.26 180 bottom
ST1901  STANDOFF_3.2_6.0  [STD_R_FF45031_D30007_M20375_SN]  251.95 31.8 180 bottom
ST1902  STANDOFF_3.2_6.0  [STD_R_FF45031_D30007_M20375_SN]  80.7 37.3 180 bottom
ST1903  STANDOFF_3.2_6.0  [STD_R_FF45031_D30007_M20375_SN]  163.9 38.8 180 bottom
SW1  DIPTRONICS_T1A2QR_4P  [SWCH-TACT_DIP_4_SMD_V_060]  264.1 143.36 0 top
TP16  -  [TP24]  166.39 34.14 180 bottom
TP306  -  [TP24]  191.33 37.87 180 bottom
TP307  -  [TP24]  197.41 40.24 180 bottom
TP400  TP26  [SMDTEST26]  283.77 104.42 270 top
TP401  TP26  [SMDTEST26]  283.77 105.69 270 top
TP402  TP26  [SMDTEST26]  276.58 94.39 270 top
TP403  TP26  [SMDTEST26]  281.02 99.34 270 bottom
TP1300  TP26  [SMDTEST26]  290.83 30.31 0 top
TP1307  TP26  [SMDTEST26]  292.12 30.31 0 top
TP1700  TP26  [SMDTEST26]  98.6 37.01 0 bottom
TP1900  TP26  [SMDTEST26]  68.65 48.44 0 top
TP1901  TP26  [SMDTEST26]  66.98 36.83 180 bottom
TP1902  TP26  [SMDTEST26]  177.62 38.81 180 bottom
TP1903  TP26  [SMDTEST26]  177.62 28.27 180 bottom
TP2400  TP26  [SMDTEST26]  295.42 25.45 90 bottom
TP4300  -  [TP24]  68.25 57.74 0 bottom
TP4301  -  [TP24]  280 73.13 180 bottom
TP4302  -  [TP24]  59.89 58.22 270 bottom
TP4303  -  [TP24]  282.19 75.06 270 bottom
TP4450  -  [TP24]  143.28 120.22 180 bottom
TP4500  -  [TP24]  131.57 142.24 90 top
TP4501  -  [TP24]  86.88 131.8 0 top
TP4502  -  [TP24]  88.12 133 0 top
TP4503  -  [TP24]  84.34 133.28 0 top
TP4504  -  [TP24]  85.61 133.25 0 top
TP4505  -  [TP24]  82.08 134.65 0 top
TP4506  -  [TP24]  89.72 130.1 0 top
TP4507  -  [TP24]  83.68 131.12 0 top
TP4508  -  [TP24]  84.31 129.75 0 top
TP4509  -  [TP24]  86.31 130.41 0 top
TP4510  -  [TP24]  89.42 133.15 0 top
TP4511  -  [TP24]  86.88 133.28 0 top
TP4512  -  [TP24]  89.09 136.45 0 top
TP4513  -  [TP24]  87.82 136.45 0 top
TP4523  -  [TP24]  128.01 109.1 0 top
TP4524  -  [TP24]  86.5 125.28 0 top
TP4525  -  [TP24]  84.27 143.26 0 top
TP4526  -  [TP24]  83.05 109.2 0 top
TP4527  -  [TP24]  127.99 142.68 0 top
TP4528  -  [TP24]  126.67 109.12 0 top
TP4600  -  [TP24]  263.52 66.91 180 bottom
TP4601  -  [TP24]  252.47 48.95 0 top
TP4700  -  [TP24]  264.59 47.02 90 bottom
TP4701  -  [TP24]  261.59 50.68 0 top
TP4702  -  [TP24]  253.26 47.76 0 top
TP4703  -  [TP24]  263.45 46.41 180 bottom
TP4704  -  [TP24]  251.79 39.07 180 bottom
TP4705  -  [TP24]  263.42 45.11 180 bottom
TP4708  -  [TP24]  264.79 66.88 180 bottom
TP4709  -  [TP24]  263.5 39.07 180 bottom
TP4710  -  [TP24]  234.29 39.53 180 bottom
TP4711  -  [TP24]  235.73 68.25 180 bottom
TP4713  -  [TP24]  251.89 47.78 270 top
TP4714  -  [TP24]  255.34 37.11 90 bottom
TP4800  -  [TP24]  257.71 53.78 0 top
TP4801  -  [TP24]  259.86 53.72 0 top
TP4802  -  [TP24]  253.87 56.49 0 top
TP4803  -  [TP24]  256.99 55.45 0 top
TP4804  -  [TP24]  260.45 50.07 0 top
TP4805  -  [TP24]  252.5 37.6 180 bottom
TP4806  -  [TP24]  267.05 48.82 180 bottom
TP4807  -  [TP24]  252.88 62.21 0 top
TP5631  -  [TP24]  145.79 108.99 180 bottom
TP50010  -  [TP24]  139.52 122.71 90 bottom
TP50021  -  [TP24]  149.5 41.3 270 bottom
TP50022  -  [TP24]  148.36 43.01 270 bottom
TP50100  -  [TP24]  163.52 140.41 0 top
TP50200  -  [TP24]  189.3 160.01 0 top
TP50300  -  [TP24]  180.36 123.7 0 top
TP50400  -  [TP24]  175 119.48 0 top
TP51300  -  [TP24]  189.49 155.09 270 top
TP51511  -  [TP24]  145.03 126.32 180 bottom
TP51521  -  [TP24]  131.7 46.1 90 bottom
TP51522  -  [TP24]  132.2 47.45 0 bottom
TP51531  -  [TP24]  139.04 45.9 180 bottom
TP51532  -  [TP24]  133.7 43.29 180 bottom
TP51545  -  [TP24]  155.7 108.06 90 bottom
TP51550  -  [TP24]  162.89 93.07 0 bottom
TP52120  -  [TP24]  145.36 145.29 180 bottom
TP52121  -  [TP24]  146.22 144.35 180 bottom
TP52200  -  [TP24]  179.63 142.12 0 top
TP52230  -  [TP24]  186.71 155.26 90 top
TP52231  -  [TP24]  185.42 155.26 90 top
TP53500  -  [TP24]  112.19 49.53 90 bottom
TP53501  -  [TP24]  111.32 50.8 0 bottom
TP53502  -  [TP24]  112.59 50.78 0 bottom
TP53510  -  [TP24]  144.68 100.84 0 bottom
TP53540  -  [TP24]  116.33 47.45 0 bottom
TP53551  -  [TP24]  108.53 54.89 90 bottom
TP53572  -  [TP24]  126.62 51.62 270 bottom
TP53582  -  [TP24]  118.01 55.35 270 bottom
TP53590  -  [TP24]  126.44 49.3 270 bottom
TP53592  -  [TP24]  121.82 47.07 270 bottom
TP53930  -  [TP24]  157.22 92.07 270 top
TP56630  -  [TP24]  304.54 63.58 180 bottom
TP56631  -  [TP24]  304.52 68.51 180 bottom
TP60000  -  [TP24]  50.9 37.87 180 bottom
TP60002  -  [TP24]  59.41 48.26 180 bottom
TP60100  -  [TP24]  214.17 28.22 0 top
TP60101  -  [TP24]  193.32 29.98 0 top
TP60102  -  [TP24]  191.61 28.1 0 top
TP60191  -  [TP24]  194.24 28.99 180 bottom
TP60200  -  [TP24]  260.96 24.62 0 top
TP60201  -  [TP24]  241.37 19.97 0 top
TP60250  -  [TP24]  51.41 74.32 0 bottom
TP60251  -  [TP24]  64.36 75.64 270 bottom
TP60300  -  [TP24]  76.43 69.96 0 bottom
TP60301  -  [TP24]  67.18 84.66 0 bottom
TP60350  -  [TP24]  75.36 84.64 270 bottom
TP60351  -  [TP24]  68.42 84.99 90 bottom
TP60400  -  [TP24]  155.27 73.61 180 bottom
TP60401  -  [TP24]  75.66 60.71 90 bottom
TP60500  -  [TP24]  79.37 111.48 270 bottom
TP60501  -  [TP24]  68.02 110.9 0 bottom
TP60600  -  [TP24]  218.34 27.05 0 top
TP60601  -  [TP24]  216.99 20.35 90 top
TP60900  -  [TP24]  232.56 49.51 90 bottom
TP60901  -  [TP24]  219.61 49.36 180 bottom
TP66000  -  [TP24]  131.19 145.11 180 bottom
TP66001  -  [TP24]  80.11 161.85 270 bottom
TP66300  -  [TP24]  85.98 148.14 180 bottom
TP66600  -  [TP24]  130.43 143.16 180 top
TP67000  -  [TP24]  176.58 73.21 180 bottom
TP67001  -  [TP24]  204.07 88.67 180 bottom
TP67200  -  [TP24]  217.78 85.96 180 bottom
TP67201  -  [TP24]  236.7 81.46 180 bottom
TP67400  -  [TP24]  209.1 174.79 0 top
TP67401  -  [TP24]  194.79 173.49 0 top
TP67600  -  [TP24]  144.9 160.71 180 bottom
TP67601  -  [TP24]  151.58 172.24 180 bottom
U1  ITE_IT8987E_CX_LQFP_128P_HP  [LQFP_1400X1400X160_128_040]  206.49 32.93 180 bottom
U2  ANPEC_APL3523A_TDFN_14P  [KK-6019B1184301-001]  228.7 32.85 180 bottom
U8  VIA_VP225_DFN_10P  [DFN_300X300X080_10_050_T6]  298.04 22.1 90 bottom
U50  MST_MH255ESP_PSOT23_3P  [IC-HALL_MST_3_SMD_105]  257.09 99.48 270 top
U250  MST_MH255ESP_PSOT23_3P  [IC-HALL_MST_3_SMD_105]  193.9 163 0 top
U300  WINB_W25Q128JVSIQ_SOIC_8P  [SOP_528X528X216_8_127]  228.55 22.56 90 top
U400  RIVET_E2500_RIV1_RL_QFN_40P  [QFN_500X500X090_40_040_T2]  283.88 100.51 0 top
U401  BOTH_NA0069RLF_SMD_24P  [SOP_1560X850X240_24_127]  294.15 104.16 90 bottom
U500  REA_ALC255_CG_MQFN_48P  [MQFN_600X600X100_48_040_T1]  19.41 56.52 180 top
U702  TI_TLC59116_VQFN_32P  [VQFN_500X500X100_32_050_T2]  140.79 37.75 270 bottom
U1300  ANPEC_APL3526QBI_TRG_TDFN_8P  [TDFN_200X200X080_8_050_T6]  265.68 22.23 270 top
U1700  PERICOM_PI3EQX12902A_TQFN_30P  [TQFN_450X250X080_30_040_T1]  98.55 39.81 180 bottom
U2400  GMT_G524B1T11U_SOT23_5P  [TSOT23_290X160X125_5_095]  295.58 118.06 270 bottom
U2401  PARADE_PS8713BTQFN24GTR2_A3_TQFN_24P  [TQFN_400X400X080_24_050_T6]  285.11 116.51 90 bottom
U2403  PARADE_PS8713BTQFN24GTR2_A3_TQFN_24P  [TQFN_400X400X080_24_050_T6]  293.76 122.55 0 top
U2500  GMT_G518B1TP1U_TSOT23_6P  [TSOT23_290X160X090_6_095_P2]  306.78 10.95 90 top
U2501  TEXAS_TPS2546RTER_QFN_16P  [QFN_300X300X080_16_050_T1]  285.16 31.68 270 top
U2502  NXP_74LVC1G08GW_TSOT353_5P  [TSOT353_205X125X110_5_065]  295.21 31.97 90 bottom
U3000  NUVO_NCT3521U_SOT23_5P  [TSSOT23_290X160X135_5_095]  18.06 79.68 180 bottom
U3500  NUVOTON_NPCT750AAAYX_QFN_32P  [QFN_500X500X080_32_050_T7]  233.5 22.89 180 bottom
U4450  NUVOTON_NCT7718W_MSOP_8P  [MSOP_300X300X110_8_065_P3]  146.88 117.02 180 bottom
U4555  INTEL_J43242_BGA_1440P  [CPU_INTEL_COF_6C_B_4200X2800]  106.5 131 270 bottom
U4700  NXP_74LVC1G08GW_TSOT353_5P  [TSOT353_205X125X110_5_065]  270.1 56.49 90 bottom
U4710  INTEL_J44894_BGA_874P  [IC-BGA_INTEL_2500_2400_141]  248.86 53.18 90 bottom
U7002  ANPEC_APL3523A_TDFN_14P  [KK-6019B1184301-001]  279.12 62.41 0 bottom
U7003  ANPEC_APL3523A_TDFN_14P  [KK-6019B1184301-001]  229.18 53.32 0 top
U7006  TC7SET08FU  [SSOP_200X125X100_5_065]  70.13 90.28 90 bottom
U50000  NVIDIA_N18E_G1_KD_QS_A1_BGA_2228P  [GPU_NVDIA_FB_N18E_3750X3750]  169.35 130.63 90 bottom
U50020  TC7SZ08FU  [SSOP_200X125X100_5_065]  146.88 40.26 270 bottom
U50500  MICRON_MT61K256M32JE_14_A_FBGA_180P  [IC-MEMORY_MICRO_1400X1200X110]  180.16 168.22 0 bottom
U50600  MICRON_MT61K256M32JE_14_A_FBGA_180P  [IC-MEMORY_MICRO_1400X1200X110]  164.16 168.22 180 bottom
U50700  MICRON_MT61K256M32JE_14_A_FBGA_180P  [IC-MEMORY_MICRO_1400X1200X110]  207.23 143.41 270 bottom
U50800  MICRON_MT61K256M32JE_14_A_FBGA_180P  [IC-MEMORY_MICRO_1400X1200X110]  207.23 158.71 90 bottom
U50900  MICRON_MT61K256M32JE_14_A_FBGA_180P  [IC-MEMORY_MICRO_1400X1200X110]  206.88 104.81 270 bottom
U51000  MICRON_MT61K256M32JE_14_A_FBGA_180P  [IC-MEMORY_MICRO_1400X1200X110]  206.88 120.12 90 bottom
U51100  MICRON_MT61K256M32JE_14_A_FBGA_180P  [IC-MEMORY_MICRO_1400X1200X110]  172.26 93.09 180 bottom
U51200  MICRON_MT61K256M32JE_14_A_FBGA_180P  [IC-MEMORY_MICRO_1400X1200X110]  186.8 93.09 0 bottom
U51400  WINBOND_W25Q80EWSNIG_SOP_8P  [SOP_490X390X175_8_127]  155.55 89.11 180 bottom
U52000  ON_NCP45491XMNTWG_QFN_32P  [QFN_400X400X100_32_040_T2]  145.06 50.57 180 bottom
U53500  PHILIPS_74LVC1G32_TSOT353_5P  [TSOT353_200X125X110_5_065]  108.92 49.32 270 bottom
U53520  TC7SZ08FU  [SSOP_200X125X100_5_065]  142.85 101.17 180 bottom
U53540  TC7SZ08FU  [SSOP_200X125X100_5_065]  117.16 49.17 270 bottom
U53550  PHILIPS_74LVC1G32_TSOT353_5P  [TSOT353_200X125X110_5_065]  105.59 56.17 0 bottom
U53555  TC7SZ08FU  [SSOP_200X125X100_5_065]  104.95 53.35 270 bottom
U53570  TC7SZ08FU  [SSOP_200X125X100_5_065]  121.94 53.42 0 bottom
U53580  TC7SZ08FU  [SSOP_200X125X100_5_065]  120.39 58.3 270 bottom
U53585  PHILIPS_74LVC1G32_TSOT353_5P  [TSOT353_200X125X110_5_065]  111.2 56.92 90 bottom
U53590  PHILIPS_74LVC1G32_TSOT353_5P  [TSOT353_200X125X110_5_065]  124.02 49.3 270 bottom
U55300  TI_TPS22965DSGR_SON_8P  [SON_200X200X080_8_050_T1]  196.92 168.84 90 top
U55800  PERICOM_PI3DPX1203BZHEX_TQFN_42P  [TQFN_900X350X084_42_050_T4]  292.17 54.61 270 top
U56250  NUVO_NCT3521U_SOT23_5P  [TSSOT23_290X160X135_5_095]  296.21 35.32 270 bottom
U56400  ITE_IT66317FN_BW_0006_R_QFN_48P  [QFN_600X600X090_48_040_T13]  289.51 74.48 0 top
U56610  GMT_G5250Q1T73U_SOT23_3P  [SOT23_290X160X145_3_095]  301.75 64.8 0 bottom
U60000  TI_BQ24780S_QFN_28P  [WQFN_400X400X080_28_040_T1]  56.48 45.71 90 bottom
U60100  MPS_NB680AGD_Z_QFN_12P  [QFN_300X200X100_12_050]  193.53 24.79 270 top
U60200  SILERGY_SY8288CRAC_QFN_21P  [QFN_300X300X090_20_045_T2]  244.89 24.24 180 top
U60250  SILERGY_SY8284CRAC_QFN_20P  [QFN_300X300X090_20_045_T1]  61.62 79.45 0 bottom
U60300  MPS_NB685AGQ_Z_QFN_16P  [QFN_300X300X100_16_050_P1]  71.22 82.58 0 bottom
U60400  RICHTEK_RT8097ALGE_TSOT23_6P  [TSOT23_290X160X130_6_095]  77.95 59.75 0 bottom
U60500  MPS_NB681GD_Z_QFN_13P  [QFN_300X200X100_13_050]  68.5 105.85 90 bottom
U60600  SILERGY_SY8088AAC_SOT23_5P  [TSOT23_295X160X140_5_095]  215.46 22.51 90 top
U60900  SILERGY_SY8288RAC_QFN_20P  [QFN_300X300X090_20_045_T2]  222.52 51.47 270 bottom
U66000  ON_NCP81215MNTXG_QFN_52P  [QFN_600X600X100_52_040_T1]  83.18 165.55 90 top
U66010  ON_NCP302045MNTWG_PQFN_33P  [PQFN_500X500X080_31_050_T2]  99.39 170.55 0 bottom
U66020  ON_NCP302045MNTWG_PQFN_33P  [PQFN_500X500X080_31_050_T2]  109.75 170.56 0 bottom
U66030  ON_NCP302045MNTWG_PQFN_33P  [PQFN_500X500X080_31_050_T2]  120.17 170.55 0 bottom
U66040  ON_NCP302045MNTWG_PQFN_33P  [PQFN_500X500X080_31_050_T2]  130.53 170.6 0 bottom
U66310  ON_NCP81151MNTBG_DFN_8P  [DFN_200X200X100_8_050_T2]  80.38 147.17 315 bottom
U66610  ON_NCP81253MNTBG_DFN_8P  [DFN_200X200X100_8_050_T2]  144.39 167.84 180 bottom
U67000  MPS_MP2886AGU_Z_QFN_40P  [QFN_500X500X100_40_040_T6]  133.85 54.46 90 top
U67010  MPS_MP86941GQVT_Z_TQFN_21P  [TQFN_500X300X080_21_040]  161.77 55.42 0 bottom
U67020  MPS_MP86941GQVT_Z_TQFN_21P  [TQFN_500X300X080_21_040]  171.67 55.42 0 bottom
U67030  MPS_MP86941GQVT_Z_TQFN_21P  [TQFN_500X300X080_21_040]  181.65 55.45 0 bottom
U67040  MPS_MP86941GQVT_Z_TQFN_21P  [TQFN_500X300X080_21_040]  191.66 55.5 0 bottom
U67050  MPS_MP86941GQVT_Z_TQFN_21P  [TQFN_500X300X080_21_040]  201.7 55.47 0 bottom
U67060  MPS_MP86941GQVT_Z_TQFN_21P  [TQFN_500X300X080_21_040]  211.72 55.5 0 bottom
U67200  RICHTEK_RT8816A_QFN_20P  [QFN_300X300X080_20_040_T2]  239.8 77.17 0 bottom
U67400  SILERGY_SY8284RAC_QFN_20P  [QFN_300X300X090_20_045_T1]  197.01 175.38 180 top
U67600  RICHTEK_RT8068AZQW_WDFN_10P  [WDFN_300X300X080_10_050_T1]  152.19 170.01 90 bottom
UU52100  ANPEC_APL3537BHAI_TRG_WLCSP_6P  [WLCSP_092X142X047_6_050]  159.69 88.17 0 bottom
X400  25MHz_10pF  [XTAL_320X250X090_4_220-2]  287.88 90.42 180 top
X4750  32.768KHZ_12.5PF  [XTAL_670X140X140_4_630]  265.33 35.44 0 bottom
X4751  TXC_24MHZ_12PF  [XTAL_320X250X080_4_220]  245.51 72.37 0 bottom
X51310  27MHz_10pF  [XTAL_320X250X090_4-2]  147.8 105.74 0 bottom
XU300  ACES_91960_0084L_8P  [SKT-BIOS_ACES_970X920X500]  228.54 23.23 270 top

## Library data of the parts
C3 C10 C4814 C4825 C4867 C4868 C4871 C4872 C4876 = CSC0402: part number: CSC0402-0.1UF_16V_2,6010A0036403,CSC_100X050X040_2,0.55MM,CSC0402,0402,X7R,CAP-CHIP,0.1UF,16V,K,X7R,0402,TAP; signal model: C2_6010A0036403_0_1uF_16V_2; room: Sheet41
C4 C5 C8 C9 C4813 C4815-C4817 C4824 C4827 C4829 C4830 C4844 C4846 C4848-C4850 C4853 C4854 C4857-C4860 C4862-C4866 C4869 C4870 C4875 = CSC0402: part number: CSC0402-1UF_6.3V_2,6010B0392101,CSC_100X050X055_2,0.65MM,CSC0402,0402,X5R,CAPACITOR-CHIP,1UF,6.3V,K,X5R,0402,TR; signal model: C2_6010B0392101_1uF_6_3V_2; room: Sheet41
C6 C7 = CSC0603: part number: CSC0603-4.7UF_6.3V_3,6010B0009906,CSC_160X080X090_2,1.00MM,CSC0603,0603,,CAPACITOR-CHIP,4.7UF,6.3V,K,X5R,0603,TR; signal model: C2_6010B0009906_4_7uF_6_3V_3; room: Sheet41
C16 C19 = CSC0402: part number: CSC0402-470PF_50V_2_DY,6010A0025101_DY,CSC_100X050X040_2,0.55MM,CSC0402,0402,X7R,CAP-CHIP-471-K,50V-X7R-0402-TAP; signal model: C2_6010A0025101_DY_470pF_50V_2_DY; room: Sheet126
C17 C7014 C7034 C7035 = CSC0402: part number: CSC0402-1000PF_50V_2,6010071020AT,CSC_100X050X055_2,0.7MM,CSC0402,0402,X7R,CAPACITOR-CHIP,1000PF,50V,K,X7R,0402,TR; signal model: C2_6010071020AT_1000PF_50V_2; room: Sheet22
C18 C510 = CSC0402: part number: CSC0402-22PF_50V_2,6010072202AT,CSC_100X050X040_2,0.55MM,CSC0402,0402,C0G,CAPACITOR-CHIP,22PF,50V,J,C0G,0402,TR; signal model: C2_6010072202AT_22pF_50V_2; room: Sheet54
C20 = CSC0805: part number: CSC0805-22UF_6.3V_5_DY,6010A0040703_DY,CSC_200X125X140_2,1.5MM,CSC0805,0805,X5R,CAPACITOR-CHIP,22UF,6.3V,M,X5R,0805,TR,1.25MM; signal model: C2_6010A0040703_DY_22UF_6_3V_5_DY; room: Sheet56
C23 C24 C606 C607 C612-C614 = CSC0402: part number: CSC0402-CSC0402_DY,CSC0402_DY,CSC_100X050X040_2,0.55MM,CSC0402,0402,,CSC0402_OPEN; signal model: C2_CSC0402_DY_CSC0402_DY; room: Sheet126
C25 = CSC0402: part number: CSC0402-CSC0402_DY,CSC0402_DY,CSC_100X050X040_2,0.55MM,CSC0402,0402,,CSC0402_OPEN; signal model: C2_CSC0402_DY_CSC0402_DY; room: Sheet127
C33 = CSC0402: part number: CSC0402-0.1UF_16V_2,6010A0036403,CSC_100X050X040_2,0.55MM,CSC0402,0402,X7R,CAP-CHIP,0.1UF,16V,K,X7R,0402,TAP; signal model: C2_6010A0036403_0_1uF_16V_2; room: Sheet36
C34 C4104 = CSC0402: part number: CSC0402-0.1UF_16V_2,6010A0036403,CSC_100X050X040_2,0.55MM,CSC0402,0402,X7R,CAP-CHIP,0.1UF,16V,K,X7R,0402,TAP; signal model: C2_6010A0036403_0_1uF_16V_2; room: Sheet47
C35 = CAP_TA_SP: part number: CAP_TA_SP-330UF_2.5V,6010B0106701,CSTJB_350X280X200_2_300,2.15MM,CAP_TA_SP,,,CAPACITOR-TA-SP,330UF,2.5V,M,85C,BX1.9,SMD,TR,45MOHM; signal model: C2_6010B0106701_330uF_2_5V; room: Sheet47
C36 C4101-C4103 C4116-C4121 C4123 C4131 C4134 = CSC0402: part number: CSC0402-1UF_6.3V_2,6010B0392101,CSC_100X050X055_2,0.65MM,CSC0402,0402,X5R,CAPACITOR-CHIP,1UF,6.3V,K,X5R,0402,TR; signal model: C2_6010B0392101_1uF_6_3V_2; room: Sheet47
C37 C4100 C4106-C4109 C4113-C4115 C4137 C4138 = CSC0603: part number: CSC0603-10UF_6.3V_3,6010B0044902,CSC_160X080X095_2,1.05MM,CSC0603,0603,,CAPACITOR-CHIP,10UF,6.3V,M,X5R,0603,TR; signal model: C2_6010B0044902_10uF_6_3V_3; room: Sheet47
C50 = CSC0402: part number: CSC0402-1000PF_50V_2,6010071020AT,CSC_100X050X055_2,0.7MM,CSC0402,0402,X7R,CAPACITOR-CHIP,1000PF,50V,K,X7R,0402,TR; signal model: C2_6010071020AT_1000PF_50V_2; room: Sheet120
C51 = CSC0402: part number: CSC0402-0.1UF_16V_2,6010A0036403,CSC_100X050X040_2,0.55MM,CSC0402,0402,X7R,CAP-CHIP,0.1UF,16V,K,X7R,0402,TAP; signal model: C2_6010A0036403_0_1uF_16V_2; room: Sheet120
C62 C63 C302-C304 C306-C308 C310 C313 C316 = CSC0402: part number: CSC0402-0.1UF_16V_2,6010A0036403,CSC_100X050X040_2,0.55MM,CSC0402,0402,X7R,CAP-CHIP,0.1UF,16V,K,X7R,0402,TAP; signal model: C2_6010A0036403_0_1uF_16V_2; room: Sheet51
C65 C351 = CSC0402: part number: CSC0402-CSC0402_DY,CSC0402_DY,CSC_100X050X040_2,0.55MM,CSC0402,0402,,CSC0402_OPEN; signal model: C2_CSC0402_DY_CSC0402_DY; room: Sheet51
C68 = CSC0402: part number: CSC0402-1000PF_50V_2,6010071020AT,CSC_100X050X055_2,0.7MM,CSC0402,0402,X7R,CAPACITOR-CHIP,1000PF,50V,K,X7R,0402,TR; signal model: C2_6010071020AT_1000PF_50V_2; room: Sheet9
C87 C88 = CSC0402: part number: CSC0402-220PF_50V_2,6010B0076701,CSC_100X050X040_2,0.55MM,CSC0402,0402,C0G,CAP-CHIP,220PF,50V,J,C0G,0402,TR; signal model: C2_6010B0076701_220pF_50V_2; room: Sheet60
C100 = CSC0603: part number: CSC0603-22UF_6.3V_3,6010B0219002-001,CLOONEY-6010B0219002-001,1.10MM,CSC0603,0603,,CAPACITOR-CHIP,22UF,6.3V,M,X5R,0603,TR,0.8MM; signal model: C2_6010B0219002-001_22uF_6_3V_3; room: Sheet22
C131 C7012 C7013 = CSC0402: part number: CSC0402-220PF_50V_2,6010B0076701,CSC_100X050X040_2,0.55MM,CSC0402,0402,C0G,CAP-CHIP,220PF,50V,J,C0G,0402,TR; signal model: C2_6010B0076701_220pF_50V_2; room: Sheet22
C137 C2990 C7010 C7018 C7205 = CSC0603: part number: CSC0603-10UF_6.3V_3,6010B0044902-001,RANGERS-6010B0044902-001,1.05MM,CSC0603,0603,,CAPACITOR-CHIP,10UF,6.3V,M,X5R,0603,TR; signal model: C2_6010B0044902-001_10uF_6_3V_3; room: Sheet22
C138 = CSC0402: part number: CSC0402-0.01UF_50V_2,6010B0058401,CSC_100X050X040_2,0.55MM,CSC0402,0402,X7R,CAP-CHIP,0.01UF,50V,K,X7R,0402,TAP; signal model: C2_6010B0058401_0_01uF_50V_2; room: Sheet23
C139 C140 C7000 C7023 = CSC0402: part number: CSC0402-0.1UF_16V_2,6010A0036403,CSC_100X050X040_2,0.55MM,CSC0402,0402,X7R,CAP-CHIP,0.1UF,16V,K,X7R,0402,TAP; signal model: C2_6010A0036403_0_1uF_16V_2; room: Sheet23
C250 = CSC0402: part number: CSC0402-2.2UF_6.3V_2,6010B0059301,CSC_100X050X040_2,0.55MM,CSC0402,0402,X5R,CAP-CHIP,2.2UF,6.3V,M,X5R,0402,TR; signal model: C2_6010B0059301_2_2uF_6_3V_2; room: Sheet52
C251 = CSC0402: part number: CSC0402-100PF_50V_2,6010071012AT,CSC_100X050X040_2,0.55MM,CSC0402,0402,NPO,CAP-CHIP-101-J,50V-NPO-0402; signal model: C2_6010071012AT_100pF_50V_2; room: Sheet52
C252 C254 = CSC0402: part number: CSC0402-0.1UF_16V_2,6010A0036403,CSC_100X050X040_2,0.55MM,CSC0402,0402,X7R,CAP-CHIP,0.1UF,16V,K,X7R,0402,TAP; signal model: C2_6010A0036403_0_1uF_16V_2; room: Sheet118
C253 = CSC0402: part number: CSC0402-1000PF_50V_2,6010071020AT,CSC_100X050X055_2,0.7MM,CSC0402,0402,X7R,CAPACITOR-CHIP,1000PF,50V,K,X7R,0402,TR; signal model: C2_6010071020AT_1000PF_50V_2; room: Sheet118
C255 = CSC0402: part number: CSC0402-CSC0402_DY,CSC0402_DY,CSC_100X050X040_2,0.55MM,CSC0402,0402,,CSC0402_OPEN; signal model: C2_CSC0402_DY_CSC0402_DY; room: Sheet52
C300 C301 = CSC0402: part number: CSC0402-0.1UF_16V_2_DY,6010A0036403_DY,CSC_100X050X040_2,0.55MM,CSC0402,0402,X7R,CAP-CHIP,0.1UF,16V,K,X7R,0402,TAP; signal model: C2_6010A0036403_DY_0_1uF_16V_2_DY; room: Sheet51
C309 = CSC0402: part number: CSC0402-0.1UF_16V_2,6010A0036403,CSC_100X050X040_2,0.55MM,CSC0402,0402,X7R,CAP-CHIP,0.1UF,16V,K,X7R,0402,TAP; signal model: C2_6010A0036403_0_1uF_16V_2; room: Sheet50
C311 C312 = CSC0402: part number: CSC0402-220PF_50V_2_DY,6010B0076701_DY,CSC_100X050X040_2,0.55MM,CSC0402,0402,C0G,CAP-CHIP,220PF,50V,J,C0G,0402,TR; signal model: C2_6010B0076701_220pF_50V_2_DY; room: Sheet51
C314 = CSC0402: part number: CSC0402-47PF_50V_2_DY,6010074702AT_DY,CSC_100X050X040_2,0.55MM,CSC0402,0402,NPO,CAP-CHIP-470-J,50V-NPO-0402; signal model: C2_6010074702AT_DY_47pF_50V_2_DY; room: Sheet51
C315 = CSC0402: part number: CSC0402-12PF_50V_2_DY,6010A0036103_DY,CSC_100X050X040_2,0.55MM,CSC0402,0402,NPO,CAP-CHIP-12PF-50V-J-NPO-0402-TAP; signal model: C2_6010A0036103_DY_12pF_50V_2_DY; room: Sheet51
C321 = CSC0402: part number: CSC0402-100PF_50V_2,6010071012AT,CSC_100X050X040_2,0.55MM,CSC0402,0402,NPO,CAP-CHIP-101-J,50V-NPO-0402; signal model: C2_6010071012AT_100pF_50V_2; room: Sheet51
C400 C402 C404 C406-C408 C411 C414 C416 C418 C420 C425 C426 C437 = CSC0402: part number: CSC0402-0.1UF_16V_2,6010A0036403,CSC_100X050X040_2,0.55MM,CSC0402,0402,X7R,CAP-CHIP,0.1UF,16V,K,X7R,0402,TAP; signal model: C2_6010A0036403_0_1uF_16V_2; room: Sheet124
C401 C7575-C7578 = CSC0402: part number: CSC0402-0.1UF_16V_2,6010A0036403,CSC_100X050X040_2,0.55MM,CSC0402,0402,X7R,CAP-CHIP,0.1UF,16V,K,X7R,0402,TAP; signal model: C2_6010A0036403_0_1uF_16V_2; room: Sheet125
C409 = CSC0402: part number: CSC0402-1UF_16V_2_DY,6010B0188501_DY,CSC_100X050X055_2,0.65MM,CSC0402,0402,X5R,CAPACITOR-CHIP,1UF,16V,K,X5R,0402,TR,0.5MM; signal model: C2_6010B0188501_DY_1uF_16V_2_DY; room: Sheet124
C410 = CSC0402: part number: CSC0402-4.7UF_6.3V_2_DY,6010B0164601_DY,CSC_100X050X065_2,0.8MM,CSC0402,0402,X5R,CAPACITOR-CHIP,4.7UF,6.3V,M,X5R,0402,TR,0.5MM; signal model: C2_6010B0164601_4_7UF_6_3V_2_DY; room: Sheet124
C412 C415 C417 C419 C424 = CSC0402: part number: CSC0402-1UF_6.3V_2,6010B0392101,CSC_100X050X055_2,0.65MM,CSC0402,0402,X5R,CAPACITOR-CHIP,1UF,6.3V,K,X5R,0402,TR; signal model: C2_6010B0392101_1uF_6_3V_2; room: Sheet124
C413 C438 = CSC0402: part number: CSC0402-1000PF_50V_2_DY,6010071020AT_DY,CSC_100X050X055_2,0.7MM,CSC0402,0402,X7R,CAPACITOR-CHIP,1000PF,50V,K,X7R,0402,TR; signal model: C2_6010071020AT_DY_1000PF_50V_2_DY; room: Sheet124
C421 = CSC0402: part number: CSC0402-0.1UF_16V_2_DY,6010A0036403_DY,CSC_100X050X040_2,0.55MM,CSC0402,0402,X7R,CAP-CHIP,0.1UF,16V,K,X7R,0402,TAP; signal model: C2_6010A0036403_DY_0_1uF_16V_2_DY; room: Sheet124
C422 C423 = CSC0402: part number: CSC0402-10PF_50V_2,6010A0025401,CSC_100X050X040_2,0.55MM,CSC0402,0402,NPO,CAP-CHIP-10PF-D,50V-NPO-0402-TAP; signal model: C2_6010A0025401_10pF_50V_2; room: Sheet124
C427 C428 C436 = CSC0603: part number: CSC0603-10UF_6.3V_3,6010B0044901-003,REBORN-6010B0044901-003,0.95MM,CSC0603,0603,X5R,CAP-CHIP,10UF,6.3V,M,X5R,0603,TR; signal model: C2_6010B0044901-003_10uF_6_3V_3; room: Sheet124
C429 = CSC1206: part number: CSC1206-1000PF_2000V_6,6010A0034001,CSC_320X160X130_2,1.45MM,CSC1206,1206,X7R,CAP-CHIP-102-K,2000V-X7R-1206-TAP; signal model: C2_6010A0034001_1000pF_2000V_6; room: Sheet125
C433 = CSC0402: part number: CSC0402-0.01UF_50V_2,6010B0058401,CSC_100X050X040_2,0.55MM,CSC0402,0402,X7R,CAP-CHIP,0.01UF,50V,K,X7R,0402,TAP; signal model: C2_6010B0058401_0_01uF_50V_2; room: Sheet125
C478 = CSC0402: part number: CSC0402-10PF_50V_2,6010A0025401,CSC_100X050X040_2,0.55MM,CSC0402,0402,NPO,CAP-CHIP-10PF-D,50V-NPO-0402-TAP; signal model: C2_6010A0025401_10pF_50V_2; room: Sheet125
C479 = CSC0402: part number: CSC0402-10PF_50V_2_DY,6010A0025401_DY,CSC_100X050X040_2,0.55MM,CSC0402,0402,NPO,CAP-CHIP-10PF-D,50V-NPO-0402-TAP; signal model: C2_6010A0025401_DY_10pF_50V_2_DY; room: Sheet125
C501 C508 C512 C513 C515 C517 C521 C530 C532 = CSC0603: part number: CSC0603-10UF_6.3V_3,6010B0044901,CSC_160X080X080_2,0.95MM,CSC0603,0603,X5R,CAP-CHIP,10UF,6.3V,M,X5R,0603,TR; signal model: C2_6010B0044901_10uF_6_3V_3; room: Sheet54
C502 = CSC0402: part number: CSC0402-2.2UF_6.3V_2,6010B0059302,CSC_100X050X055_2,0.65MM,CSC0402,0402,X5R,CAPACITOR-CHIP,2.2UF,6.3V,M,X5R,0402,TR; signal model: C2_6010B0059302_2_2UF_6_3V_2; room: Sheet54
C503 C511 = CSC0402: part number: CSC0402-1UF_6.3V_2,6010B0006001,CSC_100X050X040_2,0.55MM,CSC0402,0402,X5R,CAP-CHIP,1UF,6.3V,K,X5R,0402,TR; signal model: C2_6010B0006001_1uF_6_3V_2; room: Sheet54
C504 = CSC0603: part number: CSC0603-4.7UF_10V_3,6010B0067401,CSC_160X080X080_2,0.95MM,CSC0603,0603,X5R,CAP-CHIP,4.7UF,10V,K,X5R,0603,TR; signal model: C2_6010B0067401_4_7uF_10V_3; room: Sheet54
C505 C507 C509 C514 C516 C520 C523-C525 = CSC0402: part number: CSC0402-0.1UF_16V_2,6010A0036403,CSC_100X050X040_2,0.55MM,CSC0402,0402,X7R,CAP-CHIP,0.1UF,16V,K,X7R,0402,TAP; signal model: C2_6010A0036403_0_1uF_16V_2; room: Sheet54
C506 = CSC0402: part number: CSC0402-CSC0402_DY,CSC0402_DY,CSC_100X050X040_2,0.55MM,CSC0402,0402,,CSC0402_OPEN; signal model: C2_CSC0402_DY_CSC0402_DY; room: Sheet54
C519 = CSC0402: part number: CSC0402-0.1UF_16V_2_DY,6010A0036403_DY,CSC_100X050X040_2,0.55MM,CSC0402,0402,X7R,CAP-CHIP,0.1UF,16V,K,X7R,0402,TAP; signal model: C2_6010A0036403_DY_0_1uF_16V_2_DY; room: Sheet54
C522 = CSC0603: part number: CSC0603-10UF_6.3V_3_DY,6010B0044901_DY,CSC_160X080X080_2,0.95MM,CSC0603,0603,X5R,CAP-CHIP,10UF,6.3V,M,X5R,0603,TR; signal model: C2_6010B0044901_DY_10uF_6_3V_3_DY; room: Sheet54
C531 = CSC0603: part number: CSC0603-4.7UF_6.3V_3,6010B0009904,CSC_160X080X080_2,0.95MM,CSC0603,0603,X5R,CAP-CHIP,4.7UF,6.3V,K,X5R,0603,TR; signal model: C2_6010B0009904_4_7uF_6_3V_3; room: Sheet54
C602 C603 = CSC0603: part number: CSC0603-4.7UF_6.3V_3,6010B0009904,CSC_160X080X080_2,0.95MM,CSC0603,0603,X5R,CAP-CHIP,4.7UF,6.3V,K,X5R,0603,TR; signal model: C2_6010B0009904_4_7uF_6_3V_3; room: Sheet55
C608-C611 = CSC0402: part number: CSC0402-1000PF_50V_2,6010071020AT,CSC_100X050X055_2,0.7MM,CSC0402,0402,X7R,CAPACITOR-CHIP,1000PF,50V,K,X7R,0402,TR; signal model: C2_6010071020AT_1000PF_50V_2; room: Sheet126
C700 = CSC0402: part number: CSC0402-CSC0402_DY,CSC0402_DY,CSC_100X050X040_2,0.55MM,CSC0402,0402,,CSC0402_OPEN; signal model: C2_CSC0402_DY_CSC0402_DY; room: Sheet118
C701 = CSC0402: part number: CSC0402-2.2UF_6.3V_2,6010B0059301,CSC_100X050X040_2,0.55MM,CSC0402,0402,X5R,CAP-CHIP,2.2UF,6.3V,M,X5R,0402,TR; signal model: C2_6010B0059301_2_2uF_6_3V_2; room: Sheet118
C706 = CSC0402: part number: CSC0402-1UF_6.3V_2,6010B0392101,CSC_100X050X055_2,0.65MM,CSC0402,0402,X5R,CAPACITOR-CHIP,1UF,6.3V,K,X5R,0402,TR; signal model: C2_6010B0392101_1uF_6_3V_2; room: Sheet118
C1300 = CSC0402: part number: CSC0402-1UF_6.3V_2,6010B0392101,CSC_100X050X055_2,0.65MM,CSC0402,0402,X5R,CAPACITOR-CHIP,1UF,6.3V,K,X5R,0402,TR; signal model: C2_6010B0392101_1uF_6_3V_2; room: Sheet57
C1301 = CSC0402: part number: CSC0402-220PF_50V_2,6010B0076701,CSC_100X050X040_2,0.55MM,CSC0402,0402,C0G,CAP-CHIP,220PF,50V,J,C0G,0402,TR; signal model: C2_6010B0076701_220pF_50V_2; room: Sheet57
C1310 C1312 = CSC0603: part number: CSC0603-10UF_6.3V_3,6010B0044901,CSC_160X080X080_2,0.95MM,CSC0603,0603,X5R,CAP-CHIP,10UF,6.3V,M,X5R,0603,TR; signal model: C2_6010B0044901_10uF_6_3V_3; room: Sheet57
C1313 C1317 C1318 C1322 C1323 = CSC0402: part number: CSC0402-0.1UF_16V_2,6010A0036403,CSC_100X050X040_2,0.55MM,CSC0402,0402,X7R,CAP-CHIP,0.1UF,16V,K,X7R,0402,TAP; signal model: C2_6010A0036403_0_1uF_16V_2; room: Sheet57
C1314 C1319 = CSC0402: part number: CSC0402-0.01UF_50V_2,6010B0058401,CSC_100X050X040_2,0.55MM,CSC0402,0402,X7R,CAP-CHIP,0.01UF,50V,K,X7R,0402,TAP; signal model: C2_6010B0058401_0_01uF_50V_2; room: Sheet57
C1315 = CSC0402: part number: CSC0402-12PF_50V_2,6010A0036103,CSC_100X050X040_2,0.55MM,CSC0402,0402,NPO,CAP-CHIP-12PF-50V-J-NPO-0402-TAP; signal model: C2_6010A0036103_12pF_50V_2; room: Sheet57
C1316 = CSC0402: part number: CSC0402-18PF_50V_2_DY,6010A0036105_DY,CSC_100X050X040_2,0.55MM,CSC0402,0402,NPO,CAP-CHIP-18PF-50V-J-NPO-0402-TAP; signal model: C2_6010A0036105_DY_18pF_50V_2_DY; room: Sheet57
C1700 = CSC0805: part number: CSC0805-22UF_6.3V_5,6010A0040703,CSC_200X125X140_2,1.5MM,CSC0805,0805,X5R,CAPACITOR-CHIP,22UF,6.3V,M,X5R,0805,TR,1.25MM; signal model: C2_6010A0040703_22UF_6_3V_5; room: Sheet56
C1701 = CSC0402: part number: CSC0402-0.1UF_16V_2,6010A0036403,CSC_100X050X040_2,0.55MM,CSC0402,0402,X7R,CAP-CHIP,0.1UF,16V,K,X7R,0402,TAP; signal model: C2_6010A0036403_0_1uF_16V_2; room: Sheet56
C1702 C1703 = CSC0402: part number: CSC0402-0.01UF_50V_2,6010B0058401,CSC_100X050X040_2,0.55MM,CSC0402,0402,X7R,CAP-CHIP,0.01UF,50V,K,X7R,0402,TAP; signal model: C2_6010B0058401_0_01uF_50V_2; room: Sheet56
C1704-C1706 C1710 C1712-C1715 = CSC0402: part number: CSC0402-0.1UF_16V_2,6010A0036403,CSC_100X050X040_2,0.55MM,CSC0402,0402,X7R,CAP-CHIP,0.1UF,16V,K,X7R,0402,TAP; signal model: C2_6010A0036403_0_1uF_16V_2; room: Sheet65
C1711 = CSC0603: part number: CSC0603-10UF_6.3V_3,6010B0044901,CSC_160X080X080_2,0.95MM,CSC0603,0603,X5R,CAP-CHIP,10UF,6.3V,M,X5R,0603,TR; signal model: C2_6010B0044901_10uF_6_3V_3; room: Sheet65
C1900 = CSC0402: part number: CSC0402-1000PF_50V_2,6010071020AT,CSC_100X050X055_2,0.7MM,CSC0402,0402,X7R,CAPACITOR-CHIP,1000PF,50V,K,X7R,0402,TR; signal model: C2_6010071020AT_1000PF_50V_2; room: Sheet59
C1901 C1937 = CSC0402: part number: CSC0402-0.1UF_16V_2,6010A0036403,CSC_100X050X040_2,0.55MM,CSC0402,0402,X7R,CAP-CHIP,0.1UF,16V,K,X7R,0402,TAP; signal model: C2_6010A0036403_0_1uF_16V_2; room: Sheet59
C1902 C1908 = CSC0402: part number: CSC0402-10UF_6.3V_2,6010B0187202,CSC_100X050X070_2,0.80MM,CSC0402,0402,X5R,CAPACITOR-CHIP,10UF,6.3V,M,X5R,0402,TR,0.5MM; signal model: C2_6010B0187202_10uF_6_3V_2; room: Sheet59
C1909 C1924-C1930 = CSC0402: part number: CSC0402-0.22UF_6.3V_2,6010A0050701,CSC_100X050X040_2,0.55MM,CSC0402,0402,X5R,CAP-CHIP-0.22UF-M-6.3V-X5R-0402-TAP; signal model: C2_6010A0050701_0_22uF_6_3V_2; room: Sheet59
C1913 C1932 = CSC0402: part number: CSC0402-0.1UF_16V_2,6010A0036403,CSC_100X050X040_2,0.55MM,CSC0402,0402,X7R,CAP-CHIP,0.1UF,16V,K,X7R,0402,TAP; signal model: C2_6010A0036403_0_1uF_16V_2; room: Sheet58
C1916-C1923 = CSC0402: part number: CSC0402-0.22UF_6.3V_2,6010A0050701,CSC_100X050X040_2,0.55MM,CSC0402,0402,X5R,CAP-CHIP-0.22UF-M-6.3V-X5R-0402-TAP; signal model: C2_6010A0050701_0_22uF_6_3V_2; room: Sheet58
C1931 C1936 = CSC0402: part number: CSC0402-10UF_6.3V_2,6010B0187202,CSC_100X050X070_2,0.80MM,CSC0402,0402,X5R,CAPACITOR-CHIP,10UF,6.3V,M,X5R,0402,TR,0.5MM; signal model: C2_6010B0187202_10uF_6_3V_2; room: Sheet58
C1933 = CSC0402: part number: CSC0402-1000PF_50V_2,6010071020AT,CSC_100X050X055_2,0.7MM,CSC0402,0402,X7R,CAPACITOR-CHIP,1000PF,50V,K,X7R,0402,TR; signal model: C2_6010071020AT_1000PF_50V_2; room: Sheet58
C2400 = CAP_TANT: part number: CAP_TANT-100UF_6.3V,6010A0052401,CSTJB2_362X305X190_2,2.05MM,CAP_TANT,3.5X2.8,,CAPACITOR-TANT-100UF-6.3V-M-85C-B2-ULESR-TAP; signal model: C2_6010A0052401_100uF_6_3V; room: Sheet121
C2401 = CSC0805: part number: CSC0805-22UF_6.3V_5,6010A0040702,CSC_200X125X130_2,1.4MM,CSC0805,0805,X5R,CAP-CHIP-22UF-6.3V-M-X5R-0805-TAP; signal model: C2_6010A0040702_22uF_6_3V_5; room: Sheet121
C2402 C7553-C7555 C7583 = CSC0402: part number: CSC0402-0.1UF_16V_2,6010A0036403,CSC_100X050X040_2,0.55MM,CSC0402,0402,X7R,CAP-CHIP,0.1UF,16V,K,X7R,0402,TAP; signal model: C2_6010A0036403_0_1uF_16V_2; room: Sheet60
C2403 = CSC0603: part number: CSC0603-10UF_6.3V_3,6010B0044901,CSC_160X080X080_2,0.95MM,CSC0603,0603,X5R,CAP-CHIP,10UF,6.3V,M,X5R,0603,TR; signal model: C2_6010B0044901_10uF_6_3V_3; room: Sheet60
C2404-C2406 C2408 C2409 C7558 C7559 C7569 C7574 = CSC0402: part number: CSC0402-0.1UF_16V_2,6010A0036403,CSC_100X050X040_2,0.55MM,CSC0402,0402,X7R,CAP-CHIP,0.1UF,16V,K,X7R,0402,TAP; signal model: C2_6010A0036403_0_1uF_16V_2; room: Sheet121
C2407 = CSC0402: part number: CSC0402-1UF_6.3V_2,6010B0006001,CSC_100X050X040_2,0.55MM,CSC0402,0402,X5R,CAP-CHIP,1UF,6.3V,K,X5R,0402,TR; signal model: C2_6010B0006001_1uF_6_3V_2; room: Sheet121
C2410-C2413 = CSC0201: part number: CSC0201-0.1UF_6.3V_1,6010B0092501,CSC_060X030X030_2,0.45MM,CSC0201,CAP-CHIP,0.1UF,6.3V,K,X5R,0201,TR; signal model: C2_6010B0092501_0_1uF_6_3V_1; room: Sheet121
C2414 = CSC0805: part number: CSC0805-22UF_6.3V_5,6010A0040702,CSC_200X125X130_2,1.4MM,CSC0805,0805,X5R,CAP-CHIP-22UF-6.3V-M-X5R-0805-TAP; signal model: C2_6010A0040702_22uF_6_3V_5; room: Sheet122
C2415 C2417-C2419 C2425 = CSC0402: part number: CSC0402-0.1UF_16V_2,6010A0036403,CSC_100X050X040_2,0.55MM,CSC0402,0402,X7R,CAP-CHIP,0.1UF,16V,K,X7R,0402,TAP; signal model: C2_6010A0036403_0_1uF_16V_2; room: Sheet122
C2416 = CAP_TANT: part number: CAP_TANT-100UF_6.3V,6010A0052401,CSTJB2_362X305X190_2,2.05MM,CAP_TANT,3.5X2.8,,CAPACITOR-TANT-100UF-6.3V-M-85C-B2-ULESR-TAP; signal model: C2_6010A0052401_100uF_6_3V; room: Sheet122
C2420-C2423 = CSC0201: part number: CSC0201-0.1UF_6.3V_1,6010B0092501,CSC_060X030X030_2,0.45MM,CSC0201,CAP-CHIP,0.1UF,6.3V,K,X5R,0201,TR; signal model: C2_6010B0092501_0_1uF_6_3V_1; room: Sheet122
C2424 = CSC0805: part number: CSC0805-22UF_6.3V_5_DY,6010A0040702_DY,CSC_200X125X130_2,1.45MM,CSC0805,0805,X5R,CAP-CHIP-22UF-6.3V-M-X5R-0805-TAP; signal model: C2_6010A0040702_DY_22uF_6_3V_5_DY; room: Sheet121
C2500 C2509-C2511 = CSC0402: part number: CSC0402-0.33UF_25V_2,6010B0467501,CSC_100X050X055_2,0.65MM,CSC0402,0402,X5R,CAPACITOR-CHIP,0.33UF,25V,K,X5R,0402,TR; signal model: C2_6010B0467501_0_33UF_25V_2; room: Sheet60
C2501-C2504 = CSC0402: part number: CSC0402-0.22UF_25V_2,6010B0467001,CSC_100X050X055_2,0.65MM,CSC0402,0402,X5R,CAPACITOR-CHIP,0.22UF,25V,K,X5R,0402,TR; signal model: C2_6010B0467001_0_22UF_25V_2; room: Sheet60
C2505 C2508 C2518 C2519 C2521 C7573 = CSC0402: part number: CSC0402-0.1UF_16V_2,6010A0036403,CSC_100X050X040_2,0.55MM,CSC0402,0402,X7R,CAP-CHIP,0.1UF,16V,K,X7R,0402,TAP; signal model: C2_6010A0036403_0_1uF_16V_2; room: Sheet61
C2506 = CSC0402: part number: CSC0402-4.7UF_6.3V_2,6010B0164601,CSC_100X050X065_2,0.8MM,CSC0402,0402,X5R,CAPACITOR-CHIP,4.7UF,6.3V,M,X5R,0402,TR,0.5MM; signal model: C2_6010B0164601_4_7UF_6_3V_2; room: Sheet61
C2507 = CSC0603: part number: CSC0603-10UF_6.3V_3_DY,6010B0044901_DY,CSC_160X080X080_2,0.95MM,CSC0603,0603,X5R,CAP-CHIP,10UF,6.3V,M,X5R,0603,TR; signal model: C2_6010B0044901_DY_10uF_6_3V_3_DY; room: Sheet61
C2520 = CAP_TANT: part number: CAP_TANT-100UF_6.3V,6010A0052401,CSTJB2_362X305X190_2,2.05MM,CAP_TANT,3.5X2.8,,CAPACITOR-TANT-100UF-6.3V-M-85C-B2-ULESR-TAP; signal model: C2_6010A0052401_100uF_6_3V; room: Sheet61
C2522 = CSC0805: part number: CSC0805-22UF_6.3V_5,6010A0040702,CSC_200X125X130_2,1.4MM,CSC0805,0805,X5R,CAP-CHIP-22UF-6.3V-M-X5R-0805-TAP; signal model: C2_6010A0040702_22uF_6_3V_5; room: Sheet61
C2547 C2548 C2551 = CSC0805: part number: CSC0805-10UF_25V_5,6010B0150801,CSC_200X125X140_2,1.55MM,CSC0805,0805,X5R,CAP-CHIP,10UF,25V,K,X5R,0805,TR,1.25MM; signal model: C2_6010B0150801_10UF_25V_5; room: Sheet60
C2549 = CSC0402: part number: CSC0402-1UF_6.3V_2,6010B0392101,CSC_100X050X055_2,0.65MM,CSC0402,0402,X5R,CAPACITOR-CHIP,1UF,6.3V,K,X5R,0402,TR; signal model: C2_6010B0392101_1uF_6_3V_2; room: Sheet60
C2552 = CAP_TANT: part number: CAP_TANT-100UF_6.3V_DY,6010A0052401_DY,CSTJB2_362X305X190_2,2.05MM,CAP_TANT,,,CAPACITOR-TANT-100UF-6.3V-M-85C-B2-ULESR-TAP; signal model: C2_6010A0052401_100uF_6_3V_DY; room: Sheet60
C3000 C3002 = CSC0402: part number: CSC0402-2.2UF_6.3V_2,6010B0059302,CSC_100X050X055_2,0.65MM,CSC0402,0402,X5R,CAPACITOR-CHIP,2.2UF,6.3V,M,X5R,0402,TR; signal model: C2_6010B0059302_2_2UF_6_3V_2; room: Sheet62
C3001 = CSC0402: part number: CSC0402-0.1UF_16V_2,6010A0036403,CSC_100X050X040_2,0.55MM,CSC0402,0402,X7R,CAP-CHIP,0.1UF,16V,K,X7R,0402,TAP; signal model: C2_6010A0036403_0_1uF_16V_2; room: Sheet62
C3003 C3007 C3011 C3012 = CSC0402: part number: CSC0402-CSC0402_DY,CSC0402_DY,CSC_100X050X040_2,0.55MM,CSC0402,0402,,CSC0402_OPEN; signal model: C2_CSC0402_DY_CSC0402_DY; room: Sheet62
C3004 C3005 = CSC0402: part number: CSC0402-10PF_50V_2_DY,6010A0025401_DY,CSC_100X050X040_2,0.55MM,CSC0402,0402,NPO,CAP-CHIP-10PF-D,50V-NPO-0402-TAP; signal model: C2_6010A0025401_DY_10pF_50V_2_DY; room: Sheet62
C3008 = CSC0402: part number: CSC0402-680PF_50V_2_DY,6010A0025501_DY,CSC_100X050X040_2,0.55MM,CSC0402,0402,X7R,CAP-CHIP-681-K,50V-X7R-0402-TAP; signal model: C2_6010A0025501_DY_680pF_50V_2_DY; room: Sheet62
C3009 = CSC0402: part number: CSC0402-0.1UF_25V_2,6010B0087101,CSC_100X050X040_2,0.55MM,CSC0402,0402,X5R,CAP-CHIP,0.1UF,25V,K,X5R,0402,TR; signal model: C2_6010B0087101_0_1uF_25V_2; room: Sheet62
C3010 = CSC0603: part number: CSC0603-4.7UF_25V_3,6010B0322201,CSC_160X080X095_2,1.10MM,CSC0603,0603,,CAPACITOR-CHIP,4.7UF,25V,K,X5R,0603,TR,0.8MM; signal model: C2_6010B0322201_4_7uF_25V_3; room: Sheet62
C3013 C3014 C3016 C3017 C3019 C3020 C3026-C3029 = CSC0201: part number: CSC0201-0.1UF_6.3V_1,6010B0092501,CSC_060X030X030_2,0.45MM,CSC0201,CAP-CHIP,0.1UF,6.3V,K,X5R,0201,TR; signal model: C2_6010B0092501_0_1uF_6_3V_1; room: Sheet62
C3500 C3501 = CSC0402: part number: CSC0402-4.7UF_6.3V_2,6010B0164601,CSC_100X050X065_2,0.8MM,CSC0402,0402,X5R,CAPACITOR-CHIP,4.7UF,6.3V,M,X5R,0402,TR,0.5MM; signal model: C2_6010B0164601_4_7UF_6_3V_2; room: Sheet63
C3502-C3505 = CSC0402: part number: CSC0402-0.1UF_16V_2,6010A0036403,CSC_100X050X040_2,0.55MM,CSC0402,0402,X7R,CAP-CHIP,0.1UF,16V,K,X7R,0402,TAP; signal model: C2_6010A0036403_0_1uF_16V_2; room: Sheet63
C4105 C4111 = CSC0402: part number: CSC0402-2.2UF_6.3V_2,6010B0059302,CSC_100X050X055_2,0.65MM,CSC0402,0402,X5R,CAPACITOR-CHIP,2.2UF,6.3V,M,X5R,0402,TR; signal model: C2_6010B0059302_2_2UF_6_3V_2; room: Sheet47
C4125-C4127 C4132 C4133 C4141 C4146 C4147 C4150 C4151 C4154 C4155 C4157 = CSC0402: part number: CSC0402-1UF_6.3V_2,6010B0392101,CSC_100X050X055_2,0.65MM,CSC0402,0402,X5R,CAPACITOR-CHIP,1UF,6.3V,K,X5R,0402,TR; signal model: C2_6010B0392101_1uF_6_3V_2; room: Sheet48
C4128 C4135 C4136 C4140 C4142 C4143 C4148 C4149 C4152 C4153 C4156 = CSC0603: part number: CSC0603-10UF_6.3V_3,6010B0044902,CSC_160X080X095_2,1.05MM,CSC0603,0603,,CAPACITOR-CHIP,10UF,6.3V,M,X5R,0603,TR; signal model: C2_6010B0044902_10uF_6_3V_3; room: Sheet48
C4129 C4144 = CSC0402: part number: CSC0402-0.1UF_16V_2,6010A0036403,CSC_100X050X040_2,0.55MM,CSC0402,0402,X7R,CAP-CHIP,0.1UF,16V,K,X7R,0402,TAP; signal model: C2_6010A0036403_0_1uF_16V_2; room: Sheet48
C4130 C4145 = CSC0402: part number: CSC0402-2.2UF_6.3V_2,6010B0059302,CSC_100X050X055_2,0.65MM,CSC0402,0402,X5R,CAPACITOR-CHIP,2.2UF,6.3V,M,X5R,0402,TR; signal model: C2_6010B0059302_2_2UF_6_3V_2; room: Sheet48
C4139 = CAP_TA_SP: part number: CAP_TA_SP-330UF_2.5V,6010B0106701,CSTJB_350X280X200_2_300,2.15MM,CAP_TA_SP,,,CAPACITOR-TA-SP,330UF,2.5V,M,85C,BX1.9,SMD,TR,45MOHM; signal model: C2_6010B0106701_330uF_2_5V; room: Sheet48
C4165 C4167 C4170 C4171 = CSC0402: part number: CSC0402-0.1UF_16V_2,6010A0036403,CSC_100X050X040_2,0.55MM,CSC0402,0402,X7R,CAP-CHIP,0.1UF,16V,K,X7R,0402,TAP; signal model: C2_6010A0036403_0_1uF_16V_2; room: Sheet29
C4169 C4172 = CSC0402: part number: CSC0402-0.022UF_16V_2,6010A0000101,CSC_100X050X040_2,0.55MM,CSC0402,0402,X7R,CAP-CHIP-223-K,16V-X7R-0402-TAP; signal model: C2_6010A0000101_0_022uF_16V_2; room: Sheet29
C4300 C4305 = CSC0402: part number: CSC0402-220PF_50V_2,6010B0076701,CSC_100X050X040_2,0.55MM,CSC0402,0402,C0G,CAP-CHIP,220PF,50V,J,C0G,0402,TR; signal model: C2_6010B0076701_220pF_50V_2; room: Sheet24
C4301 C4306 = CSC0402: part number: CSC0402-CSC0402_DY,CSC0402_DY,CSC_100X050X040_2,0.55MM,CSC0402,0402,,CSC0402_OPEN; signal model: C2_CSC0402_DY_CSC0402_DY; room: Sheet24
C4303 C4307 = CSC0603: part number: CSC0603-4.7UF_6.3V_3,6010B0009904,CSC_160X080X080_2,0.95MM,CSC0603,0603,X5R,CAP-CHIP,4.7UF,6.3V,K,X5R,0603,TR; signal model: C2_6010B0009904_4_7uF_6_3V_3; room: Sheet24
C4304 C4308 = CSC0402: part number: CSC0402-0.1UF_16V_2,6010A0036403,CSC_100X050X040_2,0.55MM,CSC0402,0402,X7R,CAP-CHIP,0.1UF,16V,K,X7R,0402,TAP; signal model: C2_6010A0036403_0_1uF_16V_2; room: Sheet24
C4450 = CSC0402: part number: CSC0402-0.1UF_16V_2,6010A0036403,CSC_100X050X040_2,0.55MM,CSC0402,0402,X7R,CAP-CHIP,0.1UF,16V,K,X7R,0402,TAP; signal model: C2_6010A0036403_0_1uF_16V_2; room: Sheet49
C4451 = CSC0402: part number: CSC0402-1000PF_50V_2,6010071020AT,CSC_100X050X055_2,0.7MM,CSC0402,0402,X7R,CAPACITOR-CHIP,1000PF,50V,K,X7R,0402,TR; signal model: C2_6010071020AT_1000PF_50V_2; room: Sheet49
C4500-C4503 C4720 = CSC0805: part number: CSC0805-47UF_6.3V_5,6010B0096602,CSC_200X125X145_2,1.55MM,CSC0805,0805,,CAPACITOR-CHIP,47UF,6.3V,M,X5R,0805,TR; signal model: C2_6010B0096602_47UF_6_3V_5; room: Sheet31
C4508 C4700 C4701 C4731 C4733 C4763 C4768-C4775 C4778-C4783 C4787 = CSC0402: part number: CSC0402-10UF_6.3V_2,6010B0187202,CSC_100X050X070_2,0.80MM,CSC0402,0402,X5R,CAPACITOR-CHIP,10UF,6.3V,M,X5R,0402,TR,0.5MM; signal model: C2_6010B0187202_10uF_6_3V_2; room: Sheet33
C4509-C4515 C4538 C4539 C4551 C4598 C4599 = CSC0603: part number: CSC0603-22UF_6.3V_3,6010B0219002,CSC_160X080X100_2,1.10MM,CSC0603,0603,,CAPACITOR-CHIP,22UF,6.3V,M,X5R,0603,TR,0.8MM; signal model: C2_6010B0219002_22uF_6_3V_3; room: Sheet31
C4516-C4537 = CSC0402: part number: CSC0402-10UF_6.3V_2,6010B0187202,CSC_100X050X070_2,0.80MM,CSC0402,0402,X5R,CAPACITOR-CHIP,10UF,6.3V,M,X5R,0402,TR,0.5MM; signal model: C2_6010B0187202_10uF_6_3V_2; room: Sheet31
C4540 C4541 = CSC0603: part number: CSC0603-22UF_6.3V_3,6010B0219002,CSC_160X080X100_2,1.10MM,CSC0603,0603,,CAPACITOR-CHIP,22UF,6.3V,M,X5R,0603,TR,0.8MM; signal model: C2_6010B0219002_22uF_6_3V_3; room: Sheet32
C4549 C4552 C4556-C4563 C4566 C4568 C4614 C4667 C4697 C4699 C4744-C4746 C4753 C4758 C4800 C4807 C4808 = CSC0402: part number: CSC0402-1UF_6.3V_2,6010B0392101,CSC_100X050X055_2,0.65MM,CSC0402,0402,X5R,CAPACITOR-CHIP,1UF,6.3V,K,X5R,0402,TR; signal model: C2_6010B0392101_1uF_6_3V_2; room: Sheet31
C4554 C4588 = CSC0603: part number: CSC0603-22UF_6.3V_3,6010B0391701,CSC_160X080X080_2,0.90MM,CSC0603,0603,,CAPACITOR-CHIP,22UF,6.3V,M,X5R,0603,TR,0.6MM; signal model: C2_6010B0391701_22uF_6_3V_3; room: Sheet34
C4555 C4580-C4585 = CSC0603: part number: CSC0603-22UF_6.3V_3,6010B0219002,CSC_160X080X100_2,1.10MM,CSC0603,0603,,CAPACITOR-CHIP,22UF,6.3V,M,X5R,0603,TR,0.8MM; signal model: C2_6010B0219002_22uF_6_3V_3; room: Sheet34
C4589 C4600 = CSC0805: part number: CSC0805-47UF_6.3V_5,6010B0096602,CSC_200X125X145_2,1.55MM,CSC0805,0805,,CAPACITOR-CHIP,47UF,6.3V,M,X5R,0805,TR; signal model: C2_6010B0096602_47UF_6_3V_5; room: Sheet34
C4594 = CSC0402: part number: CSC0402-12PF_50V_2,6010A0036103,CSC_100X050X040_2,0.55MM,CSC0402,0402,NPO,CAP-CHIP-12PF-50V-J-NPO-0402-TAP; signal model: C2_6010A0036103_12pF_50V_2; room: Sheet27
C4602 = CSC0603: part number: CSC0603-47UF_4V_3,6010B0245002,CSC_160X080X100_2,1.10MM,CSC0603,0603,,CAP-CHIP-47UF-4V-K-X5R-0603-TAP; signal model: C2_6010B0245002_47UF_4V_3; room: Sheet34
C4612 = CSC0402: part number: CSC0402-47PF_50V_2,6010074702AT,CSC_100X050X040_2,0.55MM,CSC0402,0402,NPO,CAP-CHIP-470-J,50V-NPO-0402; signal model: C2_6010074702AT_47pF_50V_2; room: Sheet30
C4626 C7032 = CSC0402: part number: CSC0402-0.01UF_50V_2,6010B0058401,CSC_100X050X040_2,0.55MM,CSC0402,0402,X7R,CAP-CHIP,0.01UF,50V,K,X7R,0402,TAP; signal model: C2_6010B0058401_0_01uF_50V_2; room: Sheet22
C4627-C4631 C4660-C4663 C4668 C4760 C4761 C4785 C4797 = CSC0402: part number: CSC0402-1UF_6.3V_2,6010B0392101,CSC_100X050X055_2,0.65MM,CSC0402,0402,X5R,CAPACITOR-CHIP,1UF,6.3V,K,X5R,0402,TR; signal model: C2_6010B0392101_1uF_6_3V_2; room: Sheet34
C4656-C4659 C4680-C4683 C4687 C4688 = CSC0402: part number: CSC0402-10UF_6.3V_2,6010B0187202,CSC_100X050X070_2,0.80MM,CSC0402,0402,X5R,CAPACITOR-CHIP,10UF,6.3V,M,X5R,0402,TR,0.5MM; signal model: C2_6010B0187202_10uF_6_3V_2; room: Sheet34
C4669 C4670 = CSC0402: part number: CSC0402-1UF_6.3V_2_DY,6010B0392101_DY,CSC_100X050X055_2,0.65MM,CSC0402,0402,X5R,CAPACITOR-CHIP,1UF,6.3V,K,X5R,0402,TR; signal model: C2_6010B0392101_DY_1uF_6_3V_2_DY; room: Sheet34
C4679 C4684-C4686 C4689-C4696 C4698 C4710 C4711 C4715 = CSC0402: part number: CSC0402-10UF_6.3V_2_DY,6010B0187202_DY,CSC_100X050X070_2,0.80MM,CSC0402,0402,X5R,CAPACITOR-CHIP,10UF,6.3V,M,X5R,0402,TR,0.5MM; signal model: C2_6010B0187202_DY_10uF_6_3V_2_DY; room: Sheet34
C4702 C4704 = CSC0201: part number: CSC0201-CSC0201_DY,CSC0201_DY,CSC_060X030X030_2,0.45MM,CSC0201,CSC0201_DY; signal model: C2_CSC0201_DY_CSC0201_DY; room: Sheet30
C4703 C4706 = CSC0805: part number: CSC0805-47UF_6.3V_5,6010B0096602,CSC_200X125X145_2,1.55MM,CSC0805,0805,,CAPACITOR-CHIP,47UF,6.3V,M,X5R,0805,TR; signal model: C2_6010B0096602_47UF_6_3V_5; room: Sheet33
C4705 C4707 = CSC0201: part number: CSC0201-CSC0201_DY,CSC0201_DY,CSC_060X030X030_2,0.45MM,CSC0201,CSC0201_DY; signal model: C2_CSC0201_DY_CSC0201_DY; room: Sheet37
C4708 C4709 C4716 C4718 C4719 C4732 C4764 C4765 C4776 = CSC0603: part number: CSC0603-22UF_6.3V_3,6010B0219002,CSC_160X080X100_2,1.10MM,CSC0603,0603,,CAPACITOR-CHIP,22UF,6.3V,M,X5R,0603,TR,0.8MM; signal model: C2_6010B0219002_22uF_6_3V_3; room: Sheet33
C4712-C4714 = CSC0402: part number: CSC0402-1UF_6.3V_2,6010B0392101,CSC_100X050X055_2,0.65MM,CSC0402,0402,X5R,CAPACITOR-CHIP,1UF,6.3V,K,X5R,0402,TR; signal model: C2_6010B0392101_1uF_6_3V_2; room: Sheet42
C4717 = CSC0603: part number: CSC0603-10UF_6.3V_3,6010B0044902,CSC_160X080X095_2,1.05MM,CSC0603,0603,,CAPACITOR-CHIP,10UF,6.3V,M,X5R,0603,TR; signal model: C2_6010B0044902_10uF_6_3V_3; room: Sheet33
C4721-C4723 = CSC0805: part number: CSC0805-47UF_6.3V_5_DY,6010B0096602_DY,CSC_200X125X145_2,1.55MM,CSC0805,0805,,CAPACITOR-CHIP,47UF,6.3V,M,X5R,0805,TR; signal model: C2_6010B0096602_DY_47UF_6_3V_5_DY; room: Sheet34
C4726 C4729 C4730 C4766 C4786 C4789-C4791 = CSC0402: part number: CSC0402-1UF_6.3V_2,6010B0392101,CSC_100X050X055_2,0.65MM,CSC0402,0402,X5R,CAPACITOR-CHIP,1UF,6.3V,K,X5R,0402,TR; signal model: C2_6010B0392101_1uF_6_3V_2; room: Sheet33
C4767 C4788 = CSC0402: part number: CSC0402-18PF_50V_2,6010A0036105,CSC_100X050X040_2,0.55MM,CSC0402,0402,NPO,CAP-CHIP-18PF-50V-J-NPO-0402-TAP; signal model: C2_6010A0036105_18pF_50V_2; room: Sheet45
C4802 = CSC0402: part number: CSC0402-0.1UF_16V_2_DY,6010A0036403_DY,CSC_100X050X040_2,0.55MM,CSC0402,0402,X7R,CAP-CHIP,0.1UF,16V,K,X7R,0402,TAP; signal model: C2_6010A0036403_DY_0_1uF_16V_2_DY; room: Sheet39
C4809 C4845 C4852 C4861 C4873 C4874 C4877 = CSC0603: part number: CSC0603-22UF_6.3V_3,6010B0219002,CSC_160X080X100_2,1.10MM,CSC0603,0603,,CAPACITOR-CHIP,22UF,6.3V,M,X5R,0603,TR,0.8MM; signal model: C2_6010B0219002_22uF_6_3V_3; room: Sheet41
C4810-C4812 C4818-C4823 C4831-C4842 C4878-C4888 = CSC0201: part number: CSC0201-0.22UF_6.3V_1,6010B0058114,CSC_060X030X030_2,0.45MM,CSC0201,CAP-CHIP,0.22UF,6.3V,M,X5R,0201,TR; signal model: C2_6010B0058114_0_22uF_6_3V_1; room: Sheet26
C4826 = CSC0402: part number: CSC0402-15PF_50V_2,6010071502AT,CSC_100X050X040_2,0.55MM,CSC0402,0402,NPO,CAP-CHIP,15PF,J-50V-NPO-0402-TAP; signal model: C2_6010071502AT_15pF_50V_2; room: Sheet45
C4828 = CSC0402: part number: CSC0402-12PF_50V_2,6010A0036103,CSC_100X050X040_2,0.55MM,CSC0402,0402,NPO,CAP-CHIP-12PF-50V-J-NPO-0402-TAP; signal model: C2_6010A0036103_12pF_50V_2; room: Sheet45
C4843 C4847 C4851 C4855 C4856 = CSC0402: part number: CSC0402-10UF_6.3V_2,6010B0187202,CSC_100X050X070_2,0.80MM,CSC0402,0402,X5R,CAPACITOR-CHIP,10UF,6.3V,M,X5R,0402,TR,0.5MM; signal model: C2_6010B0187202_10uF_6_3V_2; room: Sheet41
C4890-C4892 = CSC0402: part number: CSC0402-0.1UF_16V_2_DY,6010A0036403_DY,CSC_100X050X040_2,0.55MM,CSC0402,0402,X7R,CAP-CHIP,0.1UF,16V,K,X7R,0402,TAP; signal model: C2_6010A0036403_DY_0_1uF_16V_2_DY; room: Sheet41
C4954 C4955 = CSC0402: part number: CSC0402-0.01UF_50V_2,6010B0058401,CSC_100X050X040_2,0.55MM,CSC0402,0402,X7R,CAP-CHIP,0.01UF,50V,K,X7R,0402,TAP; signal model: C2_6010B0058401_0_01uF_50V_2; room: Sheet38
C4960 C4961 = CSC0402: part number: CSC0402-0.1UF_16V_2,6010A0036403,CSC_100X050X040_2,0.55MM,CSC0402,0402,X7R,CAP-CHIP,0.1UF,16V,K,X7R,0402,TAP; signal model: C2_6010A0036403_0_1uF_16V_2; room: Sheet38
C6035 C6037 = CSC0402: part number: CSC0402-1000PF_50V_2,6010071020AT,CSC_100X050X055_2,0.7MM,CSC0402,0402,X7R,CAPACITOR-CHIP,1000PF,50V,K,X7R,0402,TR; signal model: C2_6010071020AT_1000PF_50V_2; room: Sheet7
C6036 C6038 = CSC0402: part number: CSC0402-0.01UF_50V_2,6010B0058401,CSC_100X050X040_2,0.55MM,CSC0402,0402,X7R,CAP-CHIP,0.01UF,50V,K,X7R,0402,TAP; signal model: C2_6010B0058401_0_01uF_50V_2; room: Sheet7
C7006 = CSC0402: part number: CSC0402-0.1UF_25V_2,6010B0087101,CSC_100X050X040_2,0.55MM,CSC0402,0402,X5R,CAP-CHIP,0.1UF,25V,K,X5R,0402,TR; signal model: C2_6010B0087101_0_1uF_25V_2; room: Sheet23
C7011 = CSC0402: part number: CSC0402-1000PF_50V_2,6010071020AT,CSC_100X050X055_2,0.7MM,CSC0402,0402,X7R,CAPACITOR-CHIP,1000PF,50V,K,X7R,0402,TR; signal model: C2_6010071020AT_1000PF_50V_2; room: Sheet23
C7015 = CSC0402: part number: CSC0402-100PF_50V_2_DY,6010071012AT_DY,CSC_100X050X040_2,0.55MM,CSC0402,0402,NPO,CAP-CHIP-101-J,50V-NPO-0402; signal model: C2_6010071012AT_DY_100pF_50V_2_DY; room: Sheet23
C7016 C7017 C7019 C7020 C7037 C7038 C7041 C7042 = CSC0402: part number: CSC0402-1UF_6.3V_2,6010B0392101,CSC_100X050X055_2,0.65MM,CSC0402,0402,X5R,CAPACITOR-CHIP,1UF,6.3V,K,X5R,0402,TR; signal model: C2_6010B0392101_1uF_6_3V_2; room: Sheet22
C7033 = CSC0402: part number: CSC0402-0.22UF_6.3V_2,6010A0050701,CSC_100X050X040_2,0.55MM,CSC0402,0402,X5R,CAP-CHIP-0.22UF-M-6.3V-X5R-0402-TAP; signal model: C2_6010A0050701_0_22uF_6_3V_2; room: Sheet23
C7036 = CSC0402: part number: CSC0402-0.022UF_16V_2,6010A0000101,CSC_100X050X040_2,0.55MM,CSC0402,0402,X7R,CAP-CHIP-223-K,16V-X7R-0402-TAP; signal model: C2_6010A0000101_0_022uF_16V_2; room: Sheet23
C7039 = CSC0402: part number: CSC0402-CSC0402,CSC0402,CSC_100X050X040_2,0.55MM,CSC0402,0402,,CSC0402; signal model: C2_CSC0402_CSC0402; room: Sheet22
C7500-C7513 C7546 C7547 C7550-C7552 = CSC0402: part number: CSC0402-0.1UF_16V_2,6010A0036403,CSC_100X050X040_2,0.55MM,CSC0402,0402,X7R,CAP-CHIP,0.1UF,16V,K,X7R,0402,TAP; signal model: C2_6010A0036403_0_1uF_16V_2; room: Sheet117
