# Allegro board PH317-53 COVINI-6050A3087701-MB-AX2 (BDV)(.BRD).brd (continued)
## Nets (continued)
Pads without a net: CN2 3; CN251 3; CN253 3; CN601 4; CN603 47; CN1300 6 8 12 16 20 62 66 68 70; CN1900 6 8 20 22 24 26 28 30 32 34 36 38 40 42 44 46 48 56 58 67 69; CN1901 6 8 20 22 24 26 28 30 32 34 36 40 42 44 46 48 56 58 67; CN2500 A8 B8; CN4100 87 88 91 92 95 97 100 101 104 105 162 165; CN4125 87 88 91 92 95 97 100 101 104 105 162 165; D300 2; D2400 4 6; D2402 4 6; D4711 2; D4801 2; D7000 2; D7001 2; D7002 2; D7004 2; D7005 2; D7500 3 8; D51510 2; D53552 2; D53571 2; D53581 2; D56652 2 9; FIX1 1; FIX2 1; FIX3 1; FIX4 1; FIX5 1; FIX6 1; FIX7 1; FIX8 1; FIX9 1; FIX10 1; FIX11 1; FIX12 1; FIX13 1; FIX14 1; FIX15 1; FIX16 1; PAD60300 4; U400 25 26 28; U500 4 14 16 23 24 48; U702 6 11 12 13 17 22 28 29; U2400 3; U2401 24; U2403 24; U2500 3; U3500 2 3 4 5 6 7 9 10 11 12 13 14 15 25 26 27 28 29 30 31 32; U4555 A27 AA14 AD2 AD4 AE1 AE5 AE9 AE10 AE11 AE29 AF10 AJ8 AJ10 AJ11 AK3 AL1 AL2 AL3 AM10 AM11 AP14 AP29 AT3 AT5 AT7 AT11 AT13 AU13 AW7 AW8 AW9 AW10 AW11 AW13 AY1 AY2 AY3 AY4 AY5 AY7 AY8 AY9 AY10 AY11 AY13 B27 B30 B33 B34 B36 BA1 BA2 BA3 BA4 BA5 BH30 BJ28 BK28 BL31 BL34 BM31 BN33 BN35 BR1 BR2 BR27 BR31 BR33 BR35 BT2 BT27 BT30 C1 C30 C33 C34 C38 D1 D27 D34 E1 E2 E26 E27 E30 E33 E36 E37 F26 F30 F33 F34 F35 F37 G3 G13 G38 H24 H33 H34 H36 H37 J3 J24 J34 J35 J37 J38 K36 K37 N29 R14; U4710 A17 A22 A25 A44 AA45 AB2 AB3 AC2 AC3 AC6 AC7 AC9 AC11 AC14 AC15 AD47 AD48 AE9 AE11 AE43 AE44 AE48 AF47 AH14 AH15 AH40 AH41 AH47 AH48 AJ6 AJ7 AJ46 AJ47 AK47 AL48 AM7 AM43 AM45 AM46 AM48 AN4 AN18 AN37 AN40 AN46 AN47 AP2 AP3 AP29 AP48 AR13 AR47 AT10 AT49 AV7 AV13 AV16 AV18 AW3 AW13 AW15 AW18 AW21 AW24 B17 B18 B19 B21 B23 B24 B25 B26 B27 B40 B41 B44 BA20 BB16 BB20 BC17 BD8 BD12 BD16 BD17 BD20 BD21 BD29 BD33 BE8 BE9 BE12 BE14 BE15 BE17 BE18 BE19 BE20 BE24 BE27 BE32 BE33 BF8 BF9 BF10 BF14 BF15 BF17 BF18 BF19 BF25 BF27 BF29 BF33 BF36 BF41 BG8 BG44 C16 C17 C18 C19 C20 C21 C23 C24 C26 C27 C40 C41 C42 C44 D20 D21 D29 D42 D43 E28 E45 F14 F16 F20 F24 F26 F44 G1 G2 G14 G17 G20 G24 G26 H2 H3 J18 J21 J24 K6 K7 K18 K21 K29 L24 L26 L41 L46 L47 L48 M6 M26 M29 M40 M44 N2 N3 N8 N13 N15 N18 N32 N42 N47 N48 P9 P21 P24 P41 P47 P48 R10 R13 R15 R18 R21 R24 R32 R35 R37 R40 R46 R47 T47 U2 U3 U13 U35 U37 U48 V2 V3 V47 V48 W3 W4 W6 W7 W46 W47 Y3 Y4 Y14 Y15 Y35 Y36 Y48; U50000 AA44 AC9 AM1 AM2 AM3 AM5 AM6 AM7 AM8 AN1 AN2 AN3 AN6 AN7 AN44 AR1 AR2 AR3 AR5 AR6 AR7 AR8 AT1 AT2 AT3 AT6 AT7 AV1 AV2 AV3 AV5 AV6 AV7 AV8 AW1 AW2 AW3 AW6 AW7 BA1 BA2 BA6 BA7 BA8 BB1 BB3 BB7 BB8 BD4 BD21 BD23 BD24 BE2 BE4 BE11 BE23 BF9 BF11 BF12 BF21 BF23 BF24 BG6 BG11 BG12 BG21 BG23 BG24 BH6 BH11 BH12 BH23 BJ1 BJ2 BK11 BK12 BK14 BK15 BK17 BK18 BK20 BK21 BK24 BK44 BL11 BL12 BL14 BL15 BL17 BL18 BL20 BL21 BL23 BM8 BM9 BM11 BM12 BM14 BM15 BM17 BM18 BM20 BM21 BM23 BM24 BM44 BM45 J14 J23 J35 J41 P9; U50500 F5 F10 G5 M5 N5 N10; U50600 F5 F10 G5 M5 N5 N10; U50700 F5 F10 G5 M5 N5 N10; U50800 F5 F10 G5 M5 N5 N10; U50900 F5 F10 G5 M5 N5 N10; U51000 F5 F10 G5 M5 N5 N10; U51100 F5 F10 G5 M5 N5 N10; U51200 F5 F10 G5 M5 N5 N10; U52000 8 10 17 18 21 26 31; U55800 6 12 16 17 22 23 30; U56400 25 36; U60100 4; U60200 10; U60250 10 16; U60900 10 12; U66010 6 31; U66020 6 31; U66030 6 31; U66040 6 31; U67000 2 3 4 5 13 14 27 30; U67400 10 12; U67600 7; X4750 2 3

## Via types
v1: diameter 0.457, hole 0.254, TOP to BOTTOM, 5066 vias
v2: diameter 0.61, hole 0.305, TOP to BOTTOM, 783 vias
v3: diameter 0.61, hole 0.254, TOP to BOTTOM, 565 vias
v4: diameter 0.406, hole 0.203, TOP to BOTTOM, 3220 vias
v5: diameter 0.61, hole 0.406, TOP to BOTTOM, 1319 vias
v6: diameter 0.61, hole 0.203, TOP to BOTTOM, 5 vias
v7: diameter 0.762, hole 0.406, TOP to BOTTOM, 4 vias

## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point)
1V05A_PG: length 2.8
  BOTTOM w0.254: U60900.9 222.07,49.48 221.84,49.25 221.1,49.25 v2(220.85,49) 220.62,48.77 R7006.2
1V8_AON_PG: length 4.7
  BOTTOM w0.102: U53520.1 143.5,99.81 142.8,99.11 142.01,99.11 141.58,98.69 R55601.2 R55602.2 v2(140.31,97.92)
1V8_MAIN_EN_AND_LEVEL: length 83.6
  L8 w0.102: v1(113.56,54.69) 114.63,54.69 116.2,56.26 122.48,56.26 v3(122.96,56.75) 122.96,57.06 123.99,58.09 128.2,58.09 129.52,59.41 133.33,59.41 137.87,63.96 137.87,66.61 137.67,66.81 137.67,70.73 139.51,72.57 139.51,101.26 140.2,101.96 v1(140.61,101.96)
  BOTTOM w0.102: R53573.1 122.83,56.62 v3(122.96,56.75) ; R53584.1 v3(122.96,56.75) ; v3(122.96,56.75) 123.14,56.57 R53574.2 ; v1(140.61,101.96) 140.87,102.22 U53520.4 142.2,102.6 142.79,103.2 R53520.1 ; v1(113.56,54.69) 112.54,54.69 111.37,55.87 107.92,55.87 R53550.1 106.62,55.93 105.99,55.93 105.59,56.33 U53550.2
1V8_MAIN_EN_LEVEL: length 9.6
  BOTTOM w0.102: Q53510.6 147.01,101.46 146.4,100.84 TP53510.1 ; C53510.1 R53515.2 144.98,99.7 144.68,100 TP53510.1 ; TP53510.1 142.97,100.84 142.85,100.71 U53520.2 ; TP53510.1 144.57,100.94 R53510.2
1V8_MAIN_EN_OR: length 209.9
  TOP w0.102: v1(198.6,169.4) 198.29,169.09 U55300.3
  L3 w0.102: v1(198.6,169.4) 197.53,170.46 193.72,170.46 192.93,171.25 192.43,171.25 190.93,172.75 190.93,177.27 188.79,179.4 155.27,179.4 147.65,171.78 147.65,171.19 146.33,169.87 146.33,168.79 145.54,168 145.54,164.72 143.8,162.98 143.8,148.12 142.1,146.42 141.77,146.42 141.77,146.42 141.26,146.42 139.67,144.83 138.73,144.83 137.04,143.15 v1(137.04,141.49)
  L8 w0.102: v1(137.04,141.49) 136.95,141.41 136.95,131.58 135.37,130 135.37,111.64 136.6,110.41 136.6,83.07 135.84,82.31 135.84,73.7 132.38,70.24 132.38,66.02 131.34,64.98 129.74,64.98 128.98,64.21 128.98,62.51 128.37,61.9 116.02,61.9 v1(109.24,55.12)
  BOTTOM w0.102: TP53551.1 108.76,55.12 v1(109.24,55.12) 109.63,54.73 C53552.2 110.99,54.73 R53552.2 111.22,54.91 112.41,53.73 D53552.3
1V8_MAIN_EN_OR_LEVEL: length 8.9
  BOTTOM w0.102: D53552.1 112.96,53.99 111.42,55.53 107.64,55.53 v2(107.29,55.17) U53550.4
1V8_MAIN_R_EN: length 2.5
  BOTTOM w0.102: v2(149.3,102.64) 149.19,102.53 R53512.2 147.76,101.96 Q53510.5
1V8_MAIN_R_EN#: length 2.6
  BOTTOM w0.102: Q53510.2 Q53510.3 145.73,103.03 R53511.2 145.35,103.95 v2(145.01,104.3)
1V8S_DGPU_PG: length 135.1
  TOP w0.102: U67400.9 195.09,174.93 194.81,174.65 v1(194.81,174.25)
  L5 w0.102: v1(149.18,170.7) 149.83,171.35 149.83,172.62 156.28,179.07 192.04,179.07 194.89,176.22 194.89,174.32 v1(194.81,174.25)
  L8 w0.102: v1(141.14,100.51) 142.27,101.64 142.27,106.95 140.74,108.49 140.74,110.04 138.02,112.75 138.02,116.89 140.56,119.43 140.56,124.67 140.17,125.06 140.17,139.66 139.77,140.05 139.77,144.95 138.15,146.58 138.15,146.75 138.15,150.84 141.55,154.24 141.55,158.6 143.44,160.49 143.44,162.42 145.61,164.6 145.61,167.84 146.54,168.76 147.63,168.76 149.18,170.32 v1(149.18,170.7)
  BOTTOM w0.102: v1(141.14,100.51) 141.22,100.44 R55601.1
2V5_PG: length 1.4
  BOTTOM w0.102: R7042.1 77.64,57.58 77.95,57.89 U60400.5
3V3DS_PG: length 51
  TOP w0.102: U60100.3 192.78,23.19 192.5,22.91 v1(192.25,22.91)
  L3 w0.102: v1(205.81,21.36) 206.57,21.36 207.8,20.14 214.91,20.14 214.92,20.13 214.93,20.13 215.24,19.82 223.06,19.82 223.49,20.25 223.49,20.96 v1(223.29,21.16)
  L5 w0.102: v1(192.25,22.91) 192.86,22.3 193.6,22.3 194.84,21.06 194.84,19.79 195.32,19.31 195.75,19.31 196.59,18.47 202.38,18.47 203.4,19.49 203.4,20.07 204.01,20.68 205.48,20.68 205.81,21.01 v1(205.81,21.36)
  BOTTOM w0.102: R7021.2 220.6,27.26 v2(221.1,26.75) 221.18,26.67 222.12,26.67 223.85,24.95 223.85,21.72 v1(223.29,21.16) ; v1(205.81,21.36) 205.81,21.52 205.25,22.08 205.25,23.65 205.89,24.28 U1.18
3V_LP#: length 2.3
  TOP w0.102: TP60102.1 192.78,26.93 U60100.12
19V_CURRENT_MONITOR_N: length 15.6
  TOP w0.254: R67099.4 160.78,46.74 160.5,46.46 160.5,45.37 v1(160.27,45.14)
  L10 w0.254: v1(160.27,45.14) 159.51,45.14 158.67,44.3 149.17,44.3 v1(148.76,44.71)
  BOTTOM w0.254: R52011.1 148.61,45.35 148.61,44.86 v1(148.76,44.71)
19V_CURRENT_MONITOR_P: length 18
  TOP w0.254: R67099.3 159.86,46.74 160.12,46.49 160.12,45.67 159.79,45.34 159.79,44.94 159.81,44.91 v1(159.81,44.66)
  L10 w0.254: v1(159.81,44.66) 159.1,43.95 148.84,43.95 148.1,44.68 v1(148.05,44.68)
  BOTTOM w0.254: R52014.1 146.96,44.53 147.43,45 147.43,45.16 147.85,45.58 R52012.1 148.15,45.37 148.15,44.78 v1(148.05,44.68)
AGND_AUDIO: length 14.6
  TOP w0.254: U500.38 22.82,54.72 23.09,54.46 v1(23.09,53.83) ; U500.25 v1(16.56,53.62)
  TOP w0.305: PAD502.2 v1(13.66,47.68) ; C524.1 v1(25.25,47.32) ; PAD501.2 v3(24.25,48.11) ; v1(25.41,48.95) PAD500.2
  TOP w0.381: C512.1 v1(24.46,49.95) ; v1(25.65,49.91) 25.65,50.69 C513.2 ; C504.2 v1(13.03,50.05) ; v1(14.04,50.65) 14.74,50.65 C501.2 ; C502.1 17.9,50.28 v1(18.23,49.94) ; C525.1 v1(12.01,58.45) ; v1(11.85,57.03) R501.2 ; R531.2 14.85,51.88 C505.2 14.09,51.36 14.04,51.31 v1(14.04,51.3) ; C531.2 v1(11.79,55.93) ; v1(12.01,47.6) C523.1
  BOTTOM w0.356: CN603.1 v1(32.78,35.85) ; CN603.4 v1(32.81,37.35)
AVDDH: length 19.5
  TOP w0.254: C407.1 285.68,104.9 285.28,104.5 U400.22 ; U400.9 285.3,97.94 285.3,97.38 285.53,97.15 285.65,97.15 285.66,97.16 286.69,97.16
  TOP w0.381: v1(288.54,96.17) 288.54,95.42 C417.1 ; 286.69,97.16 287.25,96.6 287.45,96.6 v2(287.78,96.27) 287.78,96.12 288.54,95.37 C417.1 ; C417.1 C416.1 ; C407.1 285.87,104.89 v1(285.87,104.14)
  L3 w0.381: v1(288.54,96.17) 288.54,96.27 288.51,96.3 288.51,103.13 287.98,103.66 286.36,103.66 286.21,103.81 286.2,103.81 v1(285.87,104.14)
AVDDL: length 46.1
  TOP w0.254: v1(287.32,99.5) 287.31,99.51 U400.13 ; U400.19 287.15,101.91 v1(287.37,102.14) ; 284.35,95.84 284.25,95.94 284.25,97.06 284.08,97.23 U400.6 ; 281.33,102.8 U400.31
  TOP w0.305: v1(287.37,102.14) 287.7,102.47 v2(287.96,102.47) 288.05,102.56 C408.2
  TOP w0.381: L401.2 278.9,93.7 v1(279.45,93.7) ; 284.35,95.84 285.05,95.14 C424.1 C420.1 285.05,93.13 v1(284.96,93.04) ; 281.33,102.8 281.48,102.95 C406.2 281.41,104.89 v1(280.92,104.4)
  TOP w0.508: L402.2 275.79,105.54 275.69,105.44 v1(275.67,105.44)
  L3 w0.508: v1(275.67,105.44) 277.09,105.44 277.59,104.93 277.59,104.42 278.51,103.51 280.03,103.51 v1(280.92,104.4) 280.92,104.37 282.17,103.13 285.67,103.13 286.66,102.14 v1(287.37,102.14) 287.37,101.5 286.84,100.97 286.84,99.99 287.32,99.51 v1(287.32,99.5) 287.83,98.99 287.83,95.1 285.77,93.04 v1(284.96,93.04) 284.3,93.7 v1(279.45,93.7)
  BOTTOM w0.381: v1(287.32,99.5) 287.32,99.51 287.01,99.82 C425.1
AVDDVCO: length 6.8
  TOP w0.254: U400.34 280.97,101.11 280.95,101.13 280.75,101.13 280.67,101.22 280.34,101.22 280.09,101.46 280.04,101.46
  TOP w0.305: 280.04,101.46 279.99,101.46 279.32,102.14 v2(279.32,102.34) 278.91,102.75 C410.1
  TOP w0.381: C410.1 278.53,103.38 C409.1 C404.1 278.27,104.73 277.63,105.37 L402.1
DGND: length 3451.5
  TOP w0.15: 179.24,125.72 v4(179.13,125.72)
  TOP w0.2: C53028.2 181.93,129.98 v4(181.93,129.81) ; v4(181.91,124.35) 181.91,124.48 C53027.2 ; C53026.2 181.01,122.41 181.01,122.41 v4(181.24,122.21) ; C53044.2 181.31,127.78 v4(181.47,127.63) ; R50501.2 173.48,167.31 v4(173.29,167.5) ; v4(162.66,165.97) 162.89,165.74 162.89,165.25 C50655.2
  TOP w0.203: C53029.2 173.66,141.99 v4(173.55,141.88) ; v4(208.37,125.99) 208.48,126.1 C51038.2
  TOP w0.225: C53008.2 181.35,125.51 v4(181.45,125.41) ; v4(180.96,175.26) 181.02,175.2 C50540.2 ; v4(183.91,167.46) 183.91,167.05 C50551.2 ; C50629.2 169.66,166.68 169.83,166.85 170.25,166.85 v4(170.27,166.87) ; v1(157.11,166.65) 157.21,166.75 C50627.2 ; v4(165.68,165.21) 165.66,165.23 C50637.2 165.07,165.76 v4(165.24,165.93)
  TOP w0.254: v4(205.38,123.12) 205.63,122.87 C51039.2 ; C52412.2 175.85,129.04 v4(175.67,129.22) 175.65,129.21 C52405.2 ; C52467.2 178.34,129.07 ; C4789.2 C4781.2 ; C4789.2 120.19,137.85 v1(120.19,137.44) ; C4789.2 120.43,138.03 121.16,138.76 C4766.2 ; v4(208.73,145.66) 209.05,145.33 C50752.2 ; C50735.2 205.29,137.8 v4(204.96,138.13) ; v4(210.17,144.86) 210.44,144.59 C50726.2 ; v4(209.84,125.41) 210.03,125.6 C51034.2 ; C51258.2 182.23,99.14 v4(182.28,99.09) ; C51035.2 204.47,122.21 v4(204.63,122.37) ; v4(211.38,99.56) 211.56,99.39 C50953.2 ; v1(251.48,57.01) C5.2 ; v4(185.41,174.22) 185.54,174.09 C50557.2 ; v4(212.13,121.62) 212.27,121.48 C51029.2 ; C51251.2 183.92,95.22 v4(183.8,95.34) ; C50922.2 202.15,106 v4(202.2,106.05) ; C52429.2 v4(165.19,127.83) ; v4(207.23,155.7) 206.59,155.06 C50840.2 ; C50749.2 200.82,145.29 v4(201.21,145.68) ; C52481.2 v4(177.06,130.63) C52439.2 ; C53023.2 179,125.23 ; v4(181.89,138.35) 181.61,138.08 C53034.2 ; v1(213.98,163.21) 214.18,163.41 C50826.2 ; R4607.2 261.56,64.9 v1(261.25,64.59) ; 167.52,121.63 C52582.2 ; C51146.2 169.17,85.03 v1(169.02,85.19) ; C51145.2 170.25,89.1 v4(170.01,89.34) ; v4(169.44,171.22) 169.59,171.38 C50642.2 170.43,170.95 C7500.1 ; v4(210.08,104.99) 210.19,105.1 C50924.2 ; C52483.2 v4(171.36,135.5) ; v4(160.32,122.91) 160.22,123.02 R51750.1 ; 172.99,140.17 C53042.2 ; C52461.2 v4(171.45,125.73) ; v4(182.41,171.97) 182.17,172.21 C50542.2 ; C50958.2 209.44,99.26 v4(209.13,99.56) ; 176.68,139.32 C53040.2 ; R1342.1 244.95,62.58 v1(245.39,62.14) ; v4(213.28,148.71) 213.34,148.76 C50722.2 ; v1(123.24,129.49) 122.82,129.07 C4731.2 ; v1(110.88,123.87) 110.86,123.87 C4770.2 ; R51001.2 208.98,113.61 210,113.61 v1(210.07,113.54) ; v4(213.63,102.56) 213.95,102.88 C50950.2 214.4,102.65 C50946.2 ; C50854.2 202.63,164.11 v4(202.75,163.99) ; C50836.2 209.72,164.23 v4(209.48,164) ; v1(250.36,65.87) 250.19,65.87 249.86,65.54 R4881.2 ; C50550.2 182.52,175.08 v4(182.41,174.97) ; C53033.2 175.47,143.43 v4(174.95,143.95) ; R4527.2 107.17,142.56 v1(107.29,142.68) 107.35,142.61 R4531.2 ; v4(203.9,115.6) 204.16,115.35 C51057.2 ; R51751.1 161.62,118.59 161.71,118.5 v4(161.71,118.01) 161.53,117.83 C51752.1 ; C4612.1 85.71,140.51 v1(85.52,140.32) ; v4(162.32,121.55) 162.53,121.34 R51900.1 ; C52553.2 172.95,134.02 v4(172.83,134.13) 172.75,134.05 C52403.2 ; C51140.2 178.12,94.84 R51101.2 177.59,94.66 v4(177.52,94.59) ; C51144.2 166.86,88.44 v4(167.01,88.59) ; v1(234.64,26.65) 234.16,26.65 232.29,24.78 U300.4 ; 178.91,133.15 C50111.2 178.58,132.83 v4(178.47,132.72) ; D7500.9 303.16,32.66 v1(303.53,33.02) ; v4(173.6,98) 173.63,98 174.04,97.59 C51129.2 ; C51254.2 181.13,90.52 v4(181.44,90.83) ; C52565.2 v4(167.95,136.93) C52404.2 ; v4(154.36,127.55) 154.65,127.25 154.65,126.99 R51615.1 ; v1(91.21,126.95) 91.21,126.98 91.41,127.18 91.73,127.18 C4631.2 ; R4605.2 261.34,62.56 v1(261.39,62.61) ; C50934.2 204.52,107.7 v4(204.63,107.81) ; v1(110.91,62.89) 111.52,62.28 C4147.2 ; C53005.2 163.39,141.22 v4(163.22,141.05) ; v4(171.44,132.07) 171.62,132.25 C52550.2 ; C53029.2 174.26,141.99 v4(174.47,141.79) ; C50074.2 156.29,131.58 v4(156.06,131.34) 156.42,130.98 C50070.2 ; C50081.2 160.01,129.66 v4(160.27,129.92) ; C4668.2 93.35,137.75 v1(93.19,137.91) ; C55300.1 199.69,170.31 v1(199.86,170.48) ; C51123.2 167.75,90.1 v4(167.75,90.1) ; C66413.2 78.38,168.93 v1(77.8,169.52) ; 168.66,140.54 C53009.2 ; 178.94,138.11 C50200.2 ; v4(209.89,99.5) 210.09,99.31 C50937.2 ; C51259.2 181.39,88.46 v4(181.53,88.59) ; C52311.2 C52312.2 161.69,122.19 v4(161.65,122.23) C52551.2 ; C51027.2 204.95,125.69 v4(204.63,125.37) ; 178.67,124.3 C53014.2 ; v4(174.52,86.29) 174.44,86.21 174.44,85.73 C51148.2 ; 174.37,131.93 C52546.2 v4(174.24,131.38) C52559.2 ; v4(209.9,110.08) 209.99,110.17 C50935.2 ; C4167.2 83.82,124.93 R4145.2 83.82,124.93 84.61,124.93 v1(84.63,124.94) ; C52579.2 173.29,132.16 C52622.2 ; C52510.2 v4(175.65,126.43) C52549.2 ; v4(189.8,91.59) 189.55,91.84 C51253.2 ; v4(180.31,141.84) 180.35,141.8 R52200.2 C52200.2 ; v4(163.9,118.55) 164.08,118.73 C51900.1 ; C4866.2 247.45,57.81 v1(247.22,57.58) 246.99,57.81 C4843.2 ; C50926.2 210.84,102.77 v4(210.63,102.56) ; v4(167.96,136.23) C52465.2 ; v4(167.96,136.23) C52578.2 ; v4(167.96,136.23) C52417.2 ; C52457.2 v4(169.35,134.13) ; C52545.2 v4(170.75,123.63) C52558.2 ; v4(200.48,161.71) 200.23,161.47 C50847.2 ; C51616.2 155.39,125.61 v4(155.34,125.66) ; C52466.2 v4(175.65,136.23) C52437.2 ; v4(212.88,99.56) 213.03,99.41 C50954.2 ; C4864.2 250.06,49.74 249.95,49.86 C4868.2 249.09,49.86 248.76,49.53 v1(248.76,49.41) 248.64,49.41 248.35,49.11 C4853.2 247.87,49.11 247.55,48.79 C4867.2 ; C51131.2 166.74,92.14 v4(166.94,92.34) ; v4(167.16,170.47) 167.14,170.49 C50652.2 ; C50400.2 175.35,121.07 ; C52539.2 v4(172.88,129.22) C52407.2 ; C52463.2 C52476.2 170.62,134.83 ; v4(200.13,117.87) 199.96,118.04 C51047.2 ; C52428.2 v4(172.13,137.62) ; C9.2 253.67,55.2 253.69,55.17 254.14,55.17 C4869.2 254.28,55.11 254.86,54.54 254.86,54.36 254.86,54.36 v1(254.86,54.33) ; C53018.2 172.62,140.66 ; v4(204.98,163.96) 205.11,164.09 C50860.2 ; 175.76,139.32 C53039.2 ; C52544.2 v4(169.37,132) ; v4(177.56,87.04) 177.61,86.98 C51154.2 ; C50075.2 156.1,133.38 v4(156.06,133.41) ; C7.2 253.03,57.05 v1(253.34,57.05) ; v4(213.63,100.31) 213.76,100.18 C50952.2 ; C51242.2 192.66,89.92 192.3,89.92 v4(192.09,90.13) ; 168.06,140.54 C53010.2 ; v4(167.95,126.43) C52475.2 ; v4(167.95,126.43) C52541.2 ; v4(167.95,126.43) C52489.2 C52503.2 ; v1(89.75,135.54) 89.86,135.54 90.33,135.07 C4660.2 ; C52527.2 v4(174.22,134.83) C52540.2 ; C50100.2 164.58,140.17 ; C50660.2 159.54,175.09 v4(159.66,174.97) ; v1(257.46,67.67) 257.46,67.5 258.01,66.96 R4604.2 ; C52562.2 178.34,136.27 ; 173.91,139.85 C53043.2 ; C51153.2 169.27,90.82 v4(169.26,90.84) ; C52537.2 171.56,132.85 v4(171.45,132.73) ; C50536.2 185.58,165.05 v4(185.42,165.21) ; 171.1,140.33 C53007.2 ; C51135.2 169.3,95.38 v4(169.27,95.35) ; v4(181.52,90.09) 181.29,89.85 C51243.2 ; v1(304.67,19.74) 304.67,19.67 304.59,19.59 D7505.8 D7505.3 ; C52547.2 v4(175.65,132.73) C52520.2 ; C52438.2 v4(175.59,127.82) C52431.2 ; C50636.2 161.65,165.72 v4(161.16,165.22) ; C51157.2 167.63,86.21 v4(167.76,86.34) ; C50761.2 208.18,137.91 v4(207.98,138.1) ; v1(123.82,143.33) 123.82,143.34 C4790.2 ; v4(212.93,110.11) 212.99,110.17 C50941.2 ; C50080.2 156.52,130.07 v4(156.78,129.81) ; v4(158.44,140.06) 158.64,140.26 C50050.2 ; C4656.2 89.69,132.42 v1(89.1,132.42) ; C50723.2 203.15,144.15 202.62,144.68 v4(202.37,144.68) 202.35,144.66 C50743.2 ; C50553.2 185.53,163.6 v4(185.41,163.72) ; v4(213.98,147.91) 214.08,148.01 C50762.2 ; v4(208.38,123.12) 208.14,122.88 C51056.2 ; v4(204.96,138.92) 204.96,138.98 205.4,139.42 C50739.2 ; C50055.2 156.44,135.13 v4(155.98,135.59) ; C52492.2 v4(167.95,134.83) ; C50842.2 207.51,163.51 v4(207.22,163.22) ; C50054.2 160.09,138.53 v4(160.27,138.35) ; v1(123.23,136.58) 123.22,136.59 123.07,136.74 C4730.2 ; v4(209.5,148.64) 209.47,148.67 C50737.2 ; C8.2 249.86,54.53 v1(250.02,54.37) ; C51061.2 201.92,121.72 v4(202.27,121.38) ; v4(170.78,97.61) 171.06,97.89 C51155.2 ; v4(204.98,146.41) 205,146.39 C50733.2 ; v1(256.21,59.93) 256.26,59.98 C4870.2 ; C50949.2 213.8,106.96 v4(213.69,107.07) ; 179.58,136.13 C53000.2 ; C53041.2 177.6,139.64 ; v4(165.17,129.23) 165.12,129.29 C52498.2 ; C52531.2 v4(169.38,132.73) ; v1(209.47,150) 209.04,150.44 208.45,150.44 R50700.2 ; C51024.2 212.98,125.53 v4(212.88,125.43) ; v4(206.92,117.12) 206.26,116.46 C51058.2 ; C50730.2 204.16,138.08 v4(204.23,138.16) ; C50547.2 178.13,161.95 v4(177.88,162.2) ; 165.26,122.27 C52416.2 ; v4(175.65,129.94) C52509.2 ; v4(175.65,129.94) C52572.2 ; v4(175.65,129.94) C52459.2 ; v4(175.65,129.94) C52496.2 ; v4(213.63,109.31) 213.83,109.51 C50942.2 ; C51158.2 177.63,88.47 v4(177.52,88.57) ; C60610.2 215.46,24.1 v5(215.26,23.9) ; v4(203.16,159.95) 202.98,159.76 202.51,159.76 202.2,160.07 C50859.2 ; C4775.2 88.45,125.53 88.45,126.09 v1(88.46,126.1) ; C4786.2 89.37,126.36 v1(89.11,126.1) ; C7503.1 180.9,97.62 C51245.2 181.43,97.64 v4(181.5,97.56) ; R4521.2 118.58,142.04 v1(118.3,142.04) ; R51100.2 177.9,90.51 v4(177.57,90.84) ; v4(177.06,125.73) C52577.2 ; v4(177.06,125.73) C52564.2 ; v4(177.06,125.73) C52548.2 ; v4(177.06,125.73) C52535.2 ; C51142.2 166.55,94.93 v4(166.99,95.36) 166.76,95.59 166.47,95.59 C51143.2 ; C51804.2 160.14,125.62 v4(160.26,125.74) ; v4(160.27,125.05) 160.24,125.02 C51803.2 ; v4(200.88,110.07) 200.71,110.25 C50944.2 ; C4829.2 254.44,51.78 v1(254.74,52.07) ; v4(210.23,153.44) 210.37,153.3 C50856.2 ; C50849.2 214.07,156.51 v1(214.28,156.71) 214.4,156.59 C50846.2 ; C4726.2 91.17,126.36 v1(91.7,125.82) 92.1,126.23 C4630.2 ; C51162.2 169.5,87.33 v4(169.26,87.09) ; v4(160.25,127.13) 160.2,127.17 C51800.2 159.6,127.19 C51732.2 158.72,127.12 158.39,126.79 C51733.2 158.39,125.94 C51601.2 158.36,125.5 158.34,125.48 v4(158.34,125.46) 158.34,125.41 158.41,125.33 C51602.2 C51612.2 C51720.2 ; C52618.2 166.2,128.53 v4(166.55,128.53) C52408.2 ; v1(84.26,135.81) R4519.2 ; C51234.2 181.41,86.91 v4(181.52,87.02) ; 171.7,140.33 C53017.2 ; C52500.2 v4(172.83,136.2) ; v4(172.83,136.2) C52455.2 ; v4(172.83,136.2) C52469.2 ; C51801.2 159.95,123.82 160.26,124.12 v4(160.26,124.35) 160.19,124.42 C51802.2 ; v4(213.92,104.01) 213.9,103.99 C50957.2 ; C52406.2 v4(174.24,127.11) C52444.2 ; C52322.2 160.09,119.33 v4(160.19,119.44) 160.19,119.89 C52321.2 ; R50900.2 208.02,111.47 v1(207.94,111.55) ; C50961.2 202.23,110.22 v4(202.38,110.07) ; 179.04,127.45 C53022.2 ; C52471.2 v4(177.06,124.33) ; C50727.2 206.29,145.13 v4(206.54,144.88) ; R4529.2 86.35,135.21 v1(85.7,135.86) ; C51304.2 157.67,128.96 v4(157.35,129.28) ; v4(160.25,131.33) 160.11,131.46 C50084.2 ; C50848.2 201.85,157.56 v4(201.99,157.42) ; C52567.2 v4(169.35,125.03) C52519.2 ; v4(156.71,135.57) 156.52,135.76 C50036.2 C50037.2 156.52,137.24 C50035.2 156.49,137.27 v4(156.09,137.67) 156.34,137.93 C50057.2 ; C51126.2 171.4,89.93 v4(171.21,89.93) ; v4(203.89,110.11) 203.78,110.22 C50956.2 203.78,111.5 C50915.1 ; C51147.2 174.28,99.36 v4(174.55,99.1) ; C52468.2 178.34,132.67 ; v1(118.3,140.74) 118.35,140.69 C4779.2 ; C52445.2 v4(169.35,130.63) ; v4(169.35,130.63) C52570.2 ; v4(169.35,130.63) C52583.2 ; v4(169.35,130.63) C52432.2 ; C52538.2 v4(163.05,122.93) ; v1(109.04,76.93) 109.66,76.93 109.95,76.63 C4120.2 ; C50645.2 162.02,172.08 v4(161.91,171.97) ; v4(204.98,155.71) 205,155.73 C50852.2 ; C4165.2 87.06,123.85 v1(87.16,123.74) ; C50032.2 156.59,138.93 v4(156.75,139.08) ; C50073.2 157.72,129.74 157.51,129.74 v4(157.38,129.87) 157.68,130.18 C50072.2 ; v4(170.75,139.03) C52401.2 171.22,139.17 ; C50658.2 161.3,166.85 v4(161.18,166.74) ; C52430.2 v4(169.35,135.53) C52443.2 ; C4855.2 C4850.2 239.99,55.16 v1(239.23,54.4) ; v1(123.24,132.62) 123.22,132.59 122.91,132.59 C4733.2 ; C53045.2 174.83,140.17 ; v4(164.48,120.3) 164.08,119.9 C51901.1 ; 178.94,122.73 C53031.2 ; v4(209.13,110.12) 209.24,110.23 C50945.2 ; v4(159.58,139.74) 159.76,139.57 C50033.2 ; C52502.2 v4(166.55,132.73) ; v1(91.61,167.85) 91.59,167.85 91.56,167.82 C66113.2 ; C53037.2 179.58,130.55 ; C52426.2 178.34,131.19 ; 179.02,137.66 C53035.2 ; C52568.2 v4(167.95,129.93) C52460.2 ; v4(210.98,160.96) 211.17,160.78 C50831.2 ; C52488.2 v4(167.95,133.43) ; C52506.2 v4(166.55,134.13) ; v4(204.62,101.83) 204.6,101.84 C50940.2 ; v4(204.97,140.42) 204.95,140.44 C50759.2 ; C50056.2 156.47,134.38 156.51,134.34 156.51,134.29 156.69,134.11 v4(156.69,134.09) ; C50657.2 158.68,170.28 v4(158.87,170.47) ; C52413.2 178.34,131.47 ; 179.26,137.06 C53032.2 ; C4729.2 126,136.41 v1(125.83,136.58) ; v4(192.12,87.09) 192.3,86.91 C51227.2 ; v4(201.95,141.92) 201.82,142.05 C50760.2 ; C50031.2 C50030.2 157.47,134.09 v4(157.23,134.09) ; C53003.2 179.62,134.94 ; C51302.2 157.55,118.61 157.93,118.24 v4(158.19,118.24) 158.16,118.27 C51303.2 ; v1(123.24,125.53) 123.31,125.46 C4773.2 ; C53001.2 v4(181.22,132.01) ; v1(123.19,140.49) 123.4,140.7 123.4,140.7 123.77,141.08 C4780.2 ; C51043.2 211.14,114.61 v4(211.38,114.85) ; v4(189.05,92.34) 188.64,91.93 C51241.2 ; C52560.2 v4(177.06,132.03) C52482.2 ; C52454.2 v4(177.06,133.43) C52534.2 ; C51228.2 189.65,94.7 v4(189.78,94.56) ; C4783.2 121.01,135 v1(121.15,135) ; v4(166.41,172.72) 166.23,172.55 C50656.2 ; C4830.2 255.28,57.35 255.24,57.31 v1(255.24,57.3) ; C50659.2 167.11,166.02 v4(167.16,165.97) ; v4(200.13,109.31) 199.96,109.49 C50933.2 ; v4(207.63,122.37) 208.04,121.96 C51042.2 ; C51730.2 156.01,128.56 v4(156.02,128.57) ; 178.47,123.66 C50300.2 ; v4(211.36,125.42) 211.48,125.54 C51060.2 ; v4(205.35,114.14) 206.06,113.43 R51000.2 ; 165.29,126.14 C52470.2 ; C50523.2 185.51,162.15 v4(185.44,162.22) ; C50951.2 211.49,110.17 v4(211.41,110.09) ; C52301.2 160.01,121.92 v4(160.31,122.22) ; C52436.2 v4(169.37,128.52) C52487.2 ; C52501.2 v4(167.95,127.83) ; v4(167.95,127.83) C52447.2 ; v4(167.95,127.83) 167.89,127.77 167.89,127.71 C52462.2 ; v4(209.48,138.16) 209.63,138.01 C50725.2 ; 180.84,118.57 v4(180.92,118.65) ; C52411.2 v4(175.65,137.63) C52458.2 ; v4(170.76,87.84) 170.92,87.68 C51136.2 ; C51256.2 188.49,89.9 v4(189.05,89.34) ; C4815.2 242.32,54.56 v1(242.69,54.18) ; v4(211.73,153.44) 211.76,153.41 C50833.2 ; C52449.2 C52435.2 v4(170.75,136.93) C52441.2 ; 175.68,121.06 C53013.2 ; C52561.2 178.34,124.87 ; C51130.2 174.19,91.27 v4(174.51,91.59) ; v4(157.45,127.16) 157.58,127.29 C51731.2 ; v4(200.86,107.08) 200.61,106.83 C50948.2 ; C52420.2 v4(174.24,125.73) C52513.2 ; 170.87,120.83 C53011.2 ; C4871.2 251.8,50.26 v1(251.58,50.47) ; v4(185.31,96.08) 185.38,96.01 C51235.2 ; v4(165.87,123.68) 165.87,123.51 165.58,123.23 C52402.2 165.26,122.87 ; R50801.2 209.12,152.08 v4(208.52,152.69) ; v1(307.18,23.18) 307,22.99 R2509.2 ; C51301.2 176.38,141.95 176.83,141.5 R52212.2 176.89,141.12 v1(177.06,140.95) 177.64,140.95 R52211.2 ; v1(260.1,60.4) 259.99,60.3 259.48,60.3 C4827.2 ; v4(211.38,117.87) 211.46,117.95 C51022.2 ; C52542.2 v4(167.95,131.33) C52529.2 ; C51224.2 188.15,87.58 v4(188.23,87.66) ; v1(118.3,141.39) 118.5,141.58 C4778.2 ; v4(204.97,153.41) 204.66,153.1 C50862.2 ; v4(168.66,175.13) 168.78,175.25 C50661.2 ; C52552.2 v4(171.43,128.51) ; C52450.2 v4(170.75,127.83) C52464.2 ; C52486.2 v4(174.24,136.93) C52424.2 ; v4(200.48,156.46) 200.44,156.43 C50816.2 ; v1(186.45,166.73) 186.88,167.16 R50510.1 ; C50855.2 204.11,164.09 v4(204.23,163.96) ; C4785.2 87.24,138.02 v1(87.15,137.93) ; C50750.2 200.36,141.28 v4(200.48,141.16) ; v4(200.13,102.56) 200.01,102.68 C50947.2 ; C52504.2 170.62,133.95 ; C50930.2 201.47,103.49 v4(201.64,103.32) ; v4(161.17,168.95) 161.64,169.42 C50633.2 ; v4(192.1,88.61) 192.26,88.46 C51255.2 ; R50800.2 206.51,151.95 205.92,152.54 v4(205.92,152.55) 205.56,152.91 C50825.2 ; C51161.2 176.86,86.24 v4(176.76,86.34) ; v4(212.69,144.8) 212.73,144.77 C50757.2 ; C60230.2 246.42,20.92 C60209.2 v1(246.91,20.3) ; C50092.2 159.61,135.59 159.78,135.76 C50034.2 160.14,136.12 v4(160.25,136.23) 159.76,136.72 C50051.2 ; v4(170.01,99.84) 170.5,100.33 C51150.2 ; C51062.2 209.12,117.13 v4(209.13,117.12) ; v4(209.13,159.87) 209.53,160.27 C50845.2 ; C4680.2 90.94,132.8 v1(91.31,132.8) ; C50962.2 203.71,99.39 v4(203.88,99.56) ; C50729.2 204.13,148.89 v4(204.31,148.72) ; C52472.2 v4(173.55,138.33) ; C52507.2 v4(175.66,134.83) C52493.2 ; C4782.2 122.51,140.73 v1(122.24,140.73) 122.24,140.16 C4787.2 ; v4(191.3,86.34) 191.48,86.17 C51222.2 ; 167.13,140.86 C53004.2 ; R2508.2 303.97,24.83 v1(304.36,25.23) ; C4851.2 251.58,53.01 v1(251.58,52.02) 251.89,51.71 252.25,51.71 C4872.2 ; C50929.2 203.73,106.03 v4(203.79,106.09) ; C52556.2 167.5,123.14 167.5,122.56 C52569.2 167.84,122.55 ; C52556.2 C52543.2 C52530.2 ; C52556.2 167.84,123.15 ; v4(164.49,117.32) 164.52,117.28 R51903.1 ; C51040.2 203.85,118.63 v4(203.88,118.6) ; C52410.2 v4(170.73,129.92) ; C50654.2 158.7,171.36 v4(158.87,171.18) ; R4528.2 88,130.64 v1(87.81,130.83) ; C52409.2 v4(169.41,138.33) ; C51036.2 204.64,117.13 v4(204.63,117.12) ; v4(200.88,99.56) 200.81,99.49 C50928.2 ; C52523.2 v4(172.84,129.89) C52526.2 ; C50647.2 164.92,161.85 164.69,162.08 164.69,162.72 164.94,162.97 C50639.2 165.65,162.97 v4(165.66,162.98) ; C52575.2 v4(177.06,135.54) C52479.2 ; v4(204.99,148.67) 205.13,148.82 C50756.2 ; 164.19,125.85 C52517.2 v4(163.75,125.73) ; v4(206.12,101.06) 205.97,100.92 C50923.2 ; C52415.2 v4(172.15,138.33) ; C50090.2 v4(160.25,132.73) 160.25,132.65 159.77,132.18 C50071.2 ; 174.7,125.28 C52584.2 ; v4(170.01,86.34) 169.9,86.23 C51149.2 ; C52102.1 157.88,122.23 v4(157.46,122.23) ; C52514.2 v4(174.24,135.53) C52451.2 ; C53016.2 176.93,121.06 ; C4865.2 247.67,55.87 v1(247.7,55.9) ; v4(192.09,90.84) 192.2,90.96 192.67,90.96 C51261.2 ; C67409.2 199.51,175.38 U67400.18 v1(197.01,175.38) ; v1(243.42,66.48) 243.44,66.49 R4892.1 ; C51225.2 185.53,98.37 v4(185.39,98.51) ; v1(256.72,63.37) 257.4,64.06 257.4,64.65 257.45,64.69 R4602.1 ; v4(209.48,155.71) 209.47,155.73 C50834.2 ; C60262.2 64.79,80.03 v5(64.89,79.93) ; v1(250.21,59.97) 250.07,60.12 C4.2 ; C52524.2 v4(172.83,133.43) C52566.2 ; 175.15,139.64 C51306.2 ; v4(167.01,96.84) 166.81,96.64 C51137.2 ; 174.37,132.21 C52533.2 ; C52491.2 v4(170.75,126.43) ; v4(202.38,99.56) 202.26,99.44 C50932.2 ; 177.95,139.62 C53046.2 ; v4(184.69,148.14) 184.69,148.93 184.51,149.11 184.51,151.42 185.62,152.52 R52231.1 ; C51600.2 156.05,127.14 v4(156.03,127.12) ; C50640.2 158.77,165.84 v4(158.91,165.97) ; v4(167.01,87.09) 166.91,86.99 C51141.2 ; 214.35,155.04 v1(214.3,154.99) ; v4(169.43,172.72) 169.49,172.78 C50625.2 ; 169.26,140.47 C50110.2 ; v4(158.84,174.22) 158.74,174.33 C50628.2 ; 171.56,134.65 C52497.2 ; C52446.2 v4(172.85,126.43) C52419.2 ; R50901.2 205.55,110.24 v4(205.38,110.07) ; v4(161.91,163.72) 162.06,163.57 C50651.2 162.68,163.57 162.94,163.32 162.94,162.63 162.76,162.45 C50650.2 ; C53002.2 v4(181.23,133.45) ; v4(204.65,114.85) 204.87,114.64 C51045.2 ; v4(212.48,160.21) 212.55,160.15 C50844.2 ; C53015.2 178.42,120.42 ; v4(189.05,86.19) 188.92,86.05 C51250.2 ; v4(201.65,118.64) 201.86,118.85 202.36,118.85 C51052.2 ; 179.58,129.3 C53038.2 ; 179.07,133.98 C53019.2 ; v4(168.51,93.86) 168.37,94 C51132.2 ; C51032.2 202.02,114.43 v4(202.41,114.82) 202.65,114.58 C51055.2 ; C52522.2 178.34,126.67 ; C4541.2 131.74,137.57 132.32,137.57 v5(132.75,138) ; v1(251.54,59.87) 251.31,60.1 R4854.1 ; U7003.11 U7003.15 ; C4562.2 120.23,127.28 R4522.2 120.65,125.71 C4508.2 120.47,125.17 v1(120.04,125.17) ; C52499.2 v4(172.88,127.81) C52485.2 ; v4(213.63,124.62) 213.78,124.77 C51051.2 ; v4(207.98,160.96) 208.24,161.22 C50829.2 ; C52480.2 v4(177.06,128.53) C52425.2 ; v1(199.92,169.07) 199.67,169.31 C55301.1 ; C50925.2 212.5,106.05 v4(212.37,106.19) ; C52530.2 167.93,124.35 v4(167.95,124.33) C52580.2 ; C52530.2 C52448.2 ; C52557.2 v4(170.75,131.33) ; C50758.2 201.06,148.84 v4(201.23,148.67) ; C53025.2 182.62,139.1 v4(182.67,139.05) ; C52576.2 v4(172.83,131.37) C52563.2 ; C52490.2 170.62,134.55 ; C50943.2 204.87,99.8 v4(204.61,99.54) ; v1(87.16,126.1) 87.02,126.24 C4663.2 ; v1(206.48,149.87) 206.88,150.27 R50701.2 ; C52474.2 v4(174.24,128.5) C52418.2 ; C50830.2 200.69,153.64 v4(201.23,154.19) ; C50053.2 159.94,137.93 v4(160.25,137.63) 159.95,137.33 C50052.2 ; 173.79,125.29 C52433.2 ; v4(166.58,123.62) 166.13,123.62 C52614.2 ; C50853.2 204.21,157.22 v4(204.24,157.19) ; v4(211.52,118.99) 211.71,119.18 C51054.2 ; v4(202.73,148.67) 202.58,148.81 C50731.2 ; C4705.2 251.38,46.75 v1(251.37,46.76) ; C52555.2 v4(166.55,130.63) ; v4(210.19,164) 210.19,164.4 C50858.2 ; v4(209.48,140.41) 209.5,140.42 C50734.2 ; v4(174.51,89.34) 174.03,89.82 C51159.2 ; C50850.2 214.05,160.9 v1(213.98,160.96) ; C52518.2 170.62,133.35 ; C50936.2 v4(207.67,101.78) ; C52427.2 178.34,134.47 ; v4(167.01,98.34) 166.94,98.41 166.58,98.41 C51128.2 ; U2501.14 v1(285.41,34.07) ; C52532.2 v4(170.72,124.33) ; R51721.1 155.48,123.77 v4(155.3,123.58) ; C50927.2 208.7,106.74 v4(208.38,107.06) ; C50843.2 211.95,157 v4(211.5,157.45) 211.06,157.89 C50851.2 ; C50082.2 159.94,130.26 v4(160.28,130.61) 160.03,130.86 C50083.2 ; C51262.2 180.7,94.56 v1(180.63,94.63) 180.35,94.91 R51200.2 ; C51125.2 173.56,87.72 v4(173.67,87.61) 173.58,87.52 C51122.2 ; 164,141.2 C53030.2 ; 170.3,122.23 C52571.2 ; v4(175.26,95.34) 175.25,95.33 174.82,95.33 C51151.2 ; v1(258.54,61.01) 258.61,61.01 258.87,61.27 C4813.2 ; C50644.2 158.57,164.05 v4(158.88,163.74) 158.58,163.44 C50662.2 ; v4(209.13,101.81) 209.15,101.83 C50939.2 ; C52554.2 v4(169.33,125.74) C52505.2 ; v4(209.13,114.77) 209.49,114.41 C51033.2 ; v4(203.88,125.37) 204.34,125.83 C51030.2 ; v4(175.52,120.6) 175.52,120.89 ; C50827.2 211.86,164.17 v4(211.71,164.02) ; 169.85,120.83 C51305.2 ; v4(184.55,99.84) 184.73,100.02 C51247.2 ; C52484.2 164.19,130.21 ; C50641.2 162.75,173.57 v4(162.66,173.47) ; C51236.2 187.94,97.29 v4(188.03,97.38) 188.31,97.66 C51244.2 ; v4(213.23,138.16) 213.1,138.02 C50732.2 ; v4(177.52,90.08) 177.81,89.79 C51124.2 ; C53036.2 179.59,125.87 ; C52515.2 v4(169.37,127.13) ; v4(169.37,127.13) C52528.2 ; v4(169.37,127.13) C52477.2 ; v4(158.86,172.7) 158.78,172.78 C50635.2 ; C52511.2 v4(165.13,125.03) ; C52302.2 159.95,121.23 v4(160.28,121.55) ; v4(210.25,148.67) 210.34,148.76 C50751.2 ; v4(161.65,123.63) C52525.2 ; C53021.2 167.45,118.49 v4(167.21,118.73) ; C4704.2 84.01,138.55 84.01,138.08 R4508.2 83.94,138.01 v1(83.94,137.39) ; C50828.2 203.05,153.12 v4(202.76,153.41) 202.43,153.08 C50835.2 ; C52495.2 178.34,127.87 ; C52516.2 v4(166.55,132.03) ; C52494.2 178.34,123.67 ; C52573.2 v4(175.65,131.33) ; v4(181.55,95.34) 181.78,95.57 C51229.2 ; C52521.2 v4(175.66,134.12) ; C50861.2 204.01,160.44 v4(204.23,160.22) ; C50753.2 211.63,138.05 v4(211.73,138.16) ; C52478.2 v4(166.55,135.53) ; 179.16,131.89 C53020.2 ; R4530.2 85.98,132.22 v1(85.79,132.41) ; C52536.2 v4(177.06,127.13) C52400.2 ; C50824.2 213.34,164.13 v4(213.23,164.03) ; v1(253.51,62.77) 253.13,63.15 R4858.1 ; PAD501.1 v1(24.25,45.85) ; C52423.2 v4(170.73,129.23) ; CN301.10 213.32,31.22 213.07,31.47 v1(212.9,31.47) 212.7,31.47 212.32,31.1 CN301.8 ; C51044.2 200.3,115 v4(200.89,115.59) ; 174.1,120.98 C53012.2 ; C50558.2 185.83,166.35 v4(185.43,165.95) ; C52581.2 v4(167.95,129.23) C52473.2 ; C52422.2 v4(169.4,137.6) ; v1(307.26,10.95) U2500.2 ; C52453.2 178.34,129.67 ; v4(160.27,133.48) 160.02,133.73 C50091.2 ; C52508.2 v4(171.44,130.66) ; C53024.2 167.13,120.68 ; C50837.2 201.08,164.16 v4(201.25,163.99) ; v4(210.63,122.37) 210.63,122.37 C51031.2 ; 165.29,126.42 C52456.2 ; C52320.2 157.63,120.19 157.43,120.4 v4(157.43,120.91) 157.55,121.03 C52300.2 ; C50742.2 211.84,148.76 v4(211.76,148.68) ; C52574.2 178.34,124.27 ; 163.86,128.69 C52512.2 ; C51610.2 160.26,127.9 160.28,127.88 160.28,127.88 v4(160.3,127.86) 160.22,127.86 160.21,127.86 C51611.2 ; C52440.2 178.34,133.87 ; v1(84.46,127.51) R4149.2 ; C52421.2 178.02,137.79 ; C52442.2 v4(166.55,127.13) ; C53006.2 163.11,140.9 ; U60200.18 v1(244.89,24.24) ; C52414.2 178.34,135.07
  TOP w0.3: R50500.2 173.65,169.77 173.55,169.68 v4(173.3,169.68) ; 172.74,140.85 v4(172.82,140.85) ; v4(170.27,166.87) 170.85,167.45 R50600.2 ; v4(165.73,109.94) 165.23,110.44 v4(164.48,110.44) 163.73,110.44 v4(163.23,109.94)
  TOP w0.305: C50537.2 179.16,163.47 v4(178.85,163.78) ; C51156.2 174.09,96.39 v4(174.53,96.84) ; C51133.2 177.62,96.93 v4(177.54,96.84) ; C51049.2 213.96,118.2 v4(213.63,117.87) ; C50649.2 166.16,175.22 v4(166.41,174.97) ; C51010.1 214.74,116.77 v1(214.55,116.77) ; v4(181.64,162.98) 181.48,162.81 C50552.2 ; C51041.2 213.82,115.58 v4(213.79,115.61) ; v1(124.52,73.26) 124.52,73.94 C34.2 124.05,74.41 C4111.2 ; C50539.2 185.55,170.62 v4(185.41,170.47) ; v1(129.49,63.32) 129.74,63.08 129.74,62.7 129.15,62.11 C4144.2 C4145.2 ; v4(169.41,170.48) 169.67,170.22 170.77,170.22 R50601.2 ; C50544.2 174.54,171.59 v4(174.89,171.24) ; R51574.2 v1(150.76,92.31) 150.76,92.41 R51441.2 ; C51232.2 183.81,90.85 v4(183.8,90.84) ; R51201.2 179.95,89.61 v1(180.3,89.25) ; PAD500.1 26.79,48.88 v1(26.79,48.01) ; R50810.1 207.08,165.98 v1(207.53,166.43) ; v4(169.41,165.97) 169.19,165.75 C50653.2 ; v4(177.52,98.34) 177.58,98.4 C51127.2 ; C50626.2 169.61,163.6 v4(169.46,163.75) ; v4(192.04,96.85) 192.12,96.77 C51233.2 ; v1(130.01,66.59) 129.84,66.59 129.58,66.85 R4219.2 ; C50857.2 205.74,161.69 v4(205.75,161.7) ; C50528.2 175.48,161.3 v4(175.66,161.47) ; v4(174.9,165.28) 174.74,165.12 C50531.2 ; v1(193.24,95.02) 193.17,95.02 C51223.2 ; v4(183.79,93.08) 183.66,93.22 C51230.2 ; C51025.2 208.82,121.31 v4(208.78,121.28) ; C51246.2 184.12,85.13 v1(184.08,85.17) ; v1(148.83,97.87) 148.45,98.25 R51571.2 ; v4(178.66,173.47) 178.75,173.57 C50530.2 ; v4(174.85,170.47) 174.85,170.58 174.46,170.97 C50522.2 ; v4(161.91,174.97) 162.05,175.12 C50648.2 ; C524.2 v1(26.68,46.69) ; C51226.2 182.23,85.67 182.23,86.12 v4(182.3,86.19) ; C50754.2 214.1,138.79 v4(213.98,138.91) ; C50546.2 v1(183.36,176.28) ; C51050.2 200.25,123.01 v4(200.13,123.12) ; v4(184.66,174.97) 184.79,175.1 C50555.2 ; R51439.2 151.13,90.53 v1(150.76,90.53) R51435.2 ; C50545.2 177.99,171.91 v4(177.93,171.97) ; R51431.2 147.43,93.33 147.88,93.78 v1(148.15,93.78) ; v4(174.86,174.27) 174.8,174.33 C50524.2 ; R50910.1 v4(208.38,100.31) ; C50554.2 183.12,165.94 v4(183.14,165.96) ; v1(188.34,100.66) 188.49,100.51 C51249.2 ; PAD502.1 v1(13.66,45.75) ; Q51592.4 155.99,87.97 156.46,88.45 156.46,89.97 v1(156.59,90.1) 156.65,90.16 R51570.2 ; C50747.2 214.18,145.85 v4(213.98,145.66) ; R51573.2 150.71,91.42 v1(150.76,91.37) 150.78,91.37 151.13,91.72 R51437.2 ; C4170.2 127.55,62.4 127.88,62.74 127.88,63.41 v1(127.86,63.43) ; v4(167.91,161.47) 168.23,161.15 C50643.2 ; v1(193.8,96.9) 193.76,96.9 C51215.1 ; C51257.2 192.34,98.05 v4(192.05,98.34) 192.39,98.68 C51238.2 ; C51240.2 191.3,100.22 v4(191.3,99.84) ; C52452.2 v4(177.06,136.93) C52434.2 ; C50556.2 185.64,168.72 185.87,168.95 185.87,169.22 v4(186.1,169.45) ; R60.2 144.53,76.13 144.43,76.02 v1(144.41,76.02) ; C4153.2 v1(126.4,64.71) ; v4(178.87,165.09) C50538.2 ; R51433.2 150.36,97.4 v1(150.36,96.75) ; v4(170.77,98.33) 170.94,98.5 C51139.2 ; C50561.2 175.56,175.07 v4(175.66,174.97) ; v1(154.14,89.51) Q51592.1 ; C50541.2 185.51,172.62 v4(185.41,172.72) ; C50746.2 215.08,146.41 v4(213.98,146.41) ; C52421.2 v4(178.47,137.63) ; v4(182.41,161.47) 182.29,161.35 C50548.2 ; C51046.2 214.89,117.86 214.58,117.55 214.58,117.55 v1(214.47,117.45) ; C50724.2 211.22,141.39 v4(210.98,141.16) ; v1(111.81,125.17) 111.88,125.17 112.68,125.98 C4700.2 C4701.2 ; C50525.2 178.23,170.05 v4(177.91,169.72) ; v1(214.62,114.21) 214.38,113.97 C51011.1 ; C50738.2 202.97,142.43 v4(202.53,142) ; v4(174.9,162.22) 174.72,162.05 C50532.2 ; v4(183.16,170.47) 183.14,170.49 C50533.2 ; C51248.2 184.55,86.34 v4(184.55,86.35) ; v4(174.9,163.72) 174.75,163.57 C50527.2 ; v4(174.88,172.75) 174.8,172.83 C50529.2 ; R60199.2 194.34,29.72 v1(194.76,29.72) ; R51577.2 R51575.2 v1(161.59,89.7) ; v4(210.84,142.28) 210.81,142.31 C50744.2 ; v4(165.06,171.93) 165.07,171.92 C50638.2 ; C50748.2 214.08,141.25 v4(213.98,141.16) ; v4(212.49,141.91) 212.63,142.05 C50740.2 ; C51260.2 185.14,88.32 v4(185.4,88.58) 185.11,88.86 C51237.2 ; v4(174.9,165.92) 174.7,166.12 C50560.2 ; C50646.2 166.36,176.01 v1(166.7,175.67) ; R51210.1 193.57,92.49 v1(193.86,92.79) ; v4(167.18,168.21) 167.83,167.57 C50634.2 ; v4(177.91,174.97) 177.98,175.05 177.98,175.39 178.08,175.49 C50549.2 ; v4(176.43,166.74) 176.65,166.96 C50526.2 ; v4(173.6,98) C51152.2
  TOP w0.33: v1(195.32,169.8) 195.76,169.8 U55300.5 ; v1(305.91,65.71) 305.91,66.44 305.5,66.86 D56652.3 D56652.8 ; Q51680.4 293.16,64.21 v1(292.79,64.21) ; v1(302.59,73.61) D56650.3 D56650.8 v1(305.18,73.61) ; Q51680.1 v1(294.33,66.12) ; Q56470.1 290.76,65.35 v1(291.08,65.66) ; v1(305.23,70.26) D56651.8 D56651.3 ; R56200.1 300.8,50.16 300.98,49.99 D56230.3 D56230.8 v1(303.78,49.99) ; v1(294.94,64.24) 295.13,64.05 Q51670.4 ; Q56470.4 v1(289.49,64.59) ; Q51670.1 v1(296.5,64.75)
  TOP w0.356: v1(267,20.95) 267,21.13 U1300.5
  TOP w0.381: C4150.2 115.17,63.78 115.38,63.99 v1(115.39,63.99) ; v1(133.04,50.12) 133.04,49.52 132.83,49.31 C67081.2 R67004.2 ; C509.2 14.36,62.28 v1(14.22,62.41) ; C4844.2 245.58,57.9 v1(244.99,57.9) 244.59,57.9 C4854.2 C4891.2 ; v1(194.46,163.05) 194.46,163.45 U250.GND ; v1(194.46,163.05) 194.25,162.84 C254.1 ; v1(194.46,163.05) 194.75,162.76 C253.2 ; v1(199.79,171.72) C67430.2 198.69,171.72 198.31,172.1 R67401.1 ; C7035.2 C17.2 231.8,57.91 232.76,56.95 v5(232.76,56.72) ; C66670.1 86.13,158.28 86.13,159.03 C66671.1 86.08,159.51 v1(85.87,159.72) 85.5,160.1 C66652.1 ; v5(114.63,131.96) 114.64,131.94 C4698.2 ; C7549.2 124.01,34.04 v1(123.87,33.9) ; C4689.2 120.64,134.75 120.9,134.75 v1(121.15,135) ; C4723.2 C4720.2 ; C4720.2 114.84,154.99 v1(115.22,154.61) ; C4720.2 114.84,156.58 114.39,157.03 C7513.1 114.75,157.74 C4721.2 ; C67009.2 136.71,59.14 v1(136.71,58.51) ; C4628.2 91.33,129.63 v1(91.39,129.69) 91.39,129.3 C4797.2 ; C519.2 30.92,56.11 v1(31.14,56.33) ; C4107.2 106.43,73.35 v1(106.66,73.12) ; C4684.2 107.29,133.38 ; v5(209.17,178.41) 208.58,177.82 C67401.2 ; v1(137.26,51.82) 137.27,51.81 C67082.2 R67013.2 ; R4729.2 C33.2 270.81,55.22 v1(270.53,54.94) ; 127.02,54.8 127.02,54.82 126.74,55.1 v1(126.74,55.68) ; 127.02,54.8 C67089.2 ; 127.02,54.8 R67092.2 ; C50717.2 199.5,147.91 v4(200.48,147.91) ; R50610.1 157.86,169.1 v1(157.54,168.77) ; CN301.G2 213.84,33.07 v1(213.15,33.76) ; v1(293.4,81.18) 293.72,80.86 C56404.1 ; R67231.2 243.42,80.91 v1(242.85,81.49) ; v1(149.9,63.86) 150.07,63.86 150.29,64.08 R4119.2 ; v1(195.28,20.23) 195.04,20.48 C60191.2 ; v1(271.39,47.07) C140.2 271.39,47.71 R4791.1 ; R55817.2 287.63,59.75 v1(288.01,60.13) ; v1(156.46,62.18) 156.46,63.71 156.11,64.06 C4103.2 155.94,64.44 C4138.2 ; v1(100.02,137.82) v1(100.02,137.05) 99.47,137.05 99.46,137.06 C4761.2 ; v1(100.02,137.82) v1(100.66,137.82) 100.84,137.99 C4681.2 ; v1(100.02,137.82) 99.57,138.27 C4683.2 ; C51671.2 296.85,61.24 v1(296.95,61.14) ; C2505.2 v1(281.28,34.71) ; v4(157.47,148.14) 157.44,148.11 C52632.2 ; v1(80.13,125.43) 80.09,125.43 79.66,124.99 R4152.2 79.66,124.14 79.25,123.73 C4171.2 R4155.2 ; v4(156.69,148.89) 156.15,149.43 C52633.2 C52631.2 ; C66107.1 R66107.1 89.46,162.62 v1(89.73,162.89) ; Q4.2 262.24,53.41 261.84,53.8 v1(261.84,53.85) 261.65,54.05 R4859.1 ; D501.2 29.94,56.05 v1(29.94,56.34) ; C4120.2 110.27,75.23 111.07,74.43 C4121.2 ; v1(88.46,129.26) 88.42,129.22 C4682.2 ; R51650.1 303.57,53.24 v1(304.06,53.72) ; 268.98,30.32 268.91,30.25 v1(268.91,29.49) ; 268.98,30.32 268.2,30.32 C1316.2 ; 268.98,30.32 C1319.2 ; v1(119.5,63.65) 119.55,63.6 C4151.2 ; v5(218.69,26.09) 218.79,25.99 219.59,25.99 C60600.2 ; v1(12.52,63.22) 12.73,63.02 C506.1 12.73,62.54 R503.2 ; C52001.2 161.86,116.42 v4(161.67,116.6) ; C4693.2 107.29,134.27 ; 102.59,137.74 C4746.2 ; v1(97.74,127.86) 97.74,127.19 C4661.2 ; v1(296.28,58.05) 296.51,58.28 R55818.2 ; v1(298.61,48.21) 298.36,47.96 C7552.2 ; v1(263.27,26.6) 262.93,26.26 C7547.2 ; C4659.2 93.6,129.48 ; C51048.2 213.76,122.25 v4(213.63,122.37) ; v1(83.46,107.75) 84.38,107.75 85.04,108.41 C4771.2 C4774.2 ; v1(239.3,53.14) 239.41,53.03 C4890.2 ; v1(111.39,68.36) 112.16,69.13 C4155.2 ; C4142.2 125.16,72.37 v1(124.53,72.37) 124.21,72.69 C4154.2 ; v1(211.07,21.06) 211.18,21.17 211.18,21.79 C138.2 ; C66016.2 101.09,168.24 101.09,168.89 v1(100.89,169.09) ; C56443.2 v1(290.62,81.44) ; C7699.2 v1(15.67,33) ; v1(101.75,125.82) 101.55,125.63 100.99,125.63 100.96,125.65 C4772.2 ; v1(288.95,34.75) 289.23,34.47 C2507.2 ; C4768.2 97.53,125.18 v1(97.18,125.18) ; C4694.2 113.92,136.28 ; R56202.1 304.68,48.42 v1(304.35,48.09) ; v1(97.18,126.47) 97.18,126.07 C4627.2 ; v1(122.46,66.08) 123.36,66.08 C4156.2 ; v1(23.69,63.62) C517.2 ; v1(86.18,168.46) 86.64,168.92 87.07,168.92 C66160.2 ; C4763.2 104.52,125.8 v1(104.49,125.82) ; C510.2 19.26,61.57 v1(19.38,61.45) ; v5(142.11,174.93) 141.5,174.32 C66616.2 ; 226.96,74.12 C67226.2 ; v4(159.73,146.76) 159.65,146.76 158.97,146.07 C52005.2 ; 117.4,137.74 C4697.2 ; 178.56,139.2 C50102.2 ; C67400.2 208.73,179.06 209.11,179.44 v5(209.11,179.45) ; CN301.G1 v1(207.22,33.67) ; C4690.2 107.29,131.6 ; C67080.2 127.31,53.18 v1(127.63,52.86) 127.76,52.99 R67093.2 ; C4848.2 239.92,66.6 238.75,67.76 C4847.2 C4858.2 237.11,67.76 236.62,67.28 v1(236.62,67.14) ; C4848.2 240.36,66.45 v1(240.65,66.16) ; C4848.2 C4849.2 240.5,64.98 C4892.2 ; v1(87.81,130.83) 87.42,130.83 C4629.2 ; C4769.2 97.65,123.28 97.21,123.28 v1(97.18,123.24) ; C52310.2 158.09,117.58 v4(157.61,117.11) ; C1300.2 265.58,20.53 v1(266.01,20.96) ; C4862.2 C4863.2 237.8,47.64 v1(237.08,46.92) ; v1(269.89,24.87) C1315.2 C1318.2 ; C55302.2 193.32,169.81 v1(193.47,169.96) ; v1(304.19,62.47) R56621.1 304.19,63.1 C56631.2 ; C4549.2 114.15,127.68 ; C1313.2 v1(293.77,26.72) ; v1(139.21,47.68) 139.37,47.52 C7565.2 ; C508.2 v1(16.12,63.99) ; R56200.1 v1(299.89,50.16) ; C7689.2 v1(15.67,32.11) ; C522.2 28.23,55.62 29.03,56.42 v1(29.33,56.42) ; 143.9,72.16 C4125.2 ; R67090.2 127.35,55.74 127.35,56.58 C67088.2 127.16,56.77 v1(126.75,56.77) ; v1(83.46,106.3) 84.44,106.3 C4765.2 ; v1(297,81.72) 296.91,81.63 296.37,81.63 C7551.2 ; R51010.1 207.75,126.86 v1(207.73,126.88) ; C523.2 v1(12.65,46.11) ; v1(160.58,87.67) 160.25,87.99 R52101.1 ; v1(124.55,107.8) C4764.2 ; v1(106.46,76.43) 106.46,76.31 106.43,76.29 C4115.2 ; 102.04,127.28 C4744.2 ; C7032.2 230.4,47.64 v5(230.4,47.18) ; v1(121.69,169.12) 121.99,168.82 C66036.2 ; C3004.2 29,60.89 29.16,60.73 v1(29.2,60.73) ; v1(82.52,158.52) C66100.2 ; 119.76,128.12 C4530.2 ; v1(150.21,68.5) 150.35,68.35 C4130.2 C4129.2 ; v1(111.15,137.56) 111.3,137.71 C4563.2 ; C4875.2 C4876.2 260.1,31.63 v1(259.69,31.22) ; v1(287.66,34.74) 288.16,34.24 C2508.2 ; C7562.2 v1(76.27,157.43) ; C56406.2 v1(295.42,75.09) ; C7570.2 205.38,28.82 v5(205.38,28.19) ; v1(305.69,59.67) 305.94,59.41 C7580.1 ; C532.2 23.42,50.51 v1(23.42,49.84) ; R51753.1 157.08,94.04 v1(157.27,94.24) ; C503.1 21.18,50.17 v1(21.55,49.8) ; C56442.2 v1(291.51,81.49) ; 118.33,137.08 C4516.2 C4517.2 C4534.2 118.33,134.85 C4711.2 C4685.2 v1(118.89,133.07) ; v1(286.23,67.75) 286.56,68.08 C56421.1 286.64,68.28 R56433.1 ; v1(156.46,61.57) 156.16,61.57 155.56,62.16 C4101.2 C4102.2 ; v5(167.64,77.37) 167.54,77.28 167.54,76.74 C7567.2 ; C1314.2 v1(293.77,27.61) ; C52004.2 155.21,141.17 155.21,140.47 v4(155.3,140.38) ; 93.58,135.6 C4688.2 ; v1(110.56,137.56) 110.41,137.71 C4808.2 ; v1(148.29,63.24) 148.97,63.91 R4217.2 ; v1(212.77,24.04) R60601.1 ; v4(204.61,110.1) 204.61,110.63 C7502.1 ; R1301.1 272.59,22.51 v1(273.12,21.97) ; C4776.2 85.06,121.82 v1(84.43,122.46) ; C1301.2 v1(269.38,21.27) ; C50038.2 148.54,167.3 ; v5(310.28,7.38) 310.28,7.42 310.42,7.56 C2548.2 ; C4715.2 116.35,134.58 C4525.2 C4520.2 C4521.2 116.09,137.05 ; 226.5,53.16 C7037.2 ; R2552.2 R2551.2 280.39,32.87 v1(280.58,32.68) ; 112.65,137.74 C4758.2 ; C4114.2 114.83,76.27 115.54,76.98 v1(115.58,76.98) 115.9,76.66 C4123.2 ; C1312.2 293.64,29.15 v1(293.27,29.52) ; C66198.2 83.06,172.62 82.65,173.04 82.02,173.04 v1(81.78,172.8) ; C4695.2 113.91,128.11 ; C56422.1 283.82,67.25 v1(284.02,67.04) ; C4732.2 123.95,109.02 124.49,108.48 v1(124.55,108.48) ; C564001.2 282.78,75.87 v1(282.77,75.85) ; C50714.1 209.61,135.24 v1(210.13,135.77) ; C4667.2 105,127.65 ; C4669.2 v1(118.89,132.19) ; C4556.2 109.42,127.67 ; C50718.2 201.1,150.38 C7501.1 ; C4562.2 119.81,127.67 ; R51640.2 298.76,61.44 299.24,61.92 v1(299.62,61.92) ; 110.18,128.12 C4526.2 ; C66026.2 111.55,168.82 v1(111.25,169.12) ; C4141.2 C4146.2 124.37,61.28 123.58,62.06 v1(123.58,62.86) ; C4760.2 97.73,137.06 v1(97.74,137.05) ; C51111.1 165.4,88.6 v1(165.27,88.73) ; v1(22.17,64.14) 22.12,64.19 21.58,64.19 21.58,64.19 C18.2 ; C7566.2 208.6,75.99 v5(209.01,76.41) ; v1(81.73,172.19) 81.91,172.02 R66197.2 C66197.2 ; v1(251.33,25.94) 251.33,26.97 C60216.2 ; R4836.1 271.77,50.02 v1(271.77,49.46) 271.75,49.48 R4787.1 ; C4657.2 100.96,126.92 ; 105.18,128.12 C4522.2 ; C1310.2 272.13,29.9 v1(272.78,30.55) ; C4149.2 115.95,66.69 v1(116.02,66.63) ; 108.42,137.1 C4692.2 ; v4(201.65,118.64) 201.49,118.79 C51012.1 ; C7560.2 238.37,30.35 v1(238.32,30.31) ; v1(230.15,53.52) 231.21,53.52 C7038.2 ; C50039.2 156.22,140.51 v4(156.1,140.38) ; v1(289.84,62.37) R55815.2 R55816.2 ; C66109.2 85.32,171.63 85.54,171.63 85.67,171.76 v1(85.75,171.76) 86.03,171.48 C66199.2 ; v1(82.78,133.97) 82.78,133.78 82.58,133.58 R4534.2 82.58,132.95 R4523.2 ; v1(210.72,119.42) 210.59,119.29 C51053.2 ; C521.2 27.1,61.04 27.38,60.76 v1(27.68,60.76) ; v1(105.05,137.57) 104.98,137.5 C4532.2 C4528.2 C4710.2 ; C4152.2 122.07,65.07 v1(122.07,63.87) ; C56402.2 C56400.2 283.33,70.11 283.66,70.43 v1(283.66,70.43) ; C7602.2 v1(26.22,31.37) 25.56,30.72 D7602.1 ; C3009.2 25.22,64.3 C3010.2 24.69,63.63 v5(24.48,63.43) ; v1(288.37,65.62) R56470.1 ; C7600.2 v1(24.88,33.6) ; v1(30.3,31.3) 30.49,31.49 D7601.1 ; v1(242.94,55.78) 243.14,55.99 C4860.2 ; 148.17,165.94 C50058.2 ; R4211.2 125.74,75.7 v1(125.37,76.07) ; v1(97.59,137.88) 97.69,137.98 C4658.2 ; C56409.2 v1(295.49,71) ; C7034.2 228.14,47.37 v1(228.09,47.32) 228.09,47.22 227.66,46.79 226.86,46.79 Q9.1 ; v5(233.38,56.11) 232.93,55.65 C2990.2 ; C1317.2 v1(269.38,22.56) ; R60205.1 238.77,19.87 v1(238.54,20.09) ; C7601.2 v1(27.11,33.94) ; v1(282.09,34.71) 282.17,34.64 C2506.2 ; v1(294.64,72.69) C56407.2 ; C56408.2 v1(292.38,69.63) 292.38,69.95 292.38,69.96 R56412.1 ; C4300.2 v1(274.94,75.21) C4306.2 ; C7553.2 308.25,21.42 v1(307.82,21.85) ; v4(200.48,163.21) 200.48,163.2 200.15,162.87 200.09,162.87 C50811.1 ; 303.84,7.68 C2549.2 ; R67003.2 129.69,48.72 v1(129.59,48.62) ; R50710.1 205.79,137.8 C50735.2 ; C4127.2 144.3,74.44 ; R1335.1 273.45,26.78 v1(273.81,26.42) 274.34,26.95 R1334.1 ; D7600.1 22.95,31.03 v1(23.21,31.3) ; 118.29,137.74 C4566.2 ; C7563.2 v1(74.18,60.3) ; C4817.2 254.03,46.53 v1(253.69,46.87) ; v1(299.21,32.16) 299.34,32.29 C7573.2 ; R7601.1 R7604.1 v1(21.46,33.81) ; C514.2 24.69,54.31 v1(24.98,54.02) 25.65,54.02 C515.2 ; v1(23.69,61.37) 23.73,61.37 24.21,61.84 C520.2 ; C7554.2 v1(308.38,20.35) ; C68.2 v1(15.69,33.89) ; R51110.1 165.74,93.67 v1(165.71,93.7) ; U60600.2 216.05,22.51 215.67,22.89 v5(215.67,23.05) ; R349.1 203.45,28.59 v5(203.86,28.19) ; v1(83.05,130.44) 83.14,130.35 R4526.2 ; v1(222.83,51.18) 223.16,50.86 R146.1 223.7,48.84 Q9.4 ; C51681.2 v1(295.14,61.4) ; C4722.2 100.42,158.64 C7512.1 ; C7548.2 65.4,106.76 v1(65.25,106.91) ; v1(292.78,62.36) 293.09,62.06 R55812.2 ; v1(292.96,46.79) 292.96,47.07 293.09,47.2 R55811.2 ; C4113.2 121,76.31 120.34,76.98 v1(120.24,76.98) 119.87,76.98 119.45,76.56 C36.2 ; 103.48,137.74 C4529.2 ; C516.2 21.87,63.15 22.17,63.45 v1(22.17,63.49) ; v1(132.03,169.17) 132.4,168.79 C66046.2 ; R51660.1 302.63,61.55 302.23,61.95 v1(301.16,61.95) ; R4838.1 269.1,53.45 v1(268.75,53.8) ; C4691.2 107.29,132.49 ; 143.9,73.08 C4126.2 ; C67087.2 127.88,59.44 v1(127.1,59.44) 127.1,58.85 R67087.2 ; C60166.2 199.49,28.78 v1(199.78,28.49) ; v1(127.61,72.85) 127.31,72.85 C4143.2 ; v1(30.17,60.29) 30.17,60.33 29.94,60.56 C3005.2 ; C530.2 v1(18.23,64.13) ; v4(158.44,140.06) 158.44,140.13 158.06,140.51 C51000.2 ; C56420.2 290.64,68.28 R56435.1 289.93,67.73 v1(290.04,67.62) ; v1(117.17,71.61) 117.24,71.53 C4157.2 ; C50820.2 214.35,155.04 ; v1(295.47,77.22) 295.72,77.22 296.1,77.6 C56452.1 ; v1(27.07,62.69) 27.59,63.21 C3012.2 ; C4670.2 v1(118.89,131.3) ; 109.29,128.12 C4523.2 ; v1(147.98,74.37) R4213.2 ; R55819.2 296.53,59.62 296.53,59.97 v1(296.24,60.26) ; v1(303.55,10.77) 303.6,10.82 R2411.1 ; v1(223.06,20.55) 222.74,20.23 C309.2 ; R55813.2 v1(292,62.39) ; C4791.2 142.24,161.78 ; 110.09,127.67 C4557.2 ; R4843.1 271.5,52.15 271.7,51.95 v1(271.72,51.95) 271.7,51.93 271.7,51.55 R4841.1 ; v1(115.67,71.73) 115.67,71.04 C4140.2 C4148.2 ; C4568.2 103.38,127.67 ; C60190.2 v1(192.27,22.28) ; C56441.2 v1(289.73,81.46) ; v1(94.44,126.47) 94.47,126.51 C4687.2 ; 180.84,118.57 180.81,118.54 C53047.2 ; 114.35,128.11 C4535.2 ; 169.65,140.4 C50101.2 ; v1(201.83,174.91) C67416.2 ; v1(291.08,65.66) 291.08,65.76 290.78,66.06 R56431.1 ; C7561.2 v1(44.56,78.16) ; R55814.2 v1(291.11,62.36) ; C7579.1 v1(305.63,60.71) ; R51902.1 163.75,121.38 ; v1(12.01,60.61) C525.2
  L8 w0.16: v4(165.85,116.61) 165.9,116.56 165.9,116.44 v4(166.44,115.89)
  L8 w0.2: v4(165.85,116.61) 165.86,116.61 166.38,117.13 v4(166.38,117.27) 166.78,117.67 166.78,118.19 167.21,118.62 v4(167.21,118.73) ; v4(166.16,114.2) 166.3,114.4 166.3,115.76 v4(166.44,115.89)
  L10 w0.14: v4(165.85,116.61) 165.9,116.67 165.9,116.79 v4(166.38,117.27)
  L10 w0.254: v4(166.04,118.39) 166.04,117.61 v4(166.38,117.27)
  BOTTOM w0.1: v4(162.52,150.17) 162.36,150.17 161.97,149.78 161.97,147.81 U50000.AU51 ; 154.97,119.11 154.36,119.11 154.34,119.08 U50000.BJ10 152.9,119.08
  BOTTOM w0.125: v4(185.45,146) 185.45,145.54 185.66,145.32 185.97,145.32 186.29,145.64 186.46,145.64 U50000.B48
  BOTTOM w0.127: U50000.AW28 160.63,131.71 160.63,132.35 U50000.AW29 ; v4(210.98,145.66) v4(210.98,144.91) ; v4(207.97,156.47) v4(208,157.21)
  BOTTOM w0.15: v4(152.65,117.03) 152.85,116.82 153.44,116.82 U50000.BJ7 154.24,116.98 v4(154.61,117.34) ; 157.47,122.88 157.46,122.87 v4(157.46,122.23) ; U50000.BF2 155.7,113.59 155.45,113.84 v4(155.45,114.5) 155.7,114.75 U50000.BF4
  BOTTOM w0.152: v1(108.65,117.14) U4555.AF1 U4555.AF2 ; U4555.AW5 U4555.AW4 U4555.AW3 U4555.AW2 ; U4555.T3 U4555.T4 U4555.T5 ; U4555.T3 U4555.T2 U4555.T1 116.15,117.64 116.15,117.2 v1(115.72,116.76) ; U4555.T3 116.08,118.99 v1(115.72,118.64) ; U4555.BE3 93.57,118.86 93.58,118.85 93.58,118.47 93.57,118.46 U4555.BE2 93.57,118.21 93.58,118.2 93.58,117.82 93.57,117.81 U4555.BE1 93.57,117.56 93.58,117.55 93.58,117.18 v1(93.12,116.72) ; U4555.W3 U4555.W2 U4555.W1 113.68,117.12 v1(113.24,116.76) ; U4555.W3 113.57,118.99 v1(113.24,118.66) ; U4555.W3 U4555.W4 U4555.W5 ; U4555.BN4 88.27,119.79 U4555.BM5 ; U4555.AC5 111.17,120.16 111.18,120.15 111.18,119.82 111.17,119.81 U4555.AC4 ; U4555.K3 U4555.K2 U4555.K1 121.4,117.52 v1(121.4,117) ; U4555.K3 121.23,119.11 121.24,119.12 121.24,119.5 121.23,119.51 U4555.K4 ; U4555.K3 121.11,118.99 v1(120.79,118.66) ; U4555.N3 118.6,118.99 v1(118.27,118.66) ; U4555.N3 U4555.N2 U4555.N1 118.71,117.55 118.72,117.55 118.72,116.97 118.71,116.97 118.71,116.92 v1(118.68,116.89) ; U4555.N3 U4555.N4 U4555.N5 ; U4555.AJ3 U4555.AJ2 U4555.AJ1 v1(106.14,117.14) ; U4555.AJ3 105.81,118.66 v1(105.7,118.66) ; U4555.AJ3 U4555.AJ4 U4555.AJ5 U4555.AJ6 ; U4555.AR3 U4555.AR2 U4555.AR1 100.85,117.43 v1(100.65,117.43) ; U4555.BH2 U4555.BH3 U4555.BH4 U4555.BH5 ; U4710.C12 U4710.D12 ; U4555.BT3 86.14,119 v1(85.61,118.83) ; U4555.AC4 U4555.AC3 U4555.AC2 111.17,118.29 111.16,118.29 111.17,118.16 U4555.AC1 v1(111.17,117.14) ; U4555.AC4 111.05,119.64 v1(110.72,119.31) ; U4555.AE6 109.08,120.53 109.08,120.07 U4555.AF4 U4555.AF3 U4555.AF2 ; v1(95.64,116.72) 95.82,116.9 95.83,116.9 96.08,117.15 96.08,117.17 96.08,117.18 96.08,117.54 96.08,117.55 U4555.BB1 96.08,117.82 96.08,117.83 96.08,118.19 96.08,118.2 U4555.BB2 U4555.BB3 96.08,119.11 96.1,119.12 96.1,119.5 96.08,119.51 U4555.BB4 96.08,119.76 96.1,119.77 96.1,120.15 96.08,120.16 U4555.BB5 U4555.BB6 ; v1(108.21,118.64) 108.51,118.34 U4555.AF2 ; U4555.M13 U4555.M14
  BOTTOM w0.17: U50000.U9 175.93,118.38 v4(175.66,118.11)
  BOTTOM w0.178: U50000.J12 181.6,119.6 ; U4710.A33 237.34,49.1 v1(236.7,49.1) ; v4(181.24,122.21) 181.24,122.21 v4(181.24,121.5) ; v1(237.16,51.79) 237.18,51.77 237.37,51.77 237.54,51.59 U4710.A28 ; v4(180.75,113.95) 180.75,114.14 180.62,114.28 180.62,114.58 ; U4710.A37 237.35,46.92 v1(237.08,46.92)
  BOTTOM w0.2: U50000.BC34 157.78,135.88 157.48,136.18 v4(157.48,136.27) ; v4(152.52,119.47) 152.5,119.45 152.5,119.45 152.2,119.15 U50000.BL10 ; U50000.BE34 156.4,135.88 v4(156.71,135.57) ; U50000.BE31 156.06,133.45 v4(156.06,133.41) U50000.BE30 ; v4(163.82,142.54) 163.82,142.46 U50000.AP43 ; U50000.BC19 158.06,125.38 158.14,125.46 v4(158.34,125.46) ; U50000.BC22 157.48,127.16 v4(157.45,127.16) ; v4(156.04,125.02) U50000.BE19 ; U50000.V29 v4(175.65,132.73) U50000.V30 ; v4(154.61,117.34) 154.97,116.98 U50000.BG7 ; U50000.AB39 v4(172.15,139.73) ; U50000.P21 v4(178.47,126.43) U50000.P20 ; v4(155.44,115.83) 155.44,116.03 U50000.BF6 ; U50000.BD32 157.1,134.22 v4(157.23,134.09) ; v4(153.88,127.83) 153.88,127.76 U50000.BJ22 ; U50000.BC16 157.47,122.95 157.47,122.88 ; U50000.V28 v4(175.65,131.33) U50000.V27 ; U50000.V17 v4(174.99,123.58) U50000.V16 ; U50000.AW46 v4(160.25,143.93)
  BOTTOM w0.203: v1(87.16,122.17) U4555.BP7 U4555.BN7 ; v1(87.16,122.17) 86.35,122.17 U4555.BT8 ; v1(87.16,122.17) U4555.BR7 ; v1(94.44,124.56) 94.89,124.84 U4555.BC12 ; v1(94.44,124.56) 93.98,124.84 U4555.BD12 ; v1(94.44,124.56) v1(94.44,123.92) ; v1(94.44,124.56) U4555.BD11 ; U4555.T8 116.02,122.25 v1(116.4,122.63) v1(116.4,123.26) ; U4555.T8 U4555.T9 ; U4555.T8 115.95,122.22 115.95,121.63 U4555.T7 115.67,121.35 115.67,121.25 U4555.U6 U4555.V6 114.27,120.69 114.08,120.69 U4555.W5 ; U4555.BH8 U4555.BH7 91.23,121.12 U4555.BH6 ; U4555.BH8 U4555.BH9 ; U4555.BH8 v1(91.68,122.64) ; v1(127.28,138) 127.03,137.75 U4555.A28 ; U4555.AT6 99.86,121.35 99.72,121.35 U4555.AU7 ; v1(127.5,125.02) 127.37,125.15 U4555.A12 ; U4555.BM6 U4555.BL6 U4555.BK6 90.54,120.61 v1(90.63,120.61) 90.96,120.94 U4555.BH6 ; U4555.BM6 U4555.BM5 v1(88.92,119.76) U4555.BM3 ; U4555.BM6 88.58,120.86 v1(88.21,121.24) U4555.BN7 ; U4555.BE29 93.5,138.22 v1(93.19,137.91) ; v1(123.89,128.7) 123.56,129.02 U4555.F17 123.56,129.16 v1(123.24,129.49) 122.91,129.81 U4555.G18 ; U4555.BD11 v1(94.44,123.92) ; U4555.BD11 U4555.BD10 ; U4555.BD11 U4555.BD12 ; v1(94.44,123.92) v1(94.44,123.29) ; v1(94.44,123.92) U4555.BD10 ; U4555.BD9 U4555.BD8 ; U4555.BD9 v1(94.44,123.29) ; U4555.BD9 U4555.BD10 ; U4555.BD9 94.39,122.68 v1(94.44,122.69) ; U4555.BD8 94.38,122.65 94.4,122.65 v1(94.44,122.69) ; U4555.BD8 U4555.BD7 93.98,121.2 93.99,121.19 ; U4555.BN34 88.14,141.39 87.81,141.07 ; 89.11,125.32 U4555.BM12 88.72,124.84 v1(88.46,124.53) ; 89.11,125.32 89.02,125.43 U4555.BM13 88.49,126.06 v1(88.46,126.1) ; 89.11,125.32 89.11,125.39 U4555.BL13 ; U4555.BP18 U4555.BR18 U4555.BT18 v1(85.41,129.65) ; U4555.BN19 88.14,130.5 v1(87.81,130.83) 87.81,130.9 U4555.BN20 ; v1(122.24,140.73) 121.91,141.06 U4555.J33 ; v1(122.24,140.73) 122.56,140.41 U4555.H32 ; v1(122.24,140.73) 121.92,140.41 U4555.J32 ; v1(99.93,123.92) v1(99.92,123.29) ; v1(99.93,123.92) U4555.AU10 ; v1(99.93,123.92) U4555.AU11 ; v1(99.92,123.29) v1(99.92,122.65) ; v1(99.92,123.29) U4555.AU9 ; v1(99.92,123.29) U4555.AU10 ; U4555.AR38 101.45,144.31 v1(101.77,144.64) ; v1(109.07,125.17) 108.93,125.17 U4555.AF12 U4555.AF13 ; v1(115.49,125.82) 115.81,126.15 U4555.T14 ; U4555.N8 119.13,122.55 v1(119.12,123.29) ; U4555.AD7 U4555.AD8 ; v1(97.59,137.88) U4555.AW29 U4555.AW30 v1(98.62,139.44) ; v1(103.67,117.12) 103.63,117.17 U4555.AM1 U4555.AM2 U4555.AM3 103.63,119.05 103.69,119.12 103.69,119.5 103.63,119.57 U4555.AM4 ; v1(123.89,138.15) 123.56,138.47 U4555.F29 123.16,138.14 123.16,138 U4555.G28 ; U4555.N10 v1(119.13,123.92) ; U4555.N10 v1(119.12,123.29) ; U4555.N10 U4555.N11 U4555.N12 ; U4555.N10 U4555.N9 v1(119.12,123.29) ; v1(119.13,123.92) v1(119.12,123.29) ; v1(119.13,123.92) 119.12,123.93 v1(119.12,124.56) 118.67,124.84 U4555.N12 ; U4555.N12 v1(119.12,125.19) ; U4555.N12 v1(118.21,125.17) U4555.P12 v1(117.3,125.17) U4555.R12 v1(116.38,125.19) U4555.T12 ; U4555.A22 127.26,133.03 127.34,132.95 v1(127.36,132.95) ; U4555.AP9 v1(102.66,123.29) ; U4555.AP9 v1(102.66,122.6) ; U4555.AP9 U4555.AP8 ; v1(102.66,123.29) v1(102.66,122.6) ; v1(102.66,123.29) U4555.AP10 v1(102.67,123.92) ; v1(102.66,123.29) v1(102.67,123.92) ; U4555.N6 118.75,120.9 118.75,120.33 U4555.N5 ; U4555.N6 U4555.M6 ; U4555.N6 118.71,121.29 118.67,121.34 U4555.N7 ; U4555.N6 v1(118.27,120.61) 117.94,120.94 U4555.P6 ; U4555.BJ29 90.3,138.18 90.24,138.12 89.99,138.12 89.89,138.02 v1(89.89,138.02) ; U4555.AU7 U4555.AU8 ; U4555.AU7 99.46,120.97 U4555.AU6 99.18,120.69 99,120.69 U4555.AW5 ; U4555.AU8 U4555.AU9 ; U4555.AU8 v1(99.92,122.65) ; U4555.BH11 U4555.BH10 ; U4555.BH11 91.68,123.94 v1(91.68,123.91) ; U4555.BH11 91.67,124.55 91.68,124.55 ; U4555.BH11 U4555.BH12 91.23,124.84 v1(90.78,124.52) 90.51,124.84 U4555.BJ12 ; U4555.BH10 91.66,123.28 91.66,123.28 v1(91.68,123.26) ; U4555.BH10 v1(91.68,123.91) ; U4555.BH10 U4555.BH9 ; v1(97.18,123.91) v1(97.18,123.24) ; v1(97.18,123.91) v1(97.18,124.55) ; v1(97.18,123.91) U4555.BA11 ; v1(97.18,123.91) U4555.BA10 ; v1(97.18,123.24) 97.14,123.25 U4555.BA9 U4555.BA10 ; v1(97.18,123.24) 97.17,123.28 U4555.BA10 ; U4555.AR5 101.11,120.15 101.11,120.15 101.11,119.78 101.11,119.77 U4555.AR4 101.11,119.51 101.12,119.5 101.12,119 U4555.AR3 100.93,118.99 v1(100.61,118.67) ; U4555.BJ35 90.42,142.3 90.42,141.78 U4555.BJ34 ; U4555.BF33 92.79,141.06 v1(93.11,141.38) 92.78,141.71 U4555.BF34 ; U4555.Y10 U4555.Y11 v1(113.64,123.87) ; U4555.Y10 v1(113.64,123.87) ; U4555.Y10 U4555.Y9 ; U4555.Y10 v1(113.64,123.22) ; U4555.AR13 101.43,125.5 v1(101.75,125.82) 101.43,126.15 U4555.AR14 ; U4555.G24 122.91,134.54 v1(123.24,134.21) ; v1(94.44,123.29) v1(94.44,122.69) ; v1(94.44,123.29) U4555.BD10 ; U4555.BR14 v1(87.16,126.1) U4555.BP14 v1(87.81,126.1) U4555.BN14 v1(88.46,126.1) ; U4555.D12 125.23,124.79 125.23,124.65 U4555.C11 125.51,124.3 v1(125.84,123.97) ; U4555.BN24 88.07,134.44 87.55,134.44 U4555.BP24 ; U4555.BA12 96.73,124.84 v1(97.18,124.55) ; U4555.BA12 U4555.BA11 ; U4555.BA12 v1(96.26,125.17) U4555.BB12 v1(95.35,125.16) 95.04,124.85 U4555.BC12 ; U4555.BA12 v1(97.18,125.18) U4555.AY12 ; U4555.G22 122.91,132.95 v1(123.24,132.62) 123.26,132.62 123.56,132.31 U4555.F21 123.25,131.93 v1(123.25,131.84) ; U4555.BH5 91.05,120.38 91.09,120.42 91.09,120.8 91.05,120.84 U4555.BH6 ; 125.11,126.48 U4555.D14 ; v1(95.47,140.73) 95.14,141.06 U4555.BC33 ; U4555.BR9 v1(87.16,123.74) ; U4555.L30 U4555.L29 120.27,138.07 120.21,138.01 120.21,137.47 v1(120.19,137.44) ; U4555.AL7 105.24,121.6 105.65,121.19 105.89,121.19 U4555.AJ6 U4555.AH6 U4555.AG6 108.2,121.2 108.22,121.22 ; U4555.T10 116.37,123.91 v1(116.41,123.91) ; U4555.T10 U4555.T9 ; U4555.T10 U4555.T11 ; U4555.T10 115.93,123.54 v1(116.4,123.26) ; v1(102.66,122.6) U4555.AP8 ; U4555.AP8 102.65,121.81 102.65,121.46 102.79,121.32 U4555.AN6 102.74,120.89 U4555.AN5 103.06,119.96 v1(103.23,119.96) 103.56,120.29 U4555.AM5 ; U4555.BA8 96.77,122.2 96.77,121.64 U4555.BA7 96.47,121.35 96.47,121.32 U4555.BB6 ; U4555.BP33 87.74,140.42 87.74,140.28 U4555.BN31 ; U4555.BL13 89.14,126.06 v1(89.11,126.1) ; U4555.BL13 89.82,126.05 ; v1(116.38,124.56) 115.93,124.84 U4555.T12 ; v1(116.38,124.56) U4555.T11 ; v1(116.38,124.56) 116.38,123.94 v1(116.41,123.91) ; U4555.BE6 U4555.BF6 U4555.BG6 U4555.BH6 ; U4555.BE6 93.45,120.82 93.45,120.4 U4555.BE5 ; U4555.BE6 93.82,121.19 93.99,121.19 ; 91.68,124.55 91.67,124.55 92.14,124.84 U4555.BG12 U4555.BG13 ; 91.68,124.55 v1(91.68,124.55) 91.68,124.54 91.68,124.54 v1(91.68,123.91) ; U4555.BN7 U4555.BM7 88.54,122.03 88.54,122.31 U4555.BM8 88.54,122.81 88.54,123.1 U4555.BM9 88.91,123.47 88.91,124.02 U4555.BM11 88.79,124.2 v1(88.46,124.53) ; 87.81,141.07 v1(87.81,141.05) ; 87.81,141.07 87.81,141.13 U4555.BP34 U4555.BR34 ; 125.11,123.19 U4555.C9 ; 125.11,123.19 125.11,123.33 U4555.D10 ; 125.11,123.19 U4555.D9 ; v1(116.41,123.91) 116.39,123.89 116.38,123.29 v1(116.4,123.26) ; v1(116.41,123.91) U4555.T11 ; v1(102.66,124.56) U4555.AP12 v1(102.66,125.19) U4555.AN12 ; v1(102.66,124.56) 102.66,123.93 v1(102.67,123.92) ; v1(102.66,124.56) U4555.AN12 ; v1(102.66,124.56) U4555.AP11 v1(102.67,123.92) ; v1(88.46,124.53) 88.46,124.6 U4555.BN12 88.09,124.87 88.01,124.87 88,124.86 87.62,124.86 87.61,124.87 87.54,124.87 U4555.BP12 87.41,124.92 87.35,124.86 86.97,124.86 86.91,124.92 U4555.BR12 U4555.BT12 v1(85.62,125.04) ; v1(95.47,139.44) U4555.BB30 U4555.BB29 ; U4555.AF13 U4555.AF14 108.7,126.15 v1(109.06,125.78) ; U4555.AF13 108.53,125.5 108.28,125.75 107.95,125.75 U4555.AG13 107.35,125.16 v1(107.24,125.16) 107.06,124.98 107.05,124.98 106.92,124.85 U4555.AH12 106.63,124.85 v1(106.32,125.16) 106.21,125.16 U4555.AJ13 105.73,125.5 v1(105.41,125.17) 105.28,125.17 U4555.AL12 104.69,125.11 104.3,125.11 U4555.AM12 103.78,125.11 103.38,125.11 U4555.AN12 ; U4710.J47 241.58,42.3 241.73,42.15 U4710.J48 241.73,41.65 241.78,41.61 v1(241.78,41.59) ; 93.99,121.19 94.15,121.19 U4555.BD6 ; v1(91.68,123.26) 91.68,123.28 91.68,123.91 v1(91.68,123.91) ; v1(91.68,123.26) v1(91.68,122.64) ; v1(91.68,123.26) 91.67,123.26 91.66,123.26 U4555.BH9 ; U4555.BD6 U4555.BC6 95.57,120.61 v1(95.64,120.61) 95.97,120.94 U4555.BB6 ; U4555.BD6 94.29,120.94 v1(93.96,120.61) 93.89,120.61 U4555.BE5 ; U4555.D18 125.11,129.63 125.11,129.49 U4555.C17 ; U4710.AT1 254.99,65.03 254.99,65.59 v1(255.09,65.69) ; U4555.BA11 U4555.BA10 ; U4555.BA11 v1(97.18,124.55) ; U4555.T9 115.97,122.89 v1(116.4,123.26) ; U4555.BJ31 90.29,139.76 v1(89.96,139.43) 90.35,139.04 U4555.BJ30 90.49,138.92 U4555.BK29 89.65,138.52 U4555.BL29 U4555.BM29 U4555.BN29 U4555.BP29 ; v1(85.52,119.65) 86.13,119.65 U4555.BT4 ; U4555.A3 U4555.B3 126.03,118.9 125.99,118.89 125.71,118.8 125.45,118.8 ; U4555.AL9 v1(105.41,122.57) ; U4555.AL9 U4555.AL10 ; U4555.AL9 v1(105.41,123.22) ; v1(105.41,122.57) U4555.AL8 ; v1(105.41,122.57) v1(105.41,123.22) ; U4710.D8 U4710.E8 ; U4555.C19 125.21,130.97 125.14,130.97 125.14,131.17 U4555.D20 ; v1(113.64,123.22) v1(113.64,122.57) ; v1(113.64,123.22) U4555.Y9 ; v1(113.64,123.22) v1(113.64,123.87) ; v1(113.64,122.57) U4555.Y9 ; v1(113.64,122.57) U4555.Y8 ; v1(85.7,135.86) 85.72,135.86 85.81,135.95 U4555.BT26 ; v1(97.18,124.55) 97.63,124.84 U4555.AY12 ; U4555.Y9 U4555.Y8 ; v1(122.59,133.42) 122.91,133.74 U4555.G23 123.04,134.02 v1(123.24,134.21) ; v1(123.89,130.27) 123.56,130.6 U4555.F19 123.56,130.7 123.4,130.86 123.4,130.9 v1(123.24,131.06) 122.91,131.39 U4555.G20 ; U4555.C5 125.51,120.51 125.22,120.81 125.22,120.81 v1(125.21,120.82) ; v1(127.61,126.95) 127.53,126.95 127.3,126.73 U4555.A14 ; U4555.M12 U4555.M13 ; U4555.C8 U4555.D6 ; v1(127.33,118.75) 127.33,119.14 U4555.A4 ; U4555.BT32 85.81,140.61 v1(85.52,140.32) ; v1(123.24,134.21) 123.56,133.89 U4555.F23 123.56,133.76 v1(123.9,133.43) ; 108.22,121.22 108.22,121.24 108.08,121.34 107.74,121.6 U4555.AG7 U4555.AG8 v1(108.15,122.57) ; 108.22,121.22 v1(108.23,121.22) ; v1(89.11,126.1) U4555.BM14 v1(88.46,126.1) ; v1(89.11,126.1) U4555.BL14 89.81,126.06 89.82,126.05 ; v1(125.84,138.15) 125.51,138.47 U4555.C29 125.11,138.94 125.11,139.08 U4555.D30 ; U4555.BN21 88.46,132.34 v1(88.46,132.4) U4555.BM21 ; U4555.F25 123.26,135.09 123.26,135 v1(123.26,135) ; U4555.T12 U4555.T13 ; U4555.T12 U4555.T11 ; U4555.D24 125.11,134.35 125.11,134.17 125.47,133.81 U4555.C23 ; v1(91.25,116.95) 90.8,117.4 U4555.BH1 90.8,118.08 U4555.BH2 91,118.34 90.68,118.66 v1(90.61,118.66) ; U4555.A24 v1(127.45,134.6) ; U4555.AU9 U4555.AU10 ; U4555.AU9 v1(99.92,122.65) ; v1(105.7,118.66) 105.7,119.19 U4555.AK4 U4555.AL4 ; U4555.Y13 113.51,125.17 113.64,125.17 U4555.W12 v1(114.55,125.17) U4555.V12 ; U4555.Y13 113.18,125.5 113.05,125.5 112.4,124.85 U4555.AA12 v1(111.81,125.17) U4555.AC12 v1(110.87,125.17) v1(110.89,124.52) U4555.AD11 ; U4555.Y13 U4555.Y14 ; U4555.Y8 U4555.Y7 112.95,121.36 112.71,121.36 112.28,120.94 U4555.AB6 U4555.AC6 111.17,120.82 111.18,120.8 111.18,120.42 111.17,120.41 U4555.AC5 ; U4555.BB6 U4555.BA6 ; v1(246.74,41.3) 246.86,41.3 246.92,41.37 U4710.AA49 ; v1(93.12,118.66) 93.45,118.99 U4555.BE3 93.57,119.11 93.58,119.12 93.58,119.5 93.57,119.51 U4555.BE4 93.57,119.76 93.58,119.77 93.58,120.15 93.57,120.16 U4555.BE5 ; U4555.B9 126.27,122.79 126.3,122.83 126.67,122.83 126.7,122.79 U4555.A9 ; U4555.AD11 U4555.AD10 ; U4555.AD11 U4555.AD12 ; U4555.AU33 99.87,141.06 v1(100.19,140.73) ; U4555.C25 125.11,135.79 125.11,135.93 U4555.D26 ; 125.45,118.8 125.38,118.51 U4555.C2 ; 125.45,118.8 125.1,118.81 U4555.D3 124.72,119.19 124.69,119.19 U4555.E4 ; U4555.AN29 U4555.AN30 ; U4555.BB3 95.97,118.99 v1(95.64,118.66) ; U4555.A10 127.6,123.58 v1(127.71,123.47) ; U4555.BT5 85.65,120.5 v1(85.51,120.62) ; U4555.AL10 v1(105.41,123.87) v1(105.41,123.22) ; U4555.AL10 v1(105.41,123.22) ; v1(127.43,121.23) U4555.A6 ; v1(244.62,41.02) 244.78,41.02 244.98,41.23 U4710.T49 ; U4710.A8 237.43,61.37 237.25,61.37 v1(237.12,61.25) ; U4555.BC12 U4555.BC13 U4555.BC14 94.76,126.15 v1(94.44,126.47) ; 115.22,143.99 U4555.U37 115.62,143.66 v1(115.94,143.34) ; 122.59,124.76 122.26,125.09 U4555.H12 ; 89.82,126.05 U4555.BK14 ; 89.82,126.05 U4555.BK13 ; U4555.AG10 v1(108.15,123.87) U4555.AG11 v1(108.15,124.52) ; U4555.BT21 v1(85.79,132.41) ; U4555.AR33 101.44,141.06 v1(101.77,140.73) ; U4555.AP34 102.23,141.71 v1(102.56,141.38) 102.23,141.06 U4555.AP33 ; 123.89,122.4 U4555.F9 ; U4555.AU11 U4555.AU12 99.2,125.11 98.81,125.11 U4555.AW12 98.29,125.11 98.03,125.11 97.77,124.85 U4555.AY12 ; U4555.AU11 U4555.AU10 ; U4555.M14 119.45,126.15 v1(119.12,125.82) ; U4710.AD49 v1(248.41,41.37) ; U4555.BH9 v1(91.68,122.64) ; U4555.BN4 U4555.BM3 ; U4555.BM3 U4555.BM2 88.69,118.19 88.65,118.16 v1(88.65,118.15) 88.64,118.15 88.64,118.16 U4555.BN2 ; U4555.P37 118.24,143.34 v1(118.3,143.34) ; U4555.E35 124.27,142.3 124.27,141.85 124.21,141.78 U4555.E34 124.21,141.61 124.53,141.29 124.53,141.23 U4555.D33 124.98,140.79 125.11,140.65 125.11,140.51 U4555.C31 125.51,140.05 v1(125.84,139.72) ; v1(104.49,125.82) 104.82,126.15 U4555.AL14 ; U4555.D38 v1(124.34,144.69) ; U4555.BC34 95.15,141.71 v1(95.47,142.03) ; U50800.C5 202.26,160.49 202.26,160.03 202.5,159.79 203,159.79 v4(203.16,159.95) ; v4(170.08,146.66) 170.19,146.78 170.19,147.42 170.33,147.55 170.33,147.71 U50000.AE51 ; U4555.L33 120.35,141.06 v1(120.67,141.38) 120.34,141.71 U4555.L34 ; U50000.B37 186.35,137.98 186.15,138.18 185.58,138.18 v4(185.5,138.1) ; U4555.BG13 92.25,125.43 U4555.BF12 v1(93.52,125.14) U4555.BD12 ; U4555.BG13 U4555.BG14 92,126.15 91.72,125.87 91.72,125.84 v1(91.7,125.82) ; U4555.K5 121.23,120.16 121.24,120.15 121.24,119.77 121.23,119.76 U4555.K4 U4555.J4 122.39,119.96 v1(122.47,119.96) ; v1(125.83,131.83) 125.83,131.84 125.83,131.93 U4555.C21 125.51,132.38 U4555.D22 ; U4555.BM26 88.79,135.88 v1(89.11,135.55) ; U4555.AR35 101.44,142.36 v1(101.77,142.03) 101.45,141.71 U4555.AR34 ; U4555.AL34 104.46,141.71 v1(104.13,141.38) 104.45,141.06 U4555.AL33 ; U4710.AM49 v1(252.29,41.37) ; U4555.AY14 v1(97.18,126.47) ; U4555.G14 123.31,127.13 123.31,127.26 U4555.F15 ; v1(250.98,41.37) U4710.AG49 ; U4710.D30 238.83,50.91 U4710.C30 ; U4555.A16 v1(127.45,128.3) ; U4555.AT30 U4555.AT29 ; U4555.AK30 U4555.AK29 ; U4555.AE6 U4555.AD6 ; v1(127.5,139.53) 127.32,139.71 126.99,139.71 U4555.A30 ; U4555.AG29 U4555.AG30 ; U4555.J36 122.1,142.76 122.24,142.76 U4555.H35 122.71,142.36 v1(123.03,142.68) 123.09,142.68 U4555.F36 123.49,143.01 v1(123.82,143.33) 123.82,144.21 U4555.E38 ; U4555.AM38 103.8,144.31 v1(104.13,143.99) ; U4555.A18 v1(127.45,129.88) ; U4555.G26 122.91,136.22 123.22,136.53 123.22,136.58 v1(123.23,136.58) 123.23,136.59 123.25,136.62 123.25,136.65 U4555.F27 ; U4555.AY33 97.51,141.06 v1(97.83,141.38) 97.5,141.71 U4555.AY34 ; v1(107.28,141.38) U4555.AH34 ; U4555.AU34 99.87,141.71 v1(100.19,142.03) ; U4555.A20 v1(127.45,131.45) ; 247.24,74.22 248.15,73.31 248.15,72.04 248.51,71.68 248.51,70.02 248.26,69.76 247.27,69.76 247.04,69.53 247.04,67.72 247.19,67.57 v1(247.19,67.47) 246.73,67.01 245.56,67.01 245.16,67.41 v1(245.16,67.47) 244.98,67.64 244.98,68.61 244.22,69.37 243.35,69.37 243.15,69.57 243.15,70.36 242.92,70.6 242.92,71.78 243.15,72.01 243.15,73.89 243.48,74.22 247.24,74.22
  BOTTOM w0.225: U50000.C52 v4(186.17,148.17) ; U50000.B52 v4(186.62,149.04) ; U50000.A51 v4(187.69,148.13) ; U50000.C51 v4(185.49,147.46) ; U50000.B51 v4(186.8,148.08)
  BOTTOM w0.25: U50000.BE21 156.06,127.12 v4(156.03,127.12) 156.2,127.29 156.21,127.29 U50000.BE22 ; v4(155.34,129.92) U50000.BG25 ; v4(155.94,123.06) 156.18,123.06 156.39,123.28 U50000.BE16 ; v4(152.7,112.37) 152.7,112.58 U50000.BK1 ; v4(154.36,127.55) 154.42,127.48 U50000.BG22 ; v4(153.98,113.76) 154.26,113.48 U50000.BH2 ; U50000.AR52 163.4,148.95 163.39,148.95 v4(163.39,148.97) ; U50000.BG16 v4(155.3,123.58) ; U50000.BL2 151.92,113.2 v4(151.91,113.16) ; U50000.BE13 156.6,120.98 157.35,120.98 v4(157.43,120.91) 157.5,120.98 157.6,120.98 U50000.BC13 ; v4(151.86,115.27) 152.18,115.58 U50000.BL5 ; v4(151.69,112.68) 151.69,112.75 151.46,112.98 151.46,113.33 151.5,113.37 U50000.BM2 ; v4(155.34,125.66) 155.07,125.38 U50000.BG19 ; v4(151.91,112.17) 151.92,112.17 152.17,112.42 152.17,112.55 152.17,112.75 U50000.BL1 ; U50000.BG31 v4(155.3,134.08) ; U50000.BL7 152.6,116.98 v4(152.65,117.03) ; U50000.BM3 v4(151.16,113.84) ; U50000.BG28 v4(155.3,131.98) ; U50000.BG13 v4(155.29,121.47)
  BOTTOM w0.254: U4710.AD19 v1(248.47,55.9) U4710.AB19 ; v4(174.47,141.79) 174.47,141.79 174.47,142.05 U50000.W43 ; U4710.U21 U4710.V22 v1(246.13,55.07) 246.13,55.14 U4710.V20 245.17,56.09 U4710.T18 U4710.T17 245.28,57 U4710.U17 ; U50000.P20 178.05,126.03 178.05,125.42 U50000.P19 ; U4710.M5 242.98,62.92 243.34,62.92 v1(243.43,63) 243.64,63 U4710.P4 243.88,63.28 244.29,63.69 U4710.R3 ; U50000.AL31 v4(166.55,134.13) U50000.AL32 ; U4710.W28 v1(246.92,51.25) ; v1(246.92,51.25) U4710.AA30 v1(247.7,50.47) ; v1(246.92,51.25) U4710.W30 ; v1(246.92,51.25) U4710.AA28 ; 252.42,51.17 252.27,51.17 U4710.AK30 251.96,50.79 v1(252.27,50.47) ; 252.42,51.17 U4710.AK28 ; 252.42,51.17 U4710.AL29 ; v1(103.23,119.96) 103.4,119.79 103.44,119.79 103.59,119.64 U4555.AM4 ; U4710.J29 241.44,51.4 v1(241.58,51.54) 241.58,52 241.44,52.13 241.44,52.54 U4710.J26 ; C50562.2 v1(172.13,172.91) C50624.2 ; v1(64.87,70.51) 64.69,70.7 C4702.2 64.35,70.64 Q4751.4 ; v4(186.18,118.79) 186.47,119.08 U50000.B10 ; U50000.AL15 166.1,122.67 166.1,123.19 U50000.AL16 ; v1(88.46,132.4) U4555.BM22 v1(89.1,132.42) ; U50000.AB2 172.5,113.86 v4(172.56,113.91) 172.77,114.13 172.77,114.61 172.52,114.86 ; U4710.J10 241.7,60.45 U4710.K11 242.2,60.58 v1(242.38,60.58) ; C67012.2 v1(158.32,59.64) ; v1(260.64,47.11) U4710.BG37 ; 113.65,141.39 v1(113.58,141.39) ; 113.65,141.39 U4555.W33 113.65,140.74 v1(113.58,140.74) ; 113.65,141.39 U4555.W34 113.65,142.04 v1(113.58,142.04) ; U50000.Y34 173.82,135.96 173.82,136.5 U50000.Y35 ; U4555.AV37 99.09,143.66 v1(99.41,143.99) 99.08,144.31 U4555.AV38 ; 211.4,151.54 211.4,150.93 211.59,150.74 C50728.2 ; 211.4,151.54 v1(211.39,151.54) ; 211.4,151.54 211.73,151.54 C50822.2 ; U4710.BC40 258.54,45.89 258.54,45.6 v1(258.59,45.55) ; v1(248.43,65.23) 248.67,65 U4710.AD1 U4710.AD2 ; U50000.AN32 164.8,134.52 v4(164.51,134.8) 164.51,134.89 U50000.AN33 ; v1(171.98,174.32) 171.62,174.68 C50632.2 ; U4710.BG22 260.43,54.86 v1(260.63,54.66) ; U50500.V13 v4(175.66,161.47) ; U67060.19 208.3,55.9 C67069.2 208.06,56.14 v1(207.41,56.14) ; v4(154.65,115.23) 154.65,115.23 U50000.BH5 ; U50000.AN30 164.8,133.14 v4(164.49,133.46) 164.8,133.77 U50000.AN31 ; v1(98,42.29) 97.95,42.24 U1700.19 ; v1(239.16,36.91) 239.16,36.7 239.68,36.19 R4870.2 ; C67219.2 240.58,81.6 v1(240.58,81.61) ; 174.22,127.11 U50000.Y21 173.9,127.31 ; 174.22,127.11 174.1,127.11 173.9,127.31 ; 174.22,127.11 v4(174.24,127.11) ; U4555.BJ32 v1(89.96,140.73) ; U50000.AU10 162,119.07 161.68,118.75 161.68,118.04 v4(161.71,118.01) ; v1(121.79,123.9) U4555.K10 121.39,123.42 121.39,123.03 U4555.K9 121.39,122.77 121.39,122.38 U4555.K8 v1(121.76,121.85) ; v1(121.79,123.9) U4555.J10 ; v1(121.79,123.9) 121.78,123.89 121.38,124.17 121.35,124.2 U4555.K11 ; U4555.BL22 v1(89.1,132.42) ; v1(89.1,132.42) U4555.BM21 89.11,131.62 89.44,131.29 U4555.BL20 89.76,130.9 v1(89.76,130.83) 89.76,130.8 89.59,130.63 U4555.BL19 ; v1(89.1,132.42) U4555.BL21 ; v1(88.46,133.98) U4555.BM24 v1(89.1,133.98) U4555.BM23 v1(88.46,133.98) ; v1(88.46,133.98) U4555.BN24 ; U4710.AW46 256.05,43.1 256.41,43.1 v1(256.54,42.97) ; U4555.F25 122.91,136.04 U4555.G26 ; U50000.V26 175.23,130.35 175.23,130.91 U50000.V27 ; CN2500.B1 312.1,11.85 CN2500.A12 311,11.85 310.72,11.56 CN2500.G7 v1(310.13,11.4) ; v1(255.55,46.66) 255.55,46.43 255.83,46.15 U4710.AV39 256.13,46.11 256.22,46.02 256.27,46.02 U4710.AW40 ; U50000.AJ28 v4(167.95,131.33) U50000.AJ27 167.53,130.91 167.53,130.35 U50000.AJ26 ; U50000.BC28 v4(157.41,132.07) U50000.BD29 ; U1.1 212.75,25.07 212.75,24.06 v1(212.77,24.04) ; U4555.BD38 94.62,143.99 ; 94.62,143.99 94.61,143.99 U4555.BD37 ; 94.62,143.99 v1(94.68,143.99) ; U4710.M24 242.69,54.1 v1(242.69,54.18) ; v1(246.92,52.02) U4710.W27 ; v1(246.92,52.02) U4710.AA27 ; v1(246.92,52.02) U4710.AA28 ; U4555.G6 122.87,120.88 122.94,120.81 122.94,120.42 122.87,120.34 U4555.G5 122.54,119.96 v1(122.47,119.96) U4555.G4 U4555.F4 ; U50500.U14 175.27,162.6 v4(174.9,162.22) ; U4555.B9 v1(125.87,122.39) ; v1(125.87,122.39) U4555.C8 ; v1(125.87,122.39) U4555.C9 ; U4555.H25 U4555.J25 121.54,135.39 v1(121.15,135) ; v1(127.35,142.96) U4555.A36 U4555.A34 ; U4555.BJ34 v1(89.96,141.38) ; v1(89.96,141.38) U4555.BJ33 ; v1(89.96,141.38) U4555.BL33 ; v1(261.44,37.16) 261.37,37.23 C4788.1 ; v4(186.13,129.87) 186.43,129.58 U50000.B25 ; U50000.P23 178.05,128.22 178.05,128.83 U50000.P24 ; U4555.BM29 U4555.BM28 v1(89.11,137.13) U4555.BM27 88.78,136.74 88.37,136.33 ; U4710.AK4 251.35,62.96 251.31,62.96 251.28,62.93 251.25,62.93 251.06,62.74 251.06,62.68 v1(250.95,62.56) ; v1(249.97,52.02) U4710.AG27 250.79,52.8 ; v1(249.97,52.02) U4710.AF28 ; v1(249.97,52.02) U4710.AG28 250.41,51.66 v1(250.77,52.02) ; U50000.AL35 165.95,136.9 165.88,136.97 v4(165.88,136.99) 165.96,136.99 U50000.AL36 ; U50000.AU39 162.09,139.29 162.09,138.77 U50000.AU38 v4(161.61,138.34) 161.61,138.31 U50000.AU37 ; U50000.BG37 v4(155.3,138.28) ; U4710.U17 U4710.U15 245.28,58.08 245.1,57.9 v1(244.99,57.9) 244.99,57.79 244.73,57.54 U4710.R16 U4710.N16 U4710.M16 ; U4710.U17 246.74,57.32 U4710.Y17 v1(247.22,57.58) 247.58,57.22 U4710.AC17 ; v4(178.51,142.57) 178.51,142.47 U50000.N43 ; v1(111.22,144.64) 111.15,144.64 U4555.AC38 110.5,143.99 v1(110.43,143.99) 110.6,143.82 110.63,143.82 110.79,143.66 U4555.AC37 110.86,143.66 111.02,143.51 111.05,143.51 v1(111.22,143.34) ; v1(93.89,139.44) U4555.BE30 U4555.BE29 ; U4555.AR37 101.44,143.66 v1(101.77,143.33) 101.45,143.01 U4555.AR36 ; U4555.AD12 v1(110.87,125.17) ; v1(244.74,49.49) 244.46,49.21 U4710.R34 U4710.N34 243.68,49.19 243.58,49.28 v1(243.58,49.38) 243.48,49.38 ; v1(244.74,49.49) 244.74,49.31 245,49.05 U4710.U33 245.7,49.16 U4710.Y33 ; v1(244.74,49.49) U4710.T32 ; v4(177.06,128.53) U50000.T23 176.61,128.1 176.61,127.56 U50000.T22 ; U4710.AA20 v1(247.7,55.9) U4710.AA19 ; v1(104.13,143.99) 104.1,143.99 103.78,143.66 U4555.AM37 ; 251.18,56.23 U4710.AJ19 251.18,56.6 251.48,56.9 v1(251.48,57.01) ; U4555.BJ36 90.35,142.97 90.44,142.88 90.44,142.48 90.35,142.4 U4555.BJ35 ; U50000.A26 187.37,130.28 v4(187.76,129.89) ; U50000.AF22 v4(169.37,127.13) U50000.AF21 ; U4710.AW10 256.29,60.2 v1(256.21,59.93) U4710.AV11 ; v1(91.31,132.8) U4555.BJ22 U4555.BK22 ; v4(163.74,146.73) 164.1,147.09 U50000.AP51 ; v4(184.69,148.14) 184.69,148.08 U50000.E51 184.4,147.77 v4(184.08,147.46) ; U50600.N1 v4(158.87,170.47) U50600.M1 v4(159.66,169.72) ; U50600.N1 v4(159.66,171.22) ; U50600.N1 v4(158.87,171.18) ; U4710.AH12 250.48,59.97 v1(250.21,59.97) 249.9,59.97 U4710.AE12 ; U50000.K40 181.05,140.08 ; v1(257.68,59.56) 257.65,59.59 257.43,59.59 257.35,59.67 U4710.BA12 ; v1(257.68,59.56) 257.68,59.55 257.68,59.39 256.99,58.7 U4710.BA14 257.26,58.16 U4710.BC15 ; v1(257.68,59.56) 257.77,59.56 257.96,59.36 258.03,59.36 U4710.BC13 ; U4555.C15 125.51,127.6 v1(125.21,127.91) 124.86,128.25 U4555.D16 ; C50721.2 211.62,134.27 C50745.2 ; 301.81,24.64 301.81,23.74 C87.2 ; 301.81,24.64 R2649.1 ; 301.81,24.64 301.81,25.09 301.75,25.15 v1(301.75,25.24) ; U4555.BM38 v1(89.3,144.74) U4555.BL38 ; v1(105.71,143.34) 106.03,143.66 U4555.AJ37 106.1,143.7 106.01,143.79 106.01,144.19 106.1,144.27 U4555.AJ38 ; v1(127.36,143.74) U4555.A37 126.67,143.59 U4555.B37 125.41,143.59 U4555.C37 ; U50000.N2 178.8,113.88 v4(178.75,113.93) 179.02,114.2 179.02,114.48 ; v4(185.98,123.22) 186.03,123.28 U50000.B16 ; v4(152.63,137.9) U50000.BL37 ; U1.75 204.29,39.83 204.11,39.65 v1(204.11,39.4) ; 239.25,45.46 v1(239.14,45.35) U4710.E42 239.5,44.95 U4710.F43 240.19,44.6 240.65,44.13 U4710.G44 240.87,44.05 241.09,43.83 v1(241.09,43.56) 241.25,43.56 U4710.J46 ; 239.25,45.46 239.78,45.46 U4710.F41 ; 239.25,45.46 239.3,45.5 U4710.E40 ; U50000.AE10 170.4,118.93 ; C51252.2 v1(194.61,89.85) ; U50000.AN18 v4(165.13,125.03) U50000.AN19 164.73,125.45 164.73,126.01 U50000.AN20 ; U50000.AD14 v4(171.44,121.54) ; U50000.AD14 v4(170.75,121.53) ; U50000.AD14 v4(170.72,122.23) U50000.AD15 ; CN1300.18 276.2,27.64 276.2,26.67 276.42,26.45 v1(276.42,26.34) ; v1(310.21,15.62) 310.23,15.6 CN2500.G9 ; CN1900.33 167.38,33.05 v1(167.03,32.69) ; U4555.BA38 96.65,144.27 96.74,144.19 96.74,143.79 96.65,143.7 U4555.BA37 96.98,143.33 v1(97.04,143.33) ; U50000.AL19 v4(166.53,125.73) U50000.AL20 ; U4555.BJ14 90.13,126.54 U4555.BK14 ; v1(87.25,112.82) 87.19,112.76 R4520.1 87.19,111.14 Q2.2 87.48,110.34 R44.1 ; U67010.19 158.39,55.82 C67019.2 v1(157.48,56.06) ; U4555.AW4 v1(98.16,119.34) U4555.AW3 v1(98.15,118.66) U4555.AW2 v1(98.14,117.98) 98.44,117.69 U4555.AW1 ; C4846.2 240.9,68.56 C4877.2 240.71,69.27 239.69,70.3 239.69,70.66 v1(239.7,70.67) ; v1(105.05,137.57) 105.01,137.66 U4555.AK29 105.64,137.77 v1(105.64,137.57) ; C4828.2 247.97,70.72 247.68,71.01 v1(247.68,71.44) ; v1(251.58,50.47) 251.19,50.09 U4710.AJ31 250.87,49.78 U4710.AH33 U4710.AE33 249.16,49.14 248.9,49.41 v1(248.76,49.41) ; U4555.M13 v1(120.04,125.17) U4555.M12 119.58,124.84 v1(119.12,124.56) ; U4555.M13 v1(119.12,125.82) ; U4555.M13 v1(119.12,125.19) ; U4710.BC45 v1(257.56,43.55) 257.43,43.55 257.06,43.92 U4710.BA44 257.14,44.13 257.14,44.39 v1(257.35,44.61) ; U4710.AJ25 251.57,52.8 ; U4710.AJ25 250.79,52.8 ; U4710.AJ25 U4710.AG23 v1(250.02,54.37) ; 251.57,52.8 U4710.AK25 251.99,53.22 252.4,53.22 v1(252.45,53.27) ; 251.57,52.8 U4710.AJ27 250.79,52.8 ; 251.57,52.8 U4710.AK27 252.15,52.61 U4710.AL26 252.45,52.61 252.45,53.27 v1(252.45,53.27) ; v4(170.74,142.56) 170.4,142.21 U50000.AE43 ; U50000.B22 186.05,127.48 v4(186.03,127.46) ; U4710.AN34 253.54,48.54 253.64,48.54 v1(253.65,48.53) 253.65,48.53 253.96,48.83 U4710.AR34 ; U50000.V34 175.23,135.81 175.23,135.25 U50000.V33 ; v4(164.46,86.24) 164.34,86.36 C51138.2 ; U4555.C17 125.84,128.76 v1(125.84,128.71) ; U50000.T10 176.68,119.08 v4(176.34,118.74) 176,118.39 U50000.U9 ; v1(240.32,71.3) 240.5,71.3 240.9,71.71 C4809.2 ; 91.96,144.31 92,144.31 v1(92.32,144.64) ; 91.96,144.31 U4555.BG38 ; 91.96,144.31 92.12,144.15 92.12,144.15 92.12,143.84 91.94,143.66 U4555.BG37 ; v4(153.19,142.03) 153.17,142.03 153.03,142.17 v4(152.68,142.17) 152.66,142.18 U50000.BL43 ; v4(152.52,119.47) 152.9,119.08 ; 250.79,52.8 U4710.AG25 ; U4555.F5 123.55,120.42 U4555.F4 ; R2680.1 298.87,24.37 298.01,25.23 298.01,26.47 v1(298.04,26.5) ; U4710.BC24 258.42,53.42 258.21,53.22 v1(258.21,53.11) 258.21,52.96 258.42,52.76 U4710.BC26 ; v1(254.83,34.75) 254.88,34.79 254.88,35.41 C4816.2 ; v4(152.9,127.61) 152.77,127.48 U50000.BL22 ; U4710.AA27 v1(247.7,52.02) U4710.AA28 ; U4710.AA27 v1(247.7,52.8) U4710.AB25 ; U4710.AA27 v1(246.92,52.8) ; U50900.B1 v4(212.88,99.56) ; U50000.K13 181.21,120.87 v4(181.24,120.87) ; U4710.AN16 253.25,57.13 v1(253.34,57.05) 253.25,57.05 253.22,57.02 253.12,57.02 U4710.AM18 252.38,56.28 U4710.AK19 ; v4(161.17,168.95) 161.53,169.31 U50600.L4 ; U4555.C25 125.51,135.32 v1(125.19,135) 125.19,134.93 U4555.D24 ; U50000.AW33 160.7,135.28 160.7,135.78 U50000.AW34 v4(160.25,136.23) U50000.AW35 ; C50955.2 211.42,112.15 v1(211.06,112.51) 211.33,112.79 C51023.2 ; U50000.AF27 v4(169.35,130.63) U50000.AG26 ; U4710.T5 245.13,63.04 245.39,63.29 v1(245.39,63.38) 245.27,63.5 U4710.T4 244.6,63.5 U4710.R4 ; U50000.A50 187.31,147.08 187.57,146.82 v4(187.57,146.75) ; CN1300.19 276.45,21.09 v1(276.63,21.26) ; U50000.AJ9 167.56,118.38 v4(167.21,118.73) ; U50000.K19 181.43,125.38 v4(181.45,125.41) ; U4710.AF25 v1(249.24,52.8) U4710.AD25 ; U50000.AD18 171.14,124.72 171.14,125.34 U50000.AD19 ; v1(305.3,16.02) D7504.8 D7504.3 ; U50000.AL51 166.2,147.49 v4(166.01,147.3) ; U50500.V11 v4(177.16,161.47) ; U50000.K2 180.9,113.8 v4(180.75,113.95) ; v4(186.93,113.15) 186.6,113.48 U50000.B2 ; v4(186.93,113.15) 186.56,112.78 U50000.B1 ; v4(186.93,113.15) 186.94,113.15 187.2,113.4 U50000.A2 ; U50000.AU16 162.07,123.21 162.07,122.65 U50000.AU15 v4(161.65,122.23) U50000.AU14 v4(162.32,121.56) ; C3501.2 C3502.2 238.19,20.09 v1(238.54,20.09) ; v4(160.28,121.55) U50000.AW14 v4(160.31,122.22) U50000.AW15 160.32,122.86 v4(160.32,122.91) 160.32,123 U50000.AW16 ; U50000.AJ31 167.53,133.85 167.53,134.41 U50000.AJ32 v4(167.95,134.83) U50000.AJ33 167.53,135.25 167.53,135.81 U50000.AJ34 ; v1(222.52,53.83) U60900.18 U60900.21 ; v1(123.24,123.19) U4555.G9 ; v1(123.24,123.19) U4555.F9 ; v1(123.24,123.19) U4555.G10 ; v4(176.74,113.92) 176.7,113.88 U50000.T2 ; v1(250.36,65.87) 250.53,65.7 U4710.AG1 ; U50000.C1 185.8,112.31 v4(185.87,112.23) ; v1(115.94,144.64) 115.87,144.64 U4555.U38 115.22,143.99 v1(115.15,143.99) ; v1(211.07,39.48) 210.69,39.86 U1.91 ; v1(136.12,58.5) 136.12,57.38 ; U4710.E33 239.5,49.97 v1(239.53,50) ; U50500.H4 v4(183.17,169) ; U4710.AC4 248.82,63.24 v1(248.87,63.2) 248.91,63.24 U4710.AE4 ; U50000.BC31 157.54,133.78 v4(157.23,134.09) ; U50000.BC37 U50000.BD38 v4(156.75,139.08) ; v4(166.52,121.57) U50000.AL14 165.87,121.58 v4(165.86,121.57) ; U4555.BM25 v1(89.11,135.55) 89.12,135.54 v1(89.75,135.54) ; U50000.AR17 v4(163.14,124.34) U50000.AR18 ; CN1900.27 169.51,34.55 v1(169.64,34.42) ; CN2500.B12 312.1,17.35 CN2500.A1 310.97,17.35 310.72,17.6 CN2500.G10 v1(310.2,18.31) ; v1(227.48,20.48) 227.48,20.7 227.8,21.03 C3503.2 C3500.2 ; v4(185.99,140.11) 186.03,140.08 U50000.B40 ; U4555.BN20 U4555.BN21 88.01,131.92 87.61,131.92 U4555.BP21 87.36,131.92 86.96,131.92 U4555.BR21 86.51,132.34 v1(86.51,132.41) 86.19,132.08 U4555.BT21 ; v1(285.62,21.95) 285.95,21.62 285.95,20.08 CN1300.57 ; C50622.2 156.32,174.46 v1(156.33,174.47) ; U4555.AR30 U4555.AR31 101.5,139.89 101.5,140.28 U4555.AR32 101.45,140.41 v1(101.77,140.73) ; U4555.AR30 U4555.AR29 101.34,138.03 101.04,137.78 v1(100.66,137.82) 100.66,138.34 U4555.AT29 100.48,138.3 100.46,138.3 100.18,138.02 100.18,137.98 v1(100.02,137.82) ; U4555.AR30 U4555.AT30 ; v4(177.06,121.53) 176.71,121.88 U50000.T14 177.05,122.23 v4(177.06,122.23) 176.71,122.58 ; U4710.U24 v1(244.92,53.41) ; U50800.L4 v4(208.01,161.72) ; v1(252.45,53.27) U4710.AL24 ; C51311.2 149.12,108.06 v1(149.55,107.62) 149.62,107.62 149.88,107.36 149.88,104.17 149.45,103.74 146.15,103.74 145.67,104.22 145.67,107.4 v1(145.94,107.67) 146.33,108.06 C51310.2 ; v4(172.38,142.98) 172.4,143.01 172.4,143.48 U50000.AB45 ; C4845.2 240.61,70.49 240.41,70.69 v1(240.32,70.69) ; v4(151.81,125.14) 151.88,125.14 152.12,125.38 U50000.BL19 ; v1(125.83,131.83) 125.67,131.83 125.67,131.83 125.24,131.83 U4555.D20 ; U4710.BC10 258.54,60.48 v1(258.54,61.01) 258.21,61.34 U4710.BC8 257.8,61.38 U4710.BB9 ; v4(166.04,118.39) 166.04,118.92 166.19,119.07 ; U50000.AB39 172.57,139.31 172.57,138.75 U50000.AB38 ; U2.11 v1(228.7,34.55) ; U4555.V12 v1(115.47,125.17) U4555.T13 v1(116.38,125.19) ; v1(35.05,64.42) 34.95,64.42 34.45,64.91 CN5.23 ; v1(210.28,166.52) 210.28,166.53 210.37,166.61 C50838.2 ; U4710.M21 242.94,55.22 v1(242.94,55.78) U4710.M18 ; U4710.F47 239.44,41.76 238.71,41.76 U4710.C48 238.07,41.81 U4710.B48 ; CN1300.1 271.95,20.08 v1(271.95,21.34) 271.33,21.34 CN1300.G1 ; U4710.BG28 260.32,51.36 v1(260.64,51.36) ; v1(246.92,52.8) U4710.W25 ; v1(246.92,52.8) U4710.AA25 ; U4555.BM33 88.79,140.74 v1(88.46,141.07) ; U4555.BT35 85.69,142.57 v1(85.65,142.98) 86.03,142.9 U4555.BT36 U4555.BR36 ; 111.29,141.39 v1(111.22,141.39) ; 111.29,141.39 U4555.AB33 111.29,140.74 v1(111.22,140.74) ; 111.29,141.39 U4555.AB34 111.29,142.04 v1(111.22,142.04) ; 116.01,141.39 U4555.T34 116.01,142.04 v1(115.94,142.04) ; 116.01,141.39 v1(115.94,141.39) ; 116.01,141.39 U4555.T33 116.01,140.74 v1(115.94,140.74) ; U4555.G22 122.91,133.09 v1(122.59,133.42) 122.21,133.04 U4555.H22 ; v1(243.4,70.76) 243.45,70.76 C4826.2 ; U4555.BM35 v1(89.13,142.6) U4555.BL35 ; U4555.E9 123.89,122.47 123.89,122.4 123.56,122.07 U4555.F8 123.25,121.69 123.25,121.63 v1(123.21,121.59) 123.21,121.66 122.91,121.96 U4555.G8 ; U50000.AB29 172.42,132.46 172.42,133 U50000.AB30 172.83,133.42 v4(172.83,133.43) 172.5,133.77 U50000.AB31 ; U4710.AT18 255.24,56.91 v1(255.24,57.3) 255,57.54 U4710.AT16 ; 253.18,59.6 U4710.AN12 ; U4710.AN12 U4710.AR12 ; U4710.AN12 252.61,59.63 v1(252.61,59.63) 252.6,59.63 252.38,59.63 252.36,59.6 U4710.AL12 251.85,59.87 v1(251.54,59.87) 251.25,59.59 250.94,59.59 ; U50000.Y22 173.9,127.31 ; U50000.AU36 161.61,136.95 v4(161.6,136.92) U50000.AU35 v4(161.63,136.22) U50000.AU34 U50000.AU33 v4(162.32,134.81) U50000.AU32 ; 118.37,141.39 U4555.N33 118.37,140.74 v1(118.3,140.74) ; 118.37,141.39 v1(118.3,141.39) ; 118.37,141.39 U4555.N34 118.37,142.04 v1(118.3,142.04) ; U4555.BR26 U4555.BR25 U4555.BP25 ; U4555.BR26 U4555.BT26 ; U4555.BR26 86.9,135.95 86.96,135.89 87.35,135.89 87.41,135.95 U4555.BP26 87.52,135.95 87.9,136.33 88.37,136.33 ; U4555.F19 122.91,130.01 U4555.G18 ; v1(234.64,26.65) 234.64,26.19 234.75,26.08 U3500.23 ; v1(244.69,46.16) 244.51,46.35 U4710.R38 244.53,46.77 U4710.U38 246.83,46.77 U4710.Y38 v1(247.39,46.78) ; U67020.19 168.34,55.82 168.11,56.06 C67029.2 168,56.14 v1(167.4,56.14) ; U4710.E19 239.3,56.78 U4710.E17 239.28,57.2 U4710.D17 U4710.D16 U4710.E15 v1(239.14,58.88) ; v1(264.39,40.53) 264.1,40.24 C4814.2 ; v1(262.33,34.19) 262.53,34.4 269.19,34.4 269.49,34.7 269.49,36.22 269.2,36.5 263.83,36.5 ; v1(253.51,62.77) 253.58,62.77 253.83,63.02 U4710.AP4 ; v1(95.3,39.53) 95.37,39.53 95.65,39.81 U1700.13 ; U50000.AL38 165.89,138.33 v4(165.89,138.31) 165.94,138.31 U50000.AL37 v4(166.55,138.33) U50000.AL38 ; U50000.AL38 165.86,139.02 165.84,139.02 ; v1(274.95,21.26) 274.95,20.08 CN1300.13 ; v1(293.88,38.13) 293.98,38.03 C56250.1 ; U50000.AJ18 v4(167.95,124.33) U50000.AJ17 167.55,123.93 167.55,123.33 U50000.AJ16 ; U4710.BF48 259.69,41.5 U4710.BF49 259.93,41.25 v1(260.47,41.25) ; C4707.2 247.93,33.74 v1(247.87,33.68) ; v4(173.28,174.35) 172.97,174.66 C50559.2 ; U50000.BG40 v4(155.3,140.38) U50000.BF41 ; U50000.AJ22 v4(167.95,127.83) U50000.AJ23 ; C50823.2 213.41,167.69 C50821.2 ; v1(242.23,46.46) U4710.K39 241.7,45.92 U4710.J40 ; v1(242.26,62.54) 242.26,62.67 U4710.J4 ; v4(187.59,114.34) 187.43,114.18 U50000.A3 ; U4710.M34 243.46,49.38 243.48,49.38 ; U50000.BL28 152.67,131.68 v4(152.83,131.52) ; U50000.AD22 171.17,127.41 171.17,126.85 U50000.AD21 ; v1(280.39,22.23) 280.54,22.23 281.45,21.32 281.45,20.08 CN1300.39 ; v1(111.15,137.56) v1(110.56,137.56) U4555.AD29 U4555.AD30 ; U50000.AU2 162,113.81 v4(162.1,113.91) ; U4555.BR14 U4555.BT14 ; v4(212.88,101.81) U50900.A4 v4(213.63,102.56) ; v1(247.7,50.47) U4710.AA31 ; v1(247.7,50.47) U4710.AB31 v1(248.76,49.41) ; v1(257.35,44.61) 257.36,44.6 U4710.BB43 258.34,44.6 258.66,44.27 U4710.BD43 258.91,44.09 U4710.BE44 ; v1(257.35,44.61) 257.35,44.88 U4710.BB41 ; U50000.BL40 v4(152.62,140) ; U50000.K22 181.05,127.63 v4(181.47,127.63) ; U4710.BG25 260.18,53.2 260.25,53.2 260.32,53.27 v1(260.64,53.27) ; U4710.C4 238.64,63.3 U4710.C5 238.64,63.14 U4710.A5 U4710.A4 236.16,63.64 v1(236.01,63.8) 236.35,64.14 U4710.A3 ; v1(107.29,142.68) 107.2,142.68 U4555.AH35 ; U50000.AB51 172.5,147.4 v4(172.64,147.26) ; U4710.P29 244.17,50.8 v1(244.17,50.7) 244.57,51.1 U4710.R29 ; v4(178.38,138.33) 178.38,138.26 U50000.P37 ; CN5.31 v1(30.45,65.01) ; U50000.P33 178.05,135.22 178.05,135.83 U50000.P34 ; U4710.AL17 251.81,57.01 v1(251.48,57.01) ; U4710.AC12 248.2,59.59 v1(247.39,59.59) U4710.Y12 ; v4(167.99,142.5) 168.3,142.19 U50000.AH43 ; v1(210,127.93) 210.02,127.94 C51028.2 ; v4(153.13,129.62) 153.09,129.58 U50000.BL25 ; U50000.AB18 172.54,124.64 172.54,124.02 U50000.AB17 ; U50000.V15 v4(175.03,122.25) U50000.V14 ; U4555.V30 U4555.V29 v1(115.16,137.56) ; C50535.2 172.23,171.33 v4(172.18,171.38) 172.18,171.38 C50631.2 ; v1(248.76,49.41) 248.64,49.41 248.38,49.14 U4710.AC33 ; U4710.R12 244.27,59.86 v1(244.01,59.86) 243.99,59.84 243.63,59.84 U4710.N12 ; v1(123.26,123.98) 123.26,123.98 123.26,124.07 U4555.F11 ; R51572.2 154.77,108.65 v1(155.01,108.89) ; v1(149.46,108.73) 149.46,108.61 149.97,108.09 R51316.2 ; CN5.9 v1(41.45,64.95) ; U4555.BK15 U4555.BJ15 90.87,127.29 v1(91.21,126.95) ; v1(310.44,13.01) 310.72,13.3 CN2500.G8 ; v1(258.57,47.68) 258.42,47.83 U4710.BC35 ; v1(260.8,57.56) 260.8,57.36 260.55,57.1 260.21,57.1 U4710.BG17 ; v4(164.56,136.22) 164.89,136.22 ; v4(166.52,119.39) 166.22,119.08 U50000.AL10 ; U50000.B46 185.92,144.28 v4(185.87,144.24) ; U4710.AG22 v1(250.02,54.37) ; v1(250.02,54.37) 249.66,54.73 U4710.AF22 v1(249.24,54.37) U4710.AD22 ; U50000.W2 174.6,113.82 v4(174.78,114.01) 174.85,114.07 174.85,114.63 174.63,114.85 ; CN5.3 v1(44.45,65) ; v1(207.73,126.88) 207.7,126.92 207.7,126.99 R51006.2 ; U50000.AB10 172.71,118.87 172.71,118.84 v4(172.81,118.74) ; v4(184.79,124.33) 184.79,124.41 ; v4(153.26,121.47) v4(152.68,121.47) 152.39,121.18 U50000.BL13 ; CN1700.7 259.35,30.5 259.42,30.57 v1(259.42,30.59) ; v1(156.38,172.88) 156.33,172.93 C50630.2 ; U4555.F3 v1(123.26,118.66) U4555.F2 123.74,118.42 123.74,118.9 U4555.F3 ; U4555.F3 U4555.F4 ; U4555.AD7 110.33,121.49 U4555.AD6 110.4,120.94 v1(110.73,120.61) 111.05,120.94 U4555.AC6 ; C50623.2 v1(156.33,171.38) ; C88.2 R2507.2 302.59,20.03 v1(302.38,19.82) 302.21,19.99 R2400.1 ; U4555.BN30 v1(88.46,139.49) U4555.BN31 ; U50000.BE36 156.11,137.66 v4(156.09,137.67) U50000.BE37 ; U4555.P38 118.24,144.64 v1(118.3,144.64) ; v1(162.94,105.77) R51585.1 ; C50938.2 210.02,113.48 v1(210.07,113.54) ; v4(164.33,114.46) 164.1,114.23 U50000.AP2 ; U50000.BL31 v4(152.62,133.7) ; C51037.2 v1(213.06,127.93) ; v1(82.84,116.36) 82.84,114.91 82.33,114.39 R43.2 82.33,113.17 Q1.E ; v1(243.47,51.99) 243.79,52.32 U4710.P26 U4710.R26 ; v1(99.16,42.32) 99.16,42.27 99.15,42.26 U1700.22 ; v4(186,125.26) 186.13,125.38 U50000.B19 ; U50000.AG33 v4(169.35,135.53) U50000.AG34 ; CN5.12 v1(39.95,64.98) ; U50000.BD35 157.17,136.58 v4(157.48,136.27) ; U1700.7 97.95,37.99 v1(98.17,37.77) 98.35,37.95 U1700.6 ; U50000.AH8 v4(168.63,117.33) ; v1(253.13,65.46) 252.85,65.18 252.85,65.12 U4710.AM1 ; C50716.2 213.46,134.36 C50736.2 ; C67231.2 C67233.2 236.32,71.23 R67233.1 236.03,71.23 v1(235.63,71.63) ; U4555.H32 123.11,140.41 v1(123.19,140.49) U4555.F31 ; U4710.AT21 254.76,54.46 254.86,54.36 v1(254.86,54.33) 254.86,54.31 254.86,53.94 U4710.AT24 U4710.AT26 ; U50000.P16 U50000.P17 ; U50000.K37 181.3,137.98 ; U50000.BC25 157.51,129.29 157.36,129.29 v4(157.35,129.28) 157.75,128.88 U50000.BC24 ; U50000.Y36 173.82,137.36 173.82,137.9 U50000.Y37 ; U50000.BE27 156.4,131 v4(156.06,131.34) 156.39,131.68 U50000.BE28 ; U50000.AN26 164.72,130.36 164.72,130.9 U50000.AN27 ; U50000.AP10 164.1,118.76 v4(163.9,118.55) ; CN1300.7 273.45,20.08 v1(273.45,21.26) ; U50000.AJ37 167.53,138.04 167.53,138.61 U50000.AJ38 v4(167.91,139.01) U50000.AJ39 v4(167.95,139.73) ; U4710.M49 v1(243.2,41.37) ; U50000.K31 180.9,133.78 v4(181.23,133.45) ; C4767.1 263.85,37.72 263.54,37.41 263.54,36.74 263.59,36.69 ; v1(103.29,137.56) U4555.AN29 v1(102.61,137.56) ; R67601.2 152.64,172.92 152.35,172.62 v1(152.26,172.62) ; U4710.AA28 v1(247.7,51.25) ; U50000.D12 185.12,120.48 v4(185.41,120.77) 185.95,121.31 v4(186.01,121.31) 186.14,121.18 U50000.B13 ; C306.2 201.5,23.8 201.76,24.06 202.26,24.06 202.29,24.09 U1.27 202.29,26.16 v1(202.16,26.28) ; v1(125.84,125.55) 125.84,125.62 U4555.C13 125.51,126.08 125.11,126.48 ; U4555.BT24 v1(86.51,133.98) U4555.BR24 86.87,134.37 86.96,134.46 87.36,134.46 87.45,134.37 U4555.BP24 ; U50000.AL22 v4(166.55,127.13) U50000.AL21 ; U50000.T15 176.71,122.58 ; 176.71,122.58 v4(177.06,122.93) 176.71,123.28 U50000.T16 ; U50000.AL16 165.88,123.59 165.88,123.67 v4(165.87,123.68) 165.88,123.7 165.92,123.7 U50000.AL17 ; U50000.AL16 166.22,123.28 166.56,123.62 U50000.AL17 ; C51231.2 v1(194.6,86.81) ; CN1901.33 77.29,43.05 77.32,43.08 v1(77.34,43.08) ; v1(118.18,137.56) v1(117.6,137.56) U4555.R29 U4555.R30 ; U4555.BM26 88.75,135.95 88.37,136.33 ; v4(168.68,118.74) 168.34,119.08 U50000.AH10 ; U50000.AJ21 v4(167.95,126.43) U50000.AJ20 167.54,126.02 167.54,125.91 167.53,125.9 167.53,125.56 167.54,125.55 167.54,125.44 U50000.AJ19 ; U4555.F4 U4555.E4 ; v4(157.45,113.83) 157.79,113.83 ; U50000.B43 v4(186.08,142.18) ; v1(107.39,137.56) U4555.AG29 v1(108.02,137.56) ; U50000.AL18 166.2,124.55 166.16,124.51 166.16,124.16 166.17,124.16 166.17,124.01 U50000.AL17 ; U4710.J9 241.81,61.01 v1(241.86,60.96) 241.86,61.13 241.27,61.72 U4710.H8 240.96,62.01 U4710.G6 ; U50000.AF39 170.06,139.74 v4(170.11,139.74) ; v1(187.93,174.43) 187.96,174.46 C50534.2 189.17,174.46 C50520.2 ; v1(121.76,121.85) U4555.K7 ; v1(121.76,121.85) U4555.J7 ; U50000.AD24 171.1,128.85 v4(171.43,128.51) 171.1,128.18 U50000.AD23 ; U4710.AL21 252.27,55.2 U4710.AK20 U4710.AJ20 251.17,55.51 v1(250.8,55.88) ; C50841.2 211.89,166.63 v1(211.73,166.48) ; U7002.11 279.12,60.81 279.14,60.79 v1(279.14,60.73) ; U4710.C25 239.25,53.18 v1(239.3,53.14) U4710.E26 ; R51576.2 154.09,106.1 153.84,105.85 v1(153.41,105.85) ; U4710.M32 243.48,49.38 ; v1(282.72,21.39) 282.75,21.36 282.75,21.19 282.95,20.99 CN1300.45 ; v1(113.58,143.34) 113.41,143.51 113.38,143.51 113.22,143.66 U4555.Y37 113.15,143.66 112.99,143.82 112.96,143.82 v1(112.79,143.99) 112.86,143.99 U4555.Y38 113.51,144.64 v1(113.58,144.64) ; v4(168.24,147.33) 168.3,147.39 U50000.AH51 ; v4(156.06,139.72) U50000.BE39 ; U50000.AF38 v4(169.41,138.33) U50000.AF37 169.42,137.64 169.42,137.63 v4(169.4,137.6) 169.42,137.6 U50000.AF36 169.8,137.18 169.8,136.68 U50000.AF35 ; U50000.BA9 U50000.AY10 159.9,119.18 160.15,119.43 160.19,119.43 v4(160.19,119.44) ; U4555.K38 121.35,144.61 v1(121.48,144.61) ; U1700.28 101.44,39.81 101.47,39.83 v1(101.5,39.83) ; v1(91.7,125.82) 91.68,125.84 91.62,125.84 91.32,126.15 U4555.BH14 ; U4710.AC46 v1(248.97,43.12) U4710.AE46 ; v1(209.9,111.51) 209.99,111.6 C50931.2 ; U50000.AG25 168.9,129.48 168.9,128.98 U50000.AG24 v4(169.37,128.52) U50000.AF23 ; R2506.2 305.09,20.09 304.75,19.74 v1(304.67,19.74) ; U4555.D26 124.86,136.27 v1(125.17,136.58) 125.17,136.62 U4555.C27 125.51,137.1 U4555.D28 ; v1(260.8,30.69) 260.85,30.64 CN1700.4 ; U50500.D1 v4(184.66,171.97) ; U50500.D1 v4(185.41,172.72) ; U50500.D1 v4(184.66,172.72) ; U67030.19 178.3,55.85 C67039.2 177.64,56.11 v1(177.36,55.83) ; v1(91.39,129.69) 91.35,129.65 U4555.BJ18 U4555.BK18 U4555.BL18 89.31,129.74 88.91,129.74 U4555.BM18 v1(88.46,129.26) U4555.BN18 88.05,129.74 87.58,129.74 U4555.BP18 ; U4710.AL33 252.12,49.5 U4710.AM32 252.12,49.93 U4710.AK31 251.96,50.16 v1(252.27,50.47) ; v1(244.09,43.56) 244.09,43.33 U4710.P46 ; U50500.R14 175.27,164.1 v4(174.9,163.72) ; 165.84,139.02 v4(165.81,139.02) ; 165.84,139.02 U50000.AL39 v4(166.49,139.73) ; v1(252.27,50.47) 252.29,50.47 ; U67040.19 188.31,55.9 C67049.2 187.97,56.24 v1(187.39,56.24) ; U4710.AT45 v1(254.42,43.12) 254.25,43.12 254.24,43.11 253.85,43.11 253.84,43.12 253.84,43.12 U4710.AP46 ; v1(288.95,21.25) 288.95,20.08 CN1300.69 ; v4(181.31,136.1) 181.12,136.1 U50000.K34 ; U4710.AT32 254.78,49.91 254.38,49.51 v1(254.38,49.28) 254.38,49.09 254.63,48.83 U4710.AT34 ; v1(187.42,164.57) 187.62,164.77 R50506.2 ; U4710.AC38 v1(248.87,46.86) U4710.AE38 250.8,46.86 U4710.AH38 251.34,46.78 251.36,46.76 v1(251.37,46.76) 251.96,46.76 U4710.AL38 v1(252.63,46.77) 253.18,46.77 U4710.AN38 253.57,46.74 v1(253.69,46.87) 253.82,46.74 U4710.AR38 ; v1(58.19,43.71) U60000.22 ; U50000.H1 182.25,112.78 v4(181.96,112.49) 181.67,112.78 U50000.J1 ; C50741.2 210.19,150.77 209.83,151.13 v1(209.83,151.38) C50839.2 ; v1(197.4,55.83) 197.66,56.09 C67059.2 198.16,56.09 198.37,55.87 U67050.19 ; U50000.W10 174.6,118.97 v4(174.84,118.73) ; v1(127.33,118.75) 127.12,118.75 126.93,118.94 U4555.A3 ; C51239.2 194.65,88.33 194.59,88.4 v1(194.58,88.4) ; v1(97.26,122.57) U4555.BA9 ; v1(97.26,122.57) U4555.BA8 ; v1(97.26,122.57) v1(97.18,123.24) ; v1(167.07,30.22) 167.23,30.05 CN1900.45 ; U50700.H4 208.36,140.78 v4(207.99,140.41) ; U4710.BC19 v1(258.08,56.29) ; v4(184.75,146.72) 185.1,146.38 U50000.D49 ; v1(251.58,52.02) 251.19,51.63 U4710.AJ28 ; U50000.T33 v4(177.06,135.54) U50000.T34 ; U50000.AB43 172.5,142.21 172.22,142.49 v4(172.19,142.49) ; U4710.N35 U4710.N37 U4710.N38 243.13,46.46 242.82,46.46 v1(242.82,46.46) ; U50000.T37 176.64,137.92 176.64,137.34 U50000.T36 ; U50000.BJ23 153.88,127.9 v4(153.88,127.83) ; U4710.E8 239.5,60.92 v1(239.44,60.86) 239.3,60.72 U4710.E10 ; v1(107.28,143.33) 107.21,143.33 U4555.AH36 ; v1(108.86,140.74) U4555.AE33 v1(108.86,141.39) U4555.AE34 v1(108.86,142.04) ; U4555.BT29 U4555.BR29 87.14,137.94 87.14,137.94 v1(87.15,137.93) 87.17,137.95 87.18,137.95 U4555.BP29 ; U50000.T51 176.7,147.86 v4(176.41,148.15) ; 159,153.87 C52642.2 ; U4555.F13 123.51,125.94 123.43,125.87 123.42,125.87 123.24,125.69 v1(123.24,125.53) 122.91,125.21 U4555.G12 122.91,125.09 122.26,124.44 U4555.H11 ; U4710.BA6 257.06,63.03 U4710.BA5 v1(256.72,63.37) 256.64,63.45 256.34,63.45 256.27,63.39 256.17,63.39 U4710.AW4 ; v1(239.53,50) 239.42,50.11 239.42,50.19 239.3,50.31 U4710.E31 239.3,50.87 U4710.D30 ; v1(239.53,50) 239.49,50 239.04,49.55 U4710.D33 ; U50000.AF20 v4(169.33,125.74) U50000.AF19 v4(169.35,125.03) U50000.AG18 168.89,124.57 168.89,124.09 U50000.AG17 ; U50000.AL27 v4(166.55,130.63) U50000.AL26 U50000.AL25 166.19,129.57 166.19,129.07 166.2,129.06 U50000.AL24 ; v4(156.78,129.81) 156.55,129.58 U50000.BE25 ; U50000.AA49 173.09,146.38 v4(172.78,146.7) 172.5,146.42 U50000.AB49 ; U50000.D24 185.1,129.01 v4(185.32,129.23) ; v4(157.38,129.87) 157.35,129.87 157.1,130.13 U50000.BD26 ; v1(251.58,51.25) 251.19,50.86 U4710.AJ30 251.16,50.86 v1(250.77,51.25) 250.41,50.89 U4710.AG30 ; U3500.16 v1(230.07,24.64) ; U50000.BL34 v4(152.63,135.78) ; U50000.AW25 160.66,129.51 160.66,128.95 U50000.AW24 160.68,128.8 160.68,128.26 U50000.AW23 160.3,127.88 v4(160.3,127.86) 160.3,127.84 160.32,127.82 160.32,127.76 U50000.AW22 v4(160.25,127.13) U50000.AW21 160.67,126.71 160.67,126.15 U50000.AW20 v4(160.26,125.74) 160.26,125.72 U50000.AW19 v4(160.27,125.05) 160.27,125.01 U50000.AW18 160.27,124.35 v4(160.26,124.35) 160.26,124.32 U50000.AW17 ; v1(258.09,50.07) 258.11,50.09 258.11,50.1 U4710.BC31 ; U4555.AD11 110.86,123.9 110.86,123.89 v1(110.88,123.87) 110.88,123.87 110.86,123.85 U4555.AD10 110.84,123.23 v1(110.84,123.2) 110.84,123.18 U4555.AD9 110.83,122.59 v1(110.84,122.55) U4555.AD8 ; U4555.AA30 U4555.AA29 112.49,138.37 v1(112.85,137.56) v1(113.44,137.56) ; U4555.A26 127.12,136.57 v1(127.17,136.58) ; U4710.AK46 251.6,43.12 251.28,43.44 251.12,43.44 250.98,43.58 v1(250.97,43.58) ; U8.1 v1(296.54,20.55) ; U1700.4 v1(99.15,37.86) ; U50000.AU27 162.06,130.98 v4(162.35,131.27) 162,131.63 U50000.AU28 162.33,132.01 v4(162.33,132.06) 162.01,132.38 U50000.AU29 162,132.52 162.01,132.54 162.01,133.07 U50000.AU30 v4(162.38,133.46) 162.32,133.46 U50000.AU31 ; U50000.P27 178.05,130.93 178.05,130.32 U50000.P26 ; v1(107.28,140.73) U4555.AH33 v1(107.28,141.38) ; U50000.AD39 v4(170.85,139.71) ; U50000.AW36 v4(160.25,137.63) U50000.AW37 160.28,138.35 v4(160.27,138.35) U50000.AW38 U50000.AW39 ; U4710.T7 244.91,61.71 244.91,60.29 v1(245.24,59.96) U4710.U12 245.65,59.6 v1(246.33,60.28) U4710.Y10 U4710.Y9 246.65,61.29 v1(246.94,61.57) v1(246.94,62.44) 247.26,62.75 U4710.AA5 246.84,63.04 246.73,62.93 246.44,62.93 246.12,63.24 U4710.V4 246.08,63.07 245.39,62.38 245.39,62.14 v1(245.39,62.14) ; v1(239.14,58.88) U4710.D12 ; v1(239.14,58.88) U4710.E13 ; v1(251.48,57.01) 251.07,57.01 U4710.AH17 ; v1(246.83,43.54) 246.56,43.54 246.47,43.44 246.44,43.44 246.4,43.41 246.36,43.41 U4710.V46 ; v1(165.27,88.73) 165.24,88.76 C51160.2 163.95,88.75 C51134.2 ; R67208.1 v1(246.35,79.1) ; U50000.BG34 v4(155.3,136.18) ; v1(196.21,33.76) 196.66,33.31 C307.2 197.04,33.31 197.22,33.13 U1.49 ; v1(239.75,48.44) 239.53,48.44 U4710.E35 ; v1(260.64,49.23) 260.25,49.23 U4710.BG33 ; U50000.V18 U50000.V17 ; U50000.T26 176.63,130.21 176.63,129.65 U50000.T25 ; v4(156.02,128.57) 156.03,128.58 156.08,128.58 156.38,128.88 U50000.BE24 ; CN1700.10 257.85,30.44 257.6,30.69 v1(257.6,30.71) ; C50832.2 213.61,151.38 v1(213.21,150.98) 213.47,150.72 C50755.2 ; v4(189.81,92.31) 189.77,92.31 U51200.L4 ; v4(183.91,171.97) U50500.D3 ; C50960.2 213.2,112.13 v1(212.85,112.47) 213.16,112.79 C51059.2 ; U50500.P11 v4(177.16,165.22) U50500.N12 v4(176.41,165.22) ; 147.68,112.3 C4450.2 ; U50000.AL33 v4(166.55,135.53) U50000.AL34 ; v4(153.24,122.87) 153.22,122.89 153.22,122.89 153.15,123 152.72,123 v4(152.55,122.86) 152.56,122.93 152.38,123.23 U50000.BL16 151.87,123.06 151.84,122.87 v4(151.84,122.86) ; v4(212.13,101.06) U50900.C3 ; C50959.2 v1(213.54,97.08) ; U50000.N10 178.8,118.74 v4(178.67,118.61) ; C51026.2 v1(211.54,127.93) ; CN5.6 v1(42.95,64.98) ; R4600.2 v1(263.28,70.11) ; U1.104 v1(213.19,36.34) ; CN5.15 v1(38.45,64.95)
  BOTTOM w0.279: C51400.2 159.7,92.58 159.53,92.41 C52100.1
  BOTTOM w0.3: U50000.P30 v4(178.47,132.72) U50000.P29 ; U50000.AD37 171.25,138.13 171.25,138.53 U50000.AD38 v4(170.75,139.03) U50000.AD39 ; U50000.T18 v4(177.06,124.33) U50000.T17 ; v4(156.1,140.38) U50000.BE40 ; U50000.BJ19 153.28,125.38 153,125.1 ; 153,125.1 153.01,125.09 153.19,125.09 U50000.BJ18 U50000.BH18 ; 153,125.1 152.62,125.1 v4(152.57,125.14) ; U50000.T21 v4(177.06,127.13) U50000.T22 ; U50000.AT51 U50000.AT52 162.63,148.55 162.63,148.96 v4(162.6,148.99) ; U50000.P28 v4(178.47,131.33) U50000.P27 ; U50000.AD36 v4(170.75,136.93) U50000.AD35 ; U50000.P23 178.44,127.84 178.46,127.84 ; v4(156.01,129.29) 156.1,129.2 156.1,129.18 U50000.BE24 ; v4(177.06,128.53) U50000.T24 ; U50000.T28 v4(177.06,132.03) U50000.T29 ; U50000.T30 v4(177.06,133.43) U50000.T31 ; v4(156.78,124.37) 156.76,124.39 156.69,124.39 U50000.BE18 ; 178.46,127.84 v4(178.47,127.84) ; 178.46,127.84 U50000.P22 ; U50000.V35 v4(175.65,136.23) U50000.V34 ; v4(152.62,133.7) v4(153.19,133.66) ; U50000.BE31 156.69,134.07 v4(156.69,134.09) ; U50000.T36 v4(177.06,136.93) U50000.T35 ; U50000.AB32 v4(172.83,134.13) U50000.AB31 ; U50000.T33 176.56,135.04 176.56,134.62 U50000.T32 ; U50000.Y36 v4(174.24,136.93) U50000.Y35 ; U50000.P38 178.38,138.4 v4(178.38,138.33) ; U50500.E11 177.91,171.97 v4(177.93,171.97) ; v4(152.63,135.78) v4(153.19,135.76) ; U50000.P33 v4(178.47,134.83) U50000.P32 v4(178.47,134.13) U50000.P31 ; U50000.P39 v4(177.75,139.73) ; v4(155.94,123.06) U50000.BE15 ; U50000.AB33 172.39,135.29 172.39,135.77 U50000.AB34 v4(172.83,136.2) U50000.AB35 ; U50000.T20 v4(177.06,125.73) U50000.T19 ; U50000.T26 v4(177.06,130.63) U50000.T27 ; U50000.BE33 v4(155.98,135.59) ; v4(152.62,140) v4(153.15,140.18) ; U50000.P36 v4(178.47,137.63) U50000.P37 ; U50000.P35 v4(178.47,136.23) U50000.P34 ; U50000.V36 v4(175.65,137.63) U50000.V37
  BOTTOM w0.305: 97.66,84.71 98.28,84.71 98.66,84.33 CN4100.73 ; 97.66,84.71 CN4100.69 ; 97.66,84.71 v1(97.66,85.8) ; U51100.H4 v4(169.26,91.59) U51100.G3 ; U51100.H4 v4(170.01,91.59) ; U51100.H4 v4(170.01,92.34) ; U51100.N12 v4(176.01,96.09) ; U51100.N12 v4(175.26,95.34) U51100.M12 v4(175.25,94.59) U51100.L11 ; U51100.N12 v4(175.26,96.09) U51100.P11 ; U51100.A11 v4(175.26,86.34) ; U51100.A11 v4(175.26,87.09) ; U51100.A11 v4(174.52,86.29) ; v4(159.66,161.47) U50600.A2 v4(160.41,162.22) ; U50500.E11 v4(177.15,171.22) U50500.F12 ; v4(213.23,164.03) U50800.U1 v4(213.23,163.21) ; Q53510.4 146.73,102.46 146.4,102.13 v1(146.4,101.96) 146.4,101.76 146.1,101.46 Q53510.1 ; v4(176.4,171.98) U50500.D12 v4(177.16,172.72) U50500.C12 v4(176.4,173.47) ; U50800.E4 v4(204.23,161.71) U50800.F3 ; v4(183.05,96.84) U51200.D12 v4(183.8,97.59) U51200.C12 v4(183.05,98.34) ; v4(210.98,160.96) U50800.P4 v4(210.23,161.71) U50800.N3 ; U50900.T12 v4(202.38,108.56) U50900.R12 ; U50900.N1 v4(203.88,99.56) ; U50900.N1 v4(204.63,100.32) U50900.M1 v4(204.61,99.54) U50900.N1 ; v4(201.23,162.46) U50800.A2 v4(200.48,163.21) ; U50700.R1 v4(202.73,138.16) ; CN4125.185 133.66,68.39 133.59,68.32 133.59,67.71 v1(133.66,67.64) 134.35,67.64 134.72,68.01 134.72,68.48 134.66,68.55 CN4125.189 ; U51100.G3 v4(169.26,90.84) U51100.F3 ; U51100.G3 v4(168.51,90.84) U51100.F3 ; U50700.M12 v4(205.75,146.4) U50700.L11 ; U50700.M12 v4(204.98,146.41) U50700.N12 ; U50700.M12 v4(205.74,147.14) ; v4(213.23,138.16) U50700.B1 v4(213.23,138.91) U50700.A2 ; v4(200.48,147.91) U50700.V13 v4(201.23,147.16) ; U51100.T3 v4(169.26,98.35) ; U51100.T3 v4(169.26,97.59) U51100.R3 ; U51100.T3 v4(168.51,97.59) U51100.R3 ; v4(200.88,124.62) U51000.B1 v4(200.9,125.4) ; v4(205.74,145.66) U50700.L11 ; U50700.L11 v4(206.48,145.66) ; v4(175.26,98.34) U51100.T12 v4(176.01,97.59) U51100.R12 v4(175.26,96.84) U51100.P11 ; CN4125.167 129.16,68.2 128.46,67.51 v1(127.6,67.51) ; U50800.T5 v4(212.48,160.21) ; v4(200.48,156.46) U50800.A11 v4(201.24,155.71) ; U51000.C10 v4(201.65,118.64) ; v1(85.65,77.7) 86.5,76.84 86.5,76.59 86.91,76.18 CN4100.26 ; CN4125.192 135.41,63.31 v1(135.39,63.32) ; CN4125.181 132.66,66.09 132.96,65.78 v1(133.36,65.78) ; CN4125.57 99.66,71.28 99.96,71.58 v1(100.1,71.58) 100.35,71.58 100.66,71.28 CN4125.61 ; v4(159.66,163.72) U50600.D1 v4(158.88,163.74) ; CN4125.251 150.16,68.55 v1(150.21,68.5) ; v4(212.93,110.11) U50900.B14 v4(212.13,109.31) ; v4(212.88,123.12) U51000.V4 ; U51000.V4 v4(213.63,123.12) ; U51000.V4 v4(213.63,122.37) ; v1(169.92,23.06) 168.43,23.06 CN1900.73 ; U50900.A11 v4(213.69,107.82) ; U50900.A11 v4(213.69,107.07) ; U50900.A11 v4(212.89,107.8) ; U50500.L11 v4(177.18,166.74) ; U50500.L11 v4(177.92,166.71) ; U50500.L11 v4(177.91,167.47) ; v1(148.87,108.74) 148.87,108.51 149.01,108.37 C51311.2 ; U50600.V4 v4(161.91,174.97) ; U50600.V4 v4(161.16,174.22) ; U50600.V4 v4(161.16,174.97) ; v1(141.91,64.15) 141.86,64.11 141.86,62.78 141.91,62.74 CN4125.218 ; v1(102.9,80.17) 102.17,80.17 101.66,80.68 CN4100.85 ; v4(169.43,172.72) U50600.R14 v4(168.66,172.72) ; v4(161.91,168.97) U50600.L4 ; v4(177.56,87.04) U51100.B14 v4(176.76,87.84) ; v1(79.7,82.84) 79.98,83.12 CN4100.1 ; CN4100.103 106.16,81.92 106.47,81.62 v1(106.66,81.62) 106.86,81.62 107.16,81.92 CN4100.107 ; v4(185.42,165.21) U50500.N1 ; U50500.N1 v4(184.65,165.94) U50500.M1 v4(185.43,165.95) U50500.N1 ; U51000.F12 v4(204.63,116.37) U51000.G12 v4(204.63,117.12) U51000.F12 ; U51000.F12 v4(203.88,117.12) U51000.E11 v4(203.16,117.87) ; v4(201.63,100.31) U50900.U1 v4(200.88,99.56) ; v1(133.98,76.41) 133.91,76.34 CN4100.206 ; v4(182.28,99.09) U51200.B14 v4(182.28,98.34) ; U51000.M3 v4(209.13,123.87) U51000.N3 ; U51000.M3 v4(208.38,123.12) U51000.L4 v4(207.63,122.37) ; U51000.M3 v4(209.13,123.12) U51000.N3 ; v1(95.44,84.88) 96.22,84.88 96.66,84.44 CN4100.65 ; v1(95.44,84.88) 95.44,84.48 95.66,84.26 CN4100.61 ; v1(95.44,84.88) 94.98,84.88 94.66,84.56 CN4100.57 ; v4(203.89,110.11) U50900.N14 ; U50900.N14 v4(204.63,109.31) ; U50900.N14 v4(204.61,110.1) U50900.M14 v4(205.38,110.07) ; v1(134.34,72.84) 134.91,73.42 CN4100.210 ; v4(210.19,164) U50800.N1 ; U50800.N1 v4(209.48,164) U50800.M1 v4(208.73,163.21) ; U50800.N1 v4(210.23,163.21) ; v4(192.12,87.09) U51200.U1 v4(191.3,87.09) U51200.V2 ; U51100.T10 173.67,97.96 173.63,98 v4(173.6,98) ; CN4125.1 85.66,69.25 85.12,68.72 85.12,68.17 85.42,67.87 85.86,67.87 v1(85.87,67.88) ; U51000.N3 v4(209.88,123.12) U51000.P4 v4(210.63,122.37) ; U50600.N3 v4(161.16,171.22) U50600.P4 v4(161.91,171.97) ; U50600.N3 v4(160.41,170.47) U50600.M3 v4(161.16,170.47) U50600.N3 ; U51200.V2 v4(191.3,86.34) ; U51200.V2 v4(190.55,86.34) ; CN4125.106 111.91,60.18 111.58,59.85 C4802.2 ; v4(213.63,109.31) U50900.A13 v4(212.88,108.56) ; v4(212.11,108.58) U50900.C12 v4(211.38,107.81) U50900.D12 v4(210.63,108.57) ; v4(203.13,116.37) U51000.D12 v4(202.38,117.12) U51000.C12 v4(201.64,116.38) ; v4(201.98,146.41) U50700.T12 ; U50700.T12 v4(202.73,146.41) U50700.R12 ; U50700.T12 v4(202.73,147.16) U50700.R12 ; CN4100.214 135.91,76.64 136.41,77.14 v1(136.51,77.14) 136.66,77.14 137.05,76.75 137.05,76.08 136.91,75.95 CN4100.218 ; U51000.L11 v4(207.62,117.88) ; U51000.L11 v4(208.38,117.87) ; U51000.L11 v4(208.38,117.12) U51000.M12 ; v4(176.76,86.34) U51100.A13 v4(176.01,87.09) ; v4(213.98,146.41) U50700.A11 ; U50700.A11 v4(213.24,146.41) ; U50700.A11 v4(213.98,145.66) ; v1(92.05,66.46) 93.16,67.57 CN4125.31 ; v1(90.05,72.56) 89.16,71.67 CN4125.15 ; v1(105.4,79.55) 104.91,80.04 104.91,81.54 105.16,81.79 CN4100.99 ; U50500.T3 v4(183.16,163.73) U50500.R3 v4(183.9,163.72) U50500.T3 ; U50500.T3 v4(183.16,162.97) ; CN4125.205 138.66,68.49 138.81,68.34 138.81,67.25 138.5,66.94 v1(138.41,66.94) 138.01,66.94 137.66,67.29 CN4125.201 ; CN4100.6 81.91,73.44 81.68,73.21 81.22,73.21 80.91,73.51 CN4100.2 80.91,76.46 ; CN4100.243 143.16,80.84 ; v4(210.98,144.91) 211.46,144.43 212.31,144.43 v4(212.69,144.8) U50700.C10 ; U51000.N12 v4(209.13,117.12) U51000.M12 ; U51000.N12 v4(209.88,117.12) U51000.P11 v4(210.63,117.12) U51000.R12 ; U51000.N12 v4(209.13,116.37) U51000.M12 ; v1(140.01,63.41) 140.01,62.94 139.91,62.84 CN4125.210 ; v1(147.07,63.33) 146.91,63.16 CN4125.238 ; v4(190.55,87.84) U51200.T3 v4(189.8,88.59) U51200.R3 v4(190.55,89.34) ; v4(192.05,98.34) U51200.B1 v4(191.3,99.09) U51200.A2 ; v1(144.12,38.79) 143.92,38.99 143.27,38.99 U702.2 ; v4(201.61,101.8) U50900.T3 ; U50900.T3 v4(202.38,101.07) U50900.R3 ; U50900.T3 v4(202.38,101.81) U50900.R3 ; v4(191.3,96.09) U51200.F1 v4(192.05,95.34) U51200.G1 v4(191.3,94.59) ; v4(211.76,148.68) U50700.D14 v4(211.73,147.91) ; v4(174.9,165.92) U50500.M14 v4(175.66,165.97) U50500.N14 v4(174.9,165.28) ; v4(204.25,139.67) U50700.N3 v4(204.97,140.42) U50700.M3 ; U51100.D3 v4(169.26,88.59) ; CN4100.102 105.91,76.13 106.22,76.43 v1(106.46,76.43) 106.61,76.43 106.91,76.13 CN4100.106 ; v4(201.63,109.31) U50900.U14 v4(200.88,110.07) ; U50800.F3 v4(204.98,162.46) U50800.G3 ; U50800.F3 v4(204.98,161.71) U50800.G3 ; CN4125.226 v1(143.91,63.37) ; CN4125.78 v1(104.91,63) ; CN4100.181 127.66,81.64 v1(127.52,81.5) ; 83.86,84.58 84.16,84.28 CN4100.15 ; v4(200.48,154.96) U50800.A13 v4(201.23,154.19) U50800.B14 v4(201.98,154.19) ; U50800.N14 v4(209.44,153.44) U50800.M14 v4(208.74,154.24) ; U50800.N14 v4(210.23,153.44) ; U50800.N14 v4(210.23,154.21) ; U50900.R3 v4(203.14,101.82) U50900.P4 ; R4835.2 244.77,35.16 v1(244.37,35.56) ; v1(128.73,81.17) 128.66,81.24 CN4100.185 ; v4(213.23,147.16) U50700.A13 v4(213.98,147.91) ; v4(206.48,141.16) U50700.L4 v4(206.48,140.41) ; v4(192.1,88.61) U51200.R1 v4(191.3,88.59) ; CN4125.247 149.16,67.11 149.46,66.81 v1(149.69,66.81) ; CN4100.82 100.91,73.4 v1(101.42,72.9) 101.91,73.4 CN4100.86 ; U50500.G12 v4(177.16,169.72) U50500.H11 ; U50500.G12 v4(176.41,170.47) U50500.F12 ; U50500.G12 v4(177.16,170.47) U50500.F12 ; v4(208.73,145.66) U50700.H11 ; U50700.H11 v4(207.99,145.67) ; U50700.H11 v4(208.73,146.4) U50700.G12 ; v4(181.64,162.98) U50500.T5 v4(181.58,163.73) ; U50500.P4 v4(183.15,164.48) ; U51200.V4 v4(189.8,87.09) ; U51200.V4 189.05,86.33 v4(189.05,86.19) ; U51200.V4 v4(189.8,86.34) ; U51000.N14 v4(209.13,114.77) U51000.M14 v4(208.39,115.65) ; U51000.N14 v4(209.88,115.62) ; U51000.N14 v4(209.88,114.84) ; v4(191.3,91.59) U51200.M1 v4(192.09,90.84) U51200.N1 ; v4(203.13,100.31) U50900.R1 v4(202.38,99.56) ; U51200.H11 v4(184.54,94.59) ; C51310.2 146.56,108.39 146.73,108.56 v1(146.73,108.69) ; v1(169.64,23.57) 169.62,23.55 CN1900.71 ; v4(183.9,165.2) U50500.N3 v4(183.14,165.96) U50500.M3 ; R51423.1 157.5,94.46 v1(157.27,94.24) ; v4(208.73,141.16) U50700.H4 v4(207.98,141.16) ; v1(132.41,79.2) 132.66,79.45 CN4100.201 132.66,84.33 132.94,84.61 133.45,84.61 133.66,84.4 CN4100.205 ; U51000.C5 v4(202.27,121.38) ; CN4125.14 88.91,61.51 88.91,63.11 88.57,63.46 88.1,63.46 v1(87.91,63.27) 87.9,63.26 87.9,62.69 87.91,62.68 CN4125.10 ; U51100.A2 v4(167.76,87.09) U51100.B1 v4(167.01,87.09) ; U51100.A2 v4(168.51,86.34) ; U51100.A2 v4(167.76,86.34) ; U51100.G12 v4(176.01,90.84) U51100.F12 ; U51100.G12 v4(175.25,91.59) U51100.H11 ; U51100.G12 v4(175.26,90.84) U51100.F12 ; v1(142.75,63.96) 142.96,63.75 142.96,62.82 142.91,62.77 CN4125.222 ; U60250.18 v1(61.62,79.45) ; U51100.H11 v4(174.51,91.59) ; U51100.H11 v4(174.51,92.34) ; U50900.L11 v4(205.38,107.8) U50900.M12 v4(204.63,107.81) U50900.N12 ; U50900.L11 v4(206.13,107.06) ; U50900.L11 v4(205.38,107.08) ; CN4125.51 98.16,68.76 96.89,67.49 v1(96.8,67.49) ; v4(213.23,161.71) U50800.V4 ; U50800.V4 v1(213.98,160.96) ; U50800.V4 v1(213.98,161.71) ; v1(94.28,63.4) 94.41,63.28 CN4125.36 ; v1(88.6,81.55) 88.79,81.55 89.16,81.93 CN4100.35 89.16,84.32 89.46,84.62 ; v4(183.05,89.34) U51200.R12 ; U51200.R12 v4(183.8,89.34) U51200.P11 v4(183.8,90.09) U51200.N12 ; U51200.R12 v4(183.8,88.59) U51200.T12 v4(183.05,87.84) ; R53520.2 C53520.2 v1(141.36,104.27) ; U50600.F12 v4(167.16,165.22) U50600.E11 v4(166.41,164.47) ; U50600.F12 v4(167.16,165.97) U50600.G12 v4(167.91,165.97) U50600.F12 ; U50500.T12 v4(177.16,163.72) U50500.R12 ; U50500.T12 v4(177.16,162.97) ; U50500.T12 v4(176.41,163.72) U50500.R12 ; U50800.C12 v4(201.98,154.96) ; U51100.C5 v4(170.76,87.84) ; v1(142.03,79.64) 142.16,79.77 CN4100.239 ; D283.3 132.08,33.53 v1(131.52,32.97) ; v4(213.79,116.36) U51000.V13 ; U51000.V13 v4(213.79,115.61) ; U51000.V13 v4(212.89,115.63) U51000.U14 v4(212.97,114.81) ; v1(130.32,63.58) 130.41,63.5 CN4125.172 ; U50900.G12 v4(209.13,107.81) U50900.F12 v4(209.13,108.56) U50900.G12 ; U50900.G12 v4(208.38,107.81) U50900.H11 ; v1(100.41,62.86) CN4125.60 ; R50906.2 203.41,97.36 203.29,97.48 v1(203.26,97.48) ; v4(212.49,141.91) U50700.C5 ; R51106.2 v1(164.79,97.21) ; v4(183.8,99.09) U51200.A11 v4(184.55,99.84) ; v1(280.87,58.48) 279.86,58.48 C7014.2 C131.2 ; v4(211.73,163.21) U50800.R1 v4(211.71,164.02) ; v4(189.05,93.83) U51200.H4 v4(189.78,94.56) U51200.G3 v4(190.55,95.34) U51200.F3 v4(189.8,96.09) U51200.E4 ; v4(210.98,147.16) U50700.D12 v4(211.74,146.4) U50700.C12 v4(212.48,147.16) ; C4117.2 v1(120.11,86.77) 119.5,86.77 119.2,86.47 C4118.2 ; CN4125.193 135.66,68.65 136.13,68.18 136.13,67.75 135.66,67.27 v1(135.62,67.27) ; U51000.N1 v4(209.84,125.41) ; U51000.N1 v4(209.13,125.4) U51000.M1 ; U51000.N1 v4(209.88,124.62) ; CN4100.68 97.41,73.5 97.76,73.15 98.28,73.15 v1(98.41,73.28) CN4100.72 ; v4(176.76,99.84) U51100.V13 v4(176.01,99.09) ; U50900.H11 v4(207.63,107.06) ; U50900.H11 v4(208.38,107.06) ; CN4100.223 138.16,81.85 138.08,81.77 138.08,80.79 138.61,80.25 v1(138.78,80.25) 138.95,80.25 139.31,80.61 139.31,81.52 139.16,81.66 CN4100.227 ; U50800.G14 v4(204.97,153.41) U50800.F14 v4(204.23,154.19) ; v1(136.5,120.69) 136.5,121.07 C4594.2 ; U50700.R12 v4(203.48,146.41) U50700.P11 v4(204.23,146.41) U50700.N12 ; v4(159.66,174.97) U50600.V2 v4(160.41,174.97) ; v4(178.66,173.47) U50500.C10 ; CN4125.47 97.16,71.31 96.75,71.71 v1(96.57,71.71) 96.55,71.71 96.16,71.32 CN4125.43 ; v1(148.17,67.52) 148.16,67.53 CN4125.243 ; C4106.2 v1(106.69,87.23) ; R51422.1 155.12,84.84 v1(155.46,85.18) ; U50800.C10 v4(201.99,157.42) ; v4(211.73,153.44) U50800.R14 v4(211.73,154.21) ; U50600.M12 v4(167.16,169.72) U50600.L11 ; U50600.M12 v4(167.91,170.47) U50600.N12 ; U50600.M12 v4(167.16,170.47) U50600.N12 ; v1(89.8,63.05) 89.91,62.94 CN4125.18 ; v4(211.73,138.91) U50700.D1 ; U50700.D1 v4(210.98,138.91) ; U50700.D1 v4(211.73,138.16) ; C351.1 R322.1 ; CN4125.223 143.16,67.79 v1(143.1,67.73) ; C65.2 v1(197.35,42.52) ; v1(124.37,84.93) 124.68,84.93 125.16,84.45 CN4100.171 ; v4(202.38,115.6) U51000.D14 v4(202.41,114.82) ; CN4125.35 94.16,68.88 93.64,68.35 93.64,67.79 93.94,67.49 v1(94.18,67.49) 94.44,67.49 95.16,68.21 CN4125.39 ; v1(147.25,112.3) 147.68,112.3 ; CN4100.238 141.91,75.87 142.07,76.03 v1(142.07,76.91) ; C1901.2 v1(177.87,42.25) ; U60400.2 v5(77.95,60.22) ; U50800.N3 v4(209.48,162.46) U50800.M3 ; U50800.N3 v4(209.48,161.71) U50800.M3 ; v4(175.66,173.47) U50500.B14 v4(174.86,174.27) ; CN4125.44 96.41,63.17 95.86,63.72 v1(95.85,63.72) ; v1(133.95,80.69) 134.2,80.69 134.66,81.16 CN4100.209 ; U51200.C3 v4(190.55,98.34) ; CN4125.188 134.41,63.53 134.48,63.6 134.48,64.21 v1(133.96,64.73) ; CN4125.40 v1(95.41,62.89) ; v4(190.55,96.84) U51200.D3 ; U702.1 144.27,39.5 v1(144.68,39.09) ; U50600.N12 v4(167.16,171.22) U50600.P11 v4(167.16,171.97) U50600.R12 ; v4(185.41,174.22) U50500.B1 v4(184.66,174.22) U50500.A2 ; v4(203.48,156.46) U50800.E11 v4(204.23,155.71) U50800.F12 ; v4(165.43,172.92) 165.49,172.92 U50600.T10 v4(166.41,172.72) ; CN4100.189 129.66,80.45 130.88,79.24 131.16,79.24 v1(131.16,79.23) ; CN4125.202 137.91,63.74 138.43,64.27 v1(138.54,64.27) 138.72,64.27 139.21,63.77 139.21,63.13 138.91,62.82 CN4125.206 ; v1(209.57,21.23) 209.29,21.5 C315.2 ; CN4125.217 141.66,66.29 142.22,65.73 v1(142.85,65.73) ; v1(90.31,81.76) 90.31,81.76 90.16,81.9 CN4100.39 ; v4(158.86,172.7) U50600.R1 v4(159.66,172.72) ; U50500.R12 v4(177.16,164.47) U50500.P11 ; v4(212.48,154.96) U50800.T12 v4(211.73,155.71) U50800.R12 ; R393.1 214.88,21.14 v1(214.65,20.91) ; U50500.A11 v4(177.91,174.97) ; U50500.A11 v4(177.15,174.23) ; U50500.A11 v4(177.16,174.97) ; v4(182.41,168.97) U50500.H4 v4(182.41,169.72) ; v4(168.7,163.73) U50600.D14 v4(169.46,163.75) ; U51200.N12 v4(183.05,90.84) U51200.M12 ; U51200.N12 v4(183.8,90.84) U51200.M12 ; U50600.L11 v4(166.4,168.96) ; U50600.L11 v4(166.41,169.72) ; U51200.N3 v4(189.8,90.84) U51200.M3 ; U51200.N3 v4(189.8,90.09) U51200.P4 v4(189.05,89.34) ; U51200.N3 v4(190.55,90.84) U51200.M3 ; CN4100.40 90.41,73.41 90.67,73.15 90.67,72.1 v1(90.57,72) 90.57,71.59 90.16,71.18 CN4125.19 ; R50806.2 205.04,166.16 v1(204.58,165.7) ; U51400.4 152.91,87.18 v1(152.91,87.23) ; U50800.M3 v4(208.73,161.71) U50800.L4 v4(207.98,160.96) ; U50700.V2 v4(201.23,139.66) ; U51000.V2 v4(212.88,124.62) U51000.U1 v4(212.88,125.43) ; U51000.V2 v4(213.63,123.87) ; U51000.V2 v4(213.63,124.62) ; v4(202.73,163.21) U50800.D1 v4(202.75,163.99) ; CN4100.230 139.91,76.69 140.54,77.31 v1(140.62,77.31) 140.87,77.31 141.17,77.01 141.17,76.17 140.91,75.91 CN4100.234 ; v4(174.5,94.6) U51100.L11 ; U51100.L11 v4(174.51,93.84) ; U51100.P4 v4(169.27,96.83) U51100.R3 ; v1(213.98,163.21) U50800.V2 v1(213.98,162.46) ; U50800.V13 v4(213.23,154.21) U50800.U14 v4(213.32,153.41) ; U50800.V13 v1(214.3,154.24) ; U50800.V13 v1(214.3,154.99) ; CN4125.168 129.41,63.24 v1(129.49,63.32) ; U50900.F1 v4(209.13,99.56) U50900.G1 ; U50900.F1 v4(209.88,100.31) ; U50900.F1 v4(209.89,99.5) ; CN4125.68 102.41,63.17 v1(101.35,64.22) ; U50900.G3 v4(209.13,101.06) U50900.F3 ; U50900.G3 v4(208.38,101.81) U50900.H4 ; U50900.G3 v4(209.13,101.81) U50900.F3 ; U51100.F12 v4(175.26,90.09) U51100.E11 v4(174.51,89.34) ; U50900.D1 v4(211.38,99.56) ; U50900.D1 v4(211.38,100.31) ; U50900.D1 v4(210.63,100.31) ; U50900.L4 v4(206.13,102.56) ; 110.16,68.42 CN4125.99 ; CN4125.22 90.91,62.81 90.7,63.02 v1(90.7,64.19) ; v1(102.51,64.34) 103.41,63.44 CN4125.72 ; CN4125.69 102.66,68.48 v1(102.51,68.33) ; U51200.L11 v4(183.8,91.59) U51200.M12 ; U51200.L11 v4(184.56,92.36) ; U51200.L11 v4(184.55,91.59) ; v4(169.44,171.22) U50600.N14 v4(168.66,171.22) ; v4(166.41,174.97) U50600.V11 v4(167.16,174.22) ; v1(90.62,67.03) 91.09,67.03 92.16,68.1 CN4125.27 ; v4(169.41,170.48) U50600.M14 v4(168.63,169.73) ; CN4100.23 v1(86.16,86.13) 85.65,86.13 85.16,85.64 CN4100.19 ; v4(200.13,101.81) U50900.V4 v4(200.13,102.56) ; v4(200.13,124.62) U51000.A2 v4(200.88,123.87) ; v4(175.26,99.84) U51100.V11 174.55,99.13 v4(174.55,99.1) ; U51000.G14 v4(204.65,114.85) U51000.F14 v4(203.9,115.6) ; v1(131.35,63.31) 131.35,62.87 131.41,62.81 CN4125.176 ; v4(212.13,116.38) U51000.T12 v4(211.38,117.12) U51000.R12 ; v4(167.76,96.84) U51100.R1 v4(167.01,96.84) ; v4(167.16,162.22) U50600.A11 v4(166.41,161.47) ; U50800.L11 v4(208.73,155.71) 208.85,155.6 U50800.M12 v4(209.48,154.96) U50800.N12 ; U50800.L11 v4(208.73,156.46) ; U50800.L11 v4(207.97,156.47) ; 93.41,76.05 92.2,77.26 v1(92.17,77.26) ; 93.41,76.05 CN4100.52 ; 93.41,76.05 94.11,76.05 94.39,75.76 94.39,74.68 CN4100.56 ; CN4100.184 128.41,76.89 v1(128.58,77.06) ; v4(203.13,107.81) U50900.P11 v4(203.88,107.81) U50900.N12 ; v4(202.73,148.67) U50700.R14 v4(203.48,147.91) ; CN4125.48 v1(97.41,62.89) ; U51100.D1 167.77,88.6 v4(167.76,88.59) ; U51100.D1 v4(167.01,88.59) ; U51100.D1 v4(167.76,89.34) ; v4(158.88,162.24) U50600.B1 v4(159.66,162.22) ; v4(210.63,101.06) U50900.D3 v4(211.38,101.81) U50900.C3 ; v4(211.73,140.41) U50700.C3 v4(212.48,139.66) ; U51200.N1 v4(191.3,90.09) ; U51200.N1 v4(192.09,90.13) ; v4(168.66,175.13) U50600.V13 ; U50600.V13 v4(168.66,174.22) U50600.U14 v4(169.46,174.34) ; U50600.V13 v4(167.91,175.13) ; CN4100.193 130.66,81.8 130.6,81.74 130.6,81.06 131.03,80.63 v1(131.18,80.63) 131.29,80.63 131.78,81.12 131.78,81.69 131.66,81.81 CN4100.197 ; v4(182.3,88.59) U51200.R14 v4(181.53,88.59) ; v4(161.91,167.47) U50600.H4 v4(161.18,166.74) U50600.G3 v4(160.41,165.97) U50600.F3 v4(161.16,165.22) U50600.E4 ; v4(181.5,97.56) U51200.D14 v4(182.3,97.6) ; C706.2 v1(140.78,41.08) ; v4(213.98,139.66) U50700.A2 ; U50700.A2 v4(213.98,138.91) ; v1(124.52,73.26) 124.41,73.37 CN4100.168 ; v4(183.05,95.34) U51200.G12 v4(183.8,95.34) U51200.F12 v4(183.8,96.09) U51200.E11 v4(184.55,96.81) ; U51100.F14 v4(177.57,90.84) U51100.G14 ; U51100.F14 v4(176.76,90.09) ; U51100.F14 v4(177.52,90.08) ; U51200.T5 v4(188.23,87.66) ; v4(175.66,164.47) U50500.R14 ; U51200.G14 v4(181.55,95.34) U51200.F14 v4(182.28,96.07) ; CN4100.9 82.66,84.58 v1(82.01,84.58) 81.66,84.23 CN4100.5 ; U51200.N14 v4(181.52,90.09) ; U51200.N14 v4(182.3,90.09) ; U51200.N14 v4(181.44,90.83) U51200.M14 v4(182.33,91.58) ; v4(177.52,94.59) U51100.M14 v4(176.76,95.34) U51100.N14 ; CN4125.98 109.91,62.83 109.93,62.85 v1(109.93,62.86) ; CN4100.235 141.16,84.32 140.87,84.62 140.39,84.62 140.17,84.4 140.17,83.12 CN4100.231 140.16,81.51 140.12,81.46 140.12,80.68 140.5,80.3 v1(140.7,80.3) ; CN4100.77 99.66,84.95 98.69,85.92 v1(98.37,85.92) ; U50700.N12 v4(204.23,147.16) ; v4(201.98,162.46) U50800.C3 ; U50900.C5 v4(212.14,103.32) ; U50700.G12 v4(209.48,146.41) U50700.F12 ; U50700.G12 v4(209.48,147.15) U50700.F12 ; CN4125.23 v1(91.16,71.5) 91.16,71.61 91.41,71.86 CN4100.44 ; v4(210.98,145.66) U50700.E11 v4(210.23,146.41) U50700.F12 ; v1(131.12,76.42) 130.91,76.42 130.41,75.92 CN4100.192 ; v4(201.64,103.32) U50900.T5 v4(202.17,103.43) ; v4(212.88,117.12) U51000.V11 v4(213.63,117.87) ; v4(176.01,89.34) U51100.D12 v4(175.26,88.59) ; v1(127.6,76.36) 127.58,76.33 127.41,76.17 CN4100.180 ; v4(212.48,162.46) U50800.T3 v4(211.73,161.71) U50800.R3 v4(210.98,162.46) ; v4(210.63,123.87) U51000.R3 v4(211.38,123.12) U51000.T3 v4(212.13,123.87) ; CN4100.64 96.41,72.81 v1(95.88,72.28) 95.41,72.74 CN4100.60 ; CN1900.75 v1(169.59,22.55) ; v4(204.23,163.96) U50800.F1 ; U50800.F1 v4(204.23,163.21) ; U50800.F1 v4(204.98,163.96) U50800.G1 v4(205.73,163.21) ; CN4125.65 101.66,68.8 v1(100.99,68.13) ; v1(132.3,63.52) 132.46,63.36 132.46,62.78 132.41,62.73 CN4125.180 ; v1(206.87,136.64) 206.87,136.36 R50706.2 ; U50800.N12 v4(210.23,155.71) U50800.P11 v4(210.98,155.71) U50800.R12 ; U50800.N12 v4(209.48,155.71) ; v4(202.73,154.19) U50800.D14 v4(202.76,153.41) ; v4(189.8,99.09) U51200.A4 v4(189.8,99.84) ; U50900.B1 v4(212.88,100.31) U50900.A2 ; CN4125.230 144.91,64.69 v1(144.83,64.77) ; v1(108.66,66.42) 108.66,66.42 CN4125.93 ; R51321.2 143.51,109.3 v1(143.38,109.3) ; v4(211.52,118.99) U51000.T10 v4(211.38,117.87) ; CN4125.86 v1(106.91,63.05) ; v1(136.36,64.16) 136.41,64.11 CN4125.196 ; v4(201.95,141.92) U50700.T5 v4(202.53,142) ; R316.2 207.29,21.73 R342.2 207.51,21.49 207.82,21.19 v1(208.02,21.19) ; U51100.V2 v4(168.51,99.09) ; v4(167.01,98.34) U51100.U1 v4(167.76,98.34) ; CN4100.98 104.91,72.42 v1(104.24,71.75) 104.66,71.33 CN4125.77 ; v4(211.38,114.85) U51000.R14 v4(211.38,115.62) ; v4(176.43,166.74) U50500.M12 ; v4(201.21,145.68) U50700.V11 v4(200.48,146.41) ; v1(284.5,21.39) 284.45,21.34 284.45,20.08 CN1300.51 ; v1(87.25,67.87) 87.66,68.28 CN4125.9 ; v4(167.91,173.47) U50600.T12 v4(167.16,172.72) U50600.R12 ; v4(213.63,101.06) U50900.A2 ; U50900.A2 v4(213.63,100.31) ; v4(183.05,99.84) U51200.A13 ; U51100.M3 v4(169.27,95.35) U51100.N3 v4(168.52,96.07) ; v4(182.41,174.97) U50500.A4 v4(183.16,174.22) ; v4(201.98,140.41) U50700.T3 v4(202.73,140.4) U50700.R3 v4(203.49,140.41) U50700.P4 ; v4(201.23,148.67) U50700.U14 v4(201.98,147.91) ; v1(128.68,78.38) 128.68,78.37 128.9,78.37 129.41,77.85 CN4100.188 ; 100.37,84.95 100.66,84.66 CN4100.81 100.66,81.52 99.75,80.61 v1(99.37,80.61) ; CN4100.18 84.91,73.49 v1(84.32,72.89) 83.91,73.3 CN4100.14 ; U51100.P11 v4(174.53,96.84) ; CN4100.196 v1(131.41,73.25) 132.65,73.25 132.91,73.51 CN4100.202 ; R2410.1 293.33,20.59 v1(293.33,20.83) ; v4(170.78,97.61) U51100.T5 v4(170.77,98.33) ; v4(210.23,138.91) U50700.F1 v4(209.48,138.16) U50700.G1 v4(208.73,138.91) ; U51000.H11 v4(205.4,117.85) ; v4(204.96,138.92) U50700.M1 v4(204.96,138.13) U50700.N1 v4(204.23,138.16) ; U51200.A2 v4(190.55,99.09) ; U51200.A2 v4(191.3,99.84) ; CN4100.226 138.91,76.12 138.98,76.18 138.98,77.18 v1(138.69,77.47) 138.2,77.47 137.83,77.1 137.83,76.33 137.91,76.25 CN4100.222 ; v1(89.75,135.54) 90.09,135.21 U4555.BK25 U4555.BJ25 ; U51100.F3 v4(169.26,90.09) U51100.E4 v4(170.01,89.34) ; U50500.V4 v4(183.16,161.47) ; U50500.V4 v4(182.41,162.22) ; U50500.V4 v4(182.41,161.47) ; U702.32 142.54,40.79 v1(142.82,41.08) 142.82,41.4 R704.1 ; v1(167.26,28.58) 167.28,28.55 CN1900.51 ; 90.86,84.62 91.16,84.31 CN4100.43 ; U50700.G14 v4(209.5,148.64) ; v4(210.98,154.96) U50800.R12 ; v1(108.9,62.9) 108.91,62.89 CN4125.94 ; v1(91.91,62.98) CN4125.26 ; CN4125.227 144.16,68.35 144.08,68.27 144.08,67.73 144.6,67.21 v1(144.61,67.21) ; v4(182.3,86.19) U51200.V13 v4(183.05,86.19) ; v4(213.23,140.41) U50700.A4 v4(213.98,141.16) ; U50900.G14 v4(209.13,110.12) U50900.F14 ; C1902.2 v1(178.76,42.25) ; CN4100.10 82.91,76.79 83.47,77.35 v1(84.07,77.35) ; v4(184.66,169.72) U50500.G1 v4(185.41,170.47) U50500.F1 v4(184.66,171.22) ; CN4100.89 102.66,80.98 v1(102.65,80.96) 103.36,80.96 103.66,81.27 CN4100.93 ; CN4125.239 147.16,66.92 146.31,66.07 v1(146.06,66.07) ; U50500.H11 v4(177.91,168.97) ; U50500.H11 v4(177.91,169.72) ; v4(201.64,115.6) U51000.B14 v4(200.89,115.59) U51000.A13 v4(200.13,116.37) ; v4(202.38,110.07) U50900.R14 v4(203.13,109.31) ; v4(202.38,124.62) U51000.D1 v4(202.36,125.4) ; CN4100.22 85.91,73.14 85.42,72.65 v1(85.42,71.71) 86.23,71.71 86.66,71.28 CN4125.5 ; v4(211.38,109.31) U50900.D14 v4(211.41,110.09) ; v1(143.46,73) 145.12,73 145.41,73.29 CN4100.252 ; v4(168.68,162.95) U50600.B14 v4(168.68,162.22) U50600.A13 v4(167.91,161.47) ; v4(169.26,99.84) U51100.V4 v4(170.01,99.84) ; U51200.C5 v4(188.03,97.38) ; v4(167.75,90.1) U51100.F1 v4(167.01,90.84) U51100.G1 v4(167.76,91.59) ; v4(176.41,162.22) U50500.V13 ; v4(213.28,148.71) U50700.B14 v4(212.48,147.91) ; v4(204.99,148.67) U50700.M14 v4(204.98,147.91) U50700.N14 v4(204.31,148.72) ; CN1300.75 290.45,21.23 v1(290.39,21.29) ; v4(176.41,174.22) U50500.A13 v4(175.66,174.97) ; v4(175.66,172.72) U50500.D14 v4(174.88,172.75) ; CN4125.209 139.66,67.29 140.19,66.76 v1(140.34,66.76) ; U50600.D3 v4(160.41,164.47) ; U4555.G16 122.91,128.24 v1(123.24,127.91) 123.24,127.84 U4555.F15 ; CN4125.244 148.41,63.12 v1(148.29,63.24) ; v4(170.01,86.34) U51100.A4 v4(169.26,87.09) ; U50800.D3 v4(203.48,162.46) ; v4(174.85,170.47) U50500.G14 ; U51000.F1 v4(204.63,125.37) U51000.G1 v4(205.38,124.62) ; U51000.F1 v4(203.88,124.62) ; U51000.F1 v4(203.88,125.37) ; v4(209.9,110.08) U50900.F14 ; U50900.F14 v4(209.88,109.31) ; U50700.F3 v4(209.48,140.41) U50700.G3 v4(209.48,139.66) U50700.F3 ; U50700.F3 v4(210.23,140.41) U50700.E4 v4(210.98,141.16) ; U50800.D12 v4(202.73,155.71) ; CN4100.176 126.41,76.69 125.62,77.48 v1(125.4,77.48) ; v4(182.41,171.97) U50500.E4 v4(183.16,171.22) U50500.F3 v4(183.16,170.47) U50500.G3 v4(183.91,170.47) ; U50900.C10 v4(212.37,106.19) ; CN4125.234 v1(145.91,63.44) ; v4(173.67,87.61) U51100.C10 ; v4(176.76,98.34) U51100.U14 v4(177.52,98.34) ; CN4125.235 146.16,71.13 145.95,71.34 145.37,71.34 145.16,71.13 CN4125.231 145.16,68.3 145.87,67.59 v1(145.89,67.59) ; U51000.E4 v4(203.88,123.12) U51000.F3 v4(204.63,123.87) U51000.G3 v4(205.38,123.12) U51000.H4 ; U50500.A2 v4(184.66,174.97) ; U50500.A2 v4(183.91,174.97) ; U50900.F3 v4(209.88,101.81) U50900.E4 v4(210.63,102.56) ; CN4125.81 105.66,68.72 104.68,67.75 v1(104.47,67.75) ; CN4125.2 85.91,62.92 85.62,63.2 85.62,63.94 85.93,64.24 86.55,64.24 v1(86.56,64.24) 86.81,63.99 86.91,63.76 CN4125.6 ; v4(167.91,171.97) U50600.R12 ; C2402.2 294.13,22.55 C2403.2 v1(294.1,23.29) ; U50000.V39 v4(175.63,139.04) 175.3,138.71 U50000.V38 ; v4(158.84,174.22) U50600.U1 v4(159.66,174.22) ; v1(92.13,80.16) 93.16,81.19 CN4100.51 ; U50800.F12 v4(204.98,154.96) U50800.G12 v4(204.98,155.71) U50800.F12 ; 81.24,76.78 v1(81.56,76.78) ; v4(200.48,140.41) U50700.V4 v4(200.48,141.16) ; CN4125.248 149.41,62.76 149.34,62.82 149.34,63.3 v1(149.9,63.86) 150.49,63.28 150.49,62.78 150.41,62.69 CN4125.252 ; v4(192.04,96.85) U51200.D1 v4(191.3,97.59) ; U50600.H11 v4(166.44,166.73) ; v4(161.91,163.72) U50600.C5 ; R51206.2 194.26,95.61 193.93,95.94 v1(193.93,96) ; v4(177.54,96.84) U51100.R14 v4(176.76,96.84) ; U51200.M3 v4(189.8,91.59) U51200.L4 v4(189.05,92.34) ; U50800.G3 v4(205.75,161.7) U50800.H4 v4(206.48,160.96) ; C4104.2 143.87,84.72 144.16,84.42 CN4100.247 144.16,81.61 v1(144.31,81.46) ; U51000.R12 v4(210.63,116.37) ; U50900.N12 v4(203.88,108.56) ; v4(203.86,101.07) U50900.N3 v4(204.62,101.83) U50900.M3 ; CN4125.52 98.41,62.67 98.36,62.71 98.36,63.27 v1(98.45,63.35) 98.53,63.43 99.05,63.43 99.41,63.07 CN4125.56 ; CN4125.171 130.16,68.42 130.06,68.32 v1(130.06,68.27) ; CN4125.73 103.66,67.59 v1(102.5,66.43) ; v4(201.23,161.71) U50800.A4 v4(200.48,161.71) ; v4(184.55,86.35) U51200.V11 v4(183.83,87.06) ; v1(92.22,64.23) 92.22,63.91 92.91,63.22 CN4125.30 ; v4(182.3,87.09) U51200.U14 v4(181.52,87.02) ; v4(161.16,162.22) U50600.A4 v4(161.16,161.47) ; CN4100.31 88.16,84.23 87.81,84.58 v1(86.95,84.58) 87.16,84.36 CN4100.27 ; CN4100.244 143.41,76.72 ; v4(209.88,107.81) U50900.E11 v4(210.63,107.06) ; U51000.D3 v4(203.13,123.87) ; CN4100.48 92.41,75.85 90.82,77.45 v1(90.54,77.45) ; U50500.C5 v4(181.65,173.48) ; U50600.T5 v4(162.66,173.47) ; 143.96,80.04 v1(144.31,80.04) ; v1(131.23,68.11) 131.16,68.19 CN4125.175 ; CN4125.85 v1(106.66,67.99) 107.11,67.99 107.66,68.54 CN4125.89 ; CN4125.103 111.16,68.59 v1(111.39,68.36) 111.57,68.54 111.83,68.54 112.13,68.85 112.13,69.93 CN4125.107 ; v1(99.59,76.37) 99.91,76.05 CN4100.78 ; v4(160.41,173.47) U50600.T3 v4(161.16,172.72) U50600.R3 v4(160.41,171.97) ; v4(159.66,165.22) U50600.F1 v4(158.91,165.97) U50600.G1 v4(159.66,166.72) ; U4555.H22 U4555.J22 ; U50800.T10 v4(211.5,157.45) ; U50900.T10 v4(202.2,106.05) ; v4(170.01,93.87) U51100.L4 ; C51400.2 v1(159.7,93.29) ; CN1900.G2 v1(170.93,21.45) ; v1(263.57,36.68) 263.59,36.69 263.73,36.55 263.78,36.55 263.83,36.5 ; U50500.L4 v4(182.41,167.47) ; CN4125.90 v1(107.91,62.87) ; v1(104.44,65.03) 105.91,63.56 CN4125.82 ; v4(201.25,163.99) U50800.B1 v4(201.23,163.21) ; v4(177.88,162.2) U50500.V11 ; v5(79.37,59.44) C60410.2 ; v1(127.57,79.41) 126.98,79.41 126.16,80.23 CN4100.175 ; U50500.T10 v4(178.85,163.78) ; U50500.C3 v4(183.16,172.72) U50500.D3 ; CN4100.248 v1(144.41,76.02) ; CN4100.47 92.16,81.56 90.73,80.12 v1(90.46,80.12) ; v4(200.13,107.81) U50900.V11 v4(200.86,107.08) ; v4(183.91,162.22) U50500.V2 v4(184.66,161.47) ; U50600.C3 v4(160.41,162.97) ; CN4125.214 140.91,64.24 v1(140.31,64.84) ; v4(185.39,98.51) U51200.C10 ; U51100.C3 v4(168.51,87.84) ; v4(211.38,124.62) U51000.R1 v4(211.36,125.42) ; CN1901.9 74.89,37.05 v1(74.88,37.04) ; v1(258.29,72.62) 258.37,72.55 R4853.1 ; CN4125.197 136.66,68.73 136.89,68.5 136.89,66.84 v1(136.99,66.74) ; v1(140.59,68.28) 140.59,68.35 140.66,68.42 CN4125.213 ; U51200.T10 v4(185.4,88.58) ; v4(176.01,87.84) U51100.C12 ; v4(200.13,109.31) U50900.V13 v4(200.88,108.56) ; v4(174.89,171.24) U50500.F14 v4(175.66,171.22) ; CN4125.184 v1(133.41,63.3) ; 144.06,77.37 144.4,77.37 v1(144.4,77.37) ; v4(185.44,162.22) U50500.U1 v4(184.66,162.97) ; R51421.1 v1(153.62,95.61) ; U66610.6 v1(144.14,169.42) ; v4(213.23,155.71) U50800.V11 v1(214.28,156.71) ; U50700.U1 v4(201.26,138.13) ; CN4125.64 v1(101.41,62.89) ; U50900.H4 v4(208.38,102.56) ; U50900.H4 v4(207.63,102.56) ; v4(200.13,117.87) U51000.A11 v4(200.88,117.12) ; U50600.G14 v4(169.41,165.97) U50600.F14 v4(168.68,165.24) ; U50700.T10 v4(202.37,144.68) ; CN4100.167 124.16,81.14 125.2,80.1 v1(125.25,80.1) ; U51000.C3 v4(201.63,123.87) ; v4(205.75,156.45) U50800.H11 ; v4(177.52,88.57) U51100.D14 v4(176.76,88.6) ; CN4100.90 102.91,73.5 102.71,73.3 v1(102.71,72.75) 103.33,72.75 103.91,73.33 CN4100.94 ; v1(110.91,62.89) CN4125.102 ; v1(136.52,80.13) 136.66,80.28 CN4100.217 136.66,84.28 136.36,84.59 135.92,84.59 135.66,84.33 CN4100.213 ; U4555.G18 U4555.H18 U4555.J18 ; U50700.D3 v4(210.98,139.66) ; v4(167.91,162.97) U50600.C12 v4(167.16,163.72) U50600.D12 ; CN1900.21 v1(169.77,36.05) ; v1(169.64,39.05) CN1900.9 ; v1(141.64,100.12) U53520.3 ; CN4100.251 v1(145.16,80.54) ; v4(200.88,101.06) U50900.V2 ; U51000.T5 v4(212.13,121.62) ; CN4100.36 v1(89.41,73.27) 89.41,73.26 88.16,73.26 87.91,73.51 CN4100.30 ; v4(210.23,147.91) U50700.F14 v4(210.25,148.67) ; C321.1 v1(198.24,42.51) ; CN4100.172 125.41,76.02 v1(125.37,76.07) ; U51000.A4 v4(200.13,123.12) ; U50600.C10 v4(165.66,162.98) ; U50500.R1 v4(185.41,163.72) ; v4(175.66,162.97) U50500.U14 ; v4(167.76,95.37) U51100.N1 v4(166.99,95.36) U51100.M1 v4(167.76,95.37)
  BOTTOM w0.33: U66040.28 127.65,170.85 127.28,170.49 ; CN1900.1 169.09,41.05 169.1,41.05 169.37,41.05 169.59,40.82 v1(169.59,40.55) CN1900.3 ; C66037.2 116.94,170.46 117.28,170.8 U66030.28 ; U66020.4 v1(109.5,173.76) ; v1(36.95,64.37) 36.8,64.37 36.43,64.74 36.43,66.03 CN5.19 ; v1(304.57,55.53) D56220.3 D56220.8 ; C66017.2 96.22,170.7 96.32,170.8 U66010.28 ; CN4125.22 90.91,60.19 ; C66027.2 106.73,170.67 106.87,170.81 U66020.28 ; v1(144.17,36.3) 143.97,36.5 U702.7 ; CN4125.94 108.91,60.15 ; CN4125.40 95.41,60.17 ; v1(137.5,38.77) 137.73,39 U702.23 ; CN4125.68 102.41,60.13 ; CN4125.18 89.91,60.1 ; CN4125.78 104.91,60.21 ; D7503.3 D7503.8 309.11,14.51 v1(309.17,14.57) ; CN4125.64 101.41,60.12 ; v1(137.49,36.4) 137.58,36.5 U702.18 ; v1(304.42,52.07) D56225.3 D56225.8 ; CN4125.14 88.91,60.18 ; CN4125.60 100.41,60.28 ; CN5.18 v1(36.95,64.96) ; CN4125.6 86.91,60.18 ; v1(170.63,37.77) 170.41,37.55 CN1900.15 ; CN4125.86 106.91,60.08 ; CN4125.36 94.41,60.13 ; CN4125.52 98.41,60.19 ; CN4125.82 105.91,60.12 ; CN4125.98 109.91,60.18 ; CN4125.10 87.91,60.11 ; U66040.4 v1(130.28,173.81) ; CN4125.26 91.91,60.14 ; CN4125.56 99.41,60.22 ; CN4125.44 96.41,60.15 ; CN4125.30 92.91,60.19 ; CN4125.48 97.41,60.15 ; U66030.4 v1(119.92,173.76) ; U66010.4 v1(99.14,173.66) ; Q51595.1 126.93,44.29 126.93,43.87 127.18,43.62 v1(127.4,43.62) 127.62,43.62 127.93,43.31 Q51595.4 ; CN4125.90 107.91,60.18 ; CN4125.72 103.41,60.12
  BOTTOM w0.356: CN1901.57 75.25,49.05 75,48.8 75,47.45 75.01,47.45 75.01,47.31 ; CN1900.39 169.52,31.55 v1(169.59,31.63) ; 75.01,47.31 v1(75.01,47.25) ; 75.01,47.31 75.25,47.55 CN1901.51 ; CN603.43 v1(32.86,56.85) ; CN603.37 32.59,53.85 v1(31.75,54.69) ; v1(72.46,40.95) 72.46,40.56 74.47,38.55 CN1901.15 ; CN603.40 v1(31.72,55.35) ; CN603.31 v1(32.84,50.85) ; v1(75,41.33) 75.22,41.55 CN1901.27 ; v1(34.49,52.38) 34.41,52.38 34.39,52.35 CN603.34 ; v1(34.74,46.13) 34.65,46.13 34.43,46.35 CN603.22 ; CN1901.3 75.14,35.55 v1(74.9,35.32) 75.17,35.05 CN1901.1 ; CN603.25 34.38,47.85 v1(34.66,48.12) ; CN603.28 v1(32.86,49.35) ; CN1300.63 v1(287.45,21.25) ; v1(279.42,20.96) 279.55,20.96 279.95,20.56 CN1300.33 ; v1(74.98,43.29) 74.98,44.27 75.25,44.55 CN1901.39 ; v1(75,46.56) 75,46.3 75.25,46.05 CN1901.45 ; CN1901.21 74.91,40.05 v1(73.59,41.37)
  BOTTOM w0.381: C7013.2 v1(228.83,36.72) C7012.2 ; v1(124.89,64.29) 124.56,64.29 ; v1(120.78,79.67) 121.2,79.67 ; 135.05,56.36 R67096.2 ; R67096.2 R67095.2 133.71,56.75 ; R67096.2 135.77,56.75 ; R60526.2 68.81,100.56 v1(68.46,100.22) ; v1(81.02,164.66) 80.86,164.82 R66407.2 80.43,164.42 80.61,164.25 C66407.2 ; v1(277.44,67.06) 277.49,67.01 C7016.2 ; C7504.1 199.39,82.24 199.56,82.07 ; C7507.1 211.45,134.09 C50721.2 ; 79.38,143.6 79.7,143.91 ; C4133.2 C4132.2 157.93,71.68 158.34,71.28 158.34,68.04 157.84,67.54 v1(157.76,67.54) ; v1(125.88,48.62) 125.68,48.62 125.64,48.65 U53590.3 ; U53580.3 120.94,57.65 120.56,57.27 v1(120.56,56.67) 119.98,56.09 R53580.2 ; v1(124.37,84.93) 124.37,85.95 123.99,86.33 C4108.2 ; R60003.2 C60012.2 53.18,48.89 v1(53.21,48.92) ; C52053.2 R52007.2 v1(148,56.25) ; D56222.1 305.97,45.78 305.58,46.16 v1(305.58,46.69) 305.44,46.83 C56200.2 ; v1(265.53,28.35) 265.53,28.13 266.01,27.65 C1701.2 ; C67202.2 230.03,85.09 v1(229.54,85.58) ; C51019.2 207.98,96.81 208.23,97.06 v1(208.23,97.06) ; v1(109.06,48.9) 109.29,48.67 U53500.3 ; v1(143.14,46.82) R52023.2 143.14,45.98 143.15,45.98 C52024.1 ; R301.2 v1(214.7,45.23) ; v1(189.25,173.1) 189.15,173.21 C50543.2 ; CN4300.G2 60.09,63.35 v1(60.02,63.43) ; C66038.2 v1(119.42,175.91) ; v1(102.13,43.79) 102.18,43.79 102.3,43.91 C1711.2 ; C56251.2 304.2,36.66 ; R4606.2 266.18,64.33 v1(266.62,64.77) ; CN4700.3 165.21,30.48 v1(165.45,30.23) ; R1716.1 v1(101.83,39.3) ; v1(246.68,30.61) 246.85,30.44 Q300.1 247.56,29.81 247.95,29.42 R7031.1 ; v1(281.45,72.83) 281.01,72.39 C4308.2 ; CN56200.14 305.78,51.15 v1(305.48,50.85) ; C7545.2 50.26,40.47 50.26,40.47 C60017.2 v1(49.5,41.25) ; C60013.2 36.86,45.56 36.32,45.56 36.23,45.47 v1(36.18,45.47) R60018.2 ; C50020.2 146.29,41.89 v1(146.92,41.89) R50022.1 ; v1(68.93,93.96) 69.13,93.77 Q7006.1 ; v1(62.81,46.55) 62.81,46.46 62.66,46.31 C60020.2 ; v1(269.53,69.57) Q56260.2 269.22,68.06 R56260.1 269.22,66.4 C56261.2 ; C66607.2 R66607.2 82.85,163.07 v1(83.18,163.39) ; v1(112.77,77.73) 113,77.73 ; v1(10.46,81.72) 10.63,81.89 C6036.2 ; C1715.2 95.15,45.22 v1(95.45,45.52) ; R4789.1 R4788.1 265.85,41.32 v1(265.96,41.43) R4718.2 ; C60916.2 v1(226.84,61.27) ; C50921.2 v1(218.81,97.82) ; C67203.2 228.79,85.46 v1(228.67,85.58) ; v5(280.13,57.48) C137.2 ; v1(110.59,65.99) 110.25,65.99 ; R1710.1 99.18,42.35 v1(99.16,42.32) ; v1(59.18,40.14) 59.18,40.84 C60023.2 ; v1(145.06,56.07) C52050.2 C52055.2 ; C7581.1 v1(305.69,59.67) ; C7006.2 189.36,29.52 v1(189.2,29.52) 189.02,29.33 C139.2 ; C308.2 213.13,44.88 v1(213.13,45.23) ; v1(308.38,20.35) 308.61,20.58 C7583.2 ; R53552.1 v1(111.17,53.29) R53501.1 ; v1(74.25,57.84) R60401.2 ; v1(269.3,43.44) 269.12,43.62 R4790.1 ; C53500.2 v1(106.07,50.45) ; U4450.5 145.54,119.59 v1(145.31,119.59) ; C7555.2 v1(307.82,21.85) ; CN4700.2 v1(162.2,33.2) ; Q702.S v1(137.44,28.25) ; C60005.2 v1(54.68,51.49) ; v1(69.64,111.46) 69.92,111.46 70.31,111.07 R60529.1 ; C1908.2 v1(180.39,20.68) ; C7011.2 v1(222.4,28.98) ; v1(139.21,47.68) 139.62,47.27 R52001.1 ; v1(134.08,37.39) 134.08,37.84 C701.2 ; U7006.3 69.76,90.93 70.14,90.54 v1(70.14,90.21) ; C302.1 v1(192.94,42.52) ; v1(119.63,50.27) C53590.2 120.3,49.43 R53590.2 ; CN6050.G2 v1(16.27,27.42) ; v1(109.27,53.39) 109.4,53.53 C53552.1 C53501.1 ; C300.2 217.42,27.38 217.93,26.88 v1(217.93,26.06) ; C67232.1 243.18,75.52 v1(243.63,75.06) 243.2,74.63 R67203.2 ; C66047.2 127.28,170.49 ; C66047.2 126.68,170.09 ; C66047.2 126.67,170.49 v1(126.44,170.72) ; CN250.G1 74.83,30.77 74.44,31.16 v1(74.44,31.25) ; v1(95.3,39.53) 95.22,39.45 R1717.1 ; C66617.2 v1(143.03,164.81) ; v1(81.48,81) 82.04,81 ; R53585.1 v1(113.31,55.73) ; R60019.2 45.14,49.16 v1(45.49,49.51) ; R144.1 75.53,89.77 v1(75.51,89.79) 75.24,90.06 Q10.4 ; C56405.2 299.86,73.56 299.48,73.94 v1(298.8,73.94) ; U56610.1 300.59,65.81 C56610.2 299.73,66.35 v1(299.64,66.44) ; CN280.G1 v1(135.35,25.85) ; C52009.2 142.33,57.88 ; C52009.2 C52008.2 ; C52009.2 143.05,58.28 ; v5(14.02,73.97) CN604.4 ; v1(75.33,57.2) 75.26,57.14 C7000.2 75.26,54.79 CN1901.G2 ; C53540.2 115.9,50.81 v1(115.9,51.51) ; v1(116.3,59.26) 116.56,59.01 C53580.2 ; v1(68.02,75.34) 67.84,75.16 C60316.2 ; C4626.1 v1(71.87,96.06) 72.24,96.06 72.62,95.68 C7042.1 ; CN253.1 76.5,160 76.6,160.1 v1(76.65,160.1) ; Q56270.2 275.79,67.68 R56270.1 v1(275.18,66.93) ; R4752.2 238.32,29.45 v1(238.32,30.31) ; CN4300.4 v1(58.57,57.08) ; Q52070.S 151.73,40.86 v1(151.13,41.46) R52071.1 ; R52055.1 144.17,59.49 R52051.2 143.59,59.48 v1(143.15,59.92) ; C60909.2 221.86,55 v1(221.31,55.55) 220.97,55.22 C60930.2 ; v1(74.11,79.28) 75.37,79.28 75.61,79.52 C60352.2 ; 165.15,57.18 C67016.2 ; v1(218.8,96.63) 218.64,96.63 ; C314.2 218.12,30.07 C62.2 219.26,30.41 v1(219.53,30.41) ; C1900.2 v1(179.75,42.25) ; v1(103.12,54.54) 102.74,54.16 R53555.1 ; C52002.2 157.53,155.49 158.13,154.89 C7568.2 159,153.87 ; C63.1 195.78,27.51 195.98,27.71 R341.2 196.75,27.71 196.78,27.74 v1(197.36,27.74) ; R2681.1 297.31,28.58 296.59,27.86 v1(296.54,27.86) ; v1(305.62,64.85) 305.4,64.63 D56610.1 ; v1(192.4,29.73) 192.72,30.06 R7013.2 C7023.2 ; C66460.2 79.63,169.62 v1(80.21,169.04) 80.97,168.28 R66393.2 R66690.2 ; CN251.G2 157.21,27.59 156.83,27.97 v1(156.31,27.97) ; C10.2 C3.2 231.91,37.59 231.77,37.72 v1(231.77,37.95) ; C66027.2 v1(105.66,170.67) ; 258.59,35.4 v1(258.59,34.98) 258.15,35.42 ; C55820.2 293.25,56.27 v1(292.78,55.81) ; R334.2 214.88,21.73 R393.1 ; UU52100.C1 v1(160.58,87.67) ; v1(161.85,30.2) 161.58,30.48 CN4700.4 ; C6.2 265.37,66.11 v1(265.45,66.2) ; Q60002.4 36.68,46.7 36.67,46.71 v1(36.67,47.26) ; v1(233.75,29.53) 233.75,29 C3505.2 ; C60259.2 v1(57.21,77.63) ; C53530.1 136.9,48.5 137.28,48.12 v1(137.28,47.68) ; C6037.2 14.26,76.59 v1(14.22,76.64) ; CN1900.G1 167.6,42.15 v1(167.43,42.32) ; C60016.2 50.83,26.02 v1(51.36,26.55) ; CN4301.G2 v1(274.95,79.92) ; C52101.1 R52102.1 162.15,89.15 v1(161.59,89.7) ; R4897.2 265.11,48.5 v1(264.84,48.77) ; C4589.2 84.24,151.3 C7511.1 ; R4748.2 268.15,57.23 v1(268.25,57.33) 268.27,57.33 268.47,57.14 U4700.3 ; v1(79.44,145.86) 79.92,146.35 U66310.6 ; v1(149.6,56.29) 149.6,56.67 149.36,56.92 Q52060.2 ; 195.15,57.19 C67046.2 ; C4304.2 70.91,57.92 70.83,57.84 C4303.2 71.45,57.61 v1(71.6,57.46) ; R50091.2 146.33,143.14 v1(145.97,143.51) ; C66018.2 v1(98.65,175.98) ; C4301.2 60.61,57.62 v1(60.27,57.28) 60.71,56.84 C4305.2 ; CN604.G1 v1(19.5,68.84) ; v1(81.78,172.8) 82.23,172.8 82.4,172.64 R66090.2 R66091.2 R66092.2 ; v1(185.92,83.82) 186.1,83.65 C7508.1 ; C7015.2 v1(67.97,74.17) ; v1(146.71,145.42) 146.91,145.62 C52003.2 ; v1(193.67,34.94) D253.2 D252.2 ; U53570.3 v1(122.59,55.41) ; v1(257.85,27.96) 256.86,27.96 256.15,27.25 CN1700.G2 ; 82.22,69.52 82.52,69.83 C7572.2 ; 194.29,80.86 C7564.2 ; C1714.2 95.91,35.69 96.16,35.44 v1(96.16,35.39) ; R50020.2 146.88,38.64 v1(147.04,38.79) ; v1(247.87,33.68) C4713.2 247.87,32.77 247.85,32.75 R7032.2 ; C316.2 215.26,24.25 v5(215.26,23.9) ; C55823.2 293.34,55.15 v1(292.78,54.59) 293.34,54.03 C55826.2 ; R66605.1 C66605.1 85.95,162.71 v1(86.18,162.48) ; CN254.4 v1(55.6,27.85) ; C60009.1 v1(53.11,40.17) ; C7017.2 v1(224.64,32.76) ; C4712.2 244.34,32.33 v1(245.55,32.33) Q300.4 ; D256.2 v1(191,34.85) ; CN56200.8 306.1,52.95 v1(305.99,53.06) ; C7582.1 305.69,60.66 v1(305.63,60.71) ; v1(119.64,45.76) 119.84,45.96 C53592.1 ; R60523.2 68.51,110.48 v1(68.81,110.77) ; C56201.2 304.66,48.39 v1(304.35,48.09) ; v1(234.11,77.78) 234.36,77.53 234.85,77.53 235.13,77.24 C67209.2 ; CN4301.G1 273.61,71.48 v1(272.77,72.32) ; C60014.2 v1(49.32,44.83) 49.05,45.1 R60024.2 ; R1714.1 95.09,40.34 v1(95.3,40.14) ; R7044.1 v1(66.39,111.14) ; CN1300.G2 291.12,21.29 v1(290.39,21.29) ; v1(114.75,55.71) 114.91,55.55 C53582.2 ; C3002.2 C3001.2 v1(18.75,77.17) ; v1(242.72,30.65) 243.19,30.65 C4714.2 243.63,30.82 244.16,30.29 R4795.2 ; C1931.2 v1(67.45,33.51) ; R338.1 202.89,44.65 C310.2 203.78,45.13 v1(203.88,45.23) ; v1(298.52,32.16) 298.52,32.03 299.62,30.94 C2520.2 ; R4703.2 v1(264.77,57.28) ; v1(217.55,105.44) 217.28,105.72 C50919.2 ; C1932.2 v1(65.91,32.93) ; R1715.1 101.95,40.29 v1(101.5,39.83) ; CN280.4 v1(130.2,28.55) ; R60302.1 66.54,82.91 v1(66.44,83.01) 66.44,83.05 R60346.2 ; CN603.G1 v1(29.14,34.15) ; C55824.2 291.07,56.85 291.41,56.85 v1(291.61,57.05) ; v1(124.55,108.48) 124.55,110.35 R4541.1 R4540.1 ; v1(229.13,28.35) 229.47,28.69 C7019.2 ; v1(75.1,87.33) 74.5,87.33 R60349.2 ; R50021.2 148.94,39.43 148.76,39.61 U50020.3 v1(147.93,38.79) ; C7036.2 v1(72.67,97.75) ; v1(94.36,170.51) 94.36,170.36 94.46,170.26 R66160.2 R66162.2 ; U2502.3 v1(295.06,32.62) ; v1(218.68,36.63) 218.67,36.63 218.41,36.38 C313.2 ; v1(145.03,143.36) 145.18,143.21 C50085.2 144.74,142.77 ; v1(238.3,70.62) R4756.2 R4758.2 ; v1(106.91,52.94) 106.67,52.7 U53555.3 ; U3000.2 v1(18.06,79.25) ; 175.1,57.2 C67026.2 ; v1(81.02,163.39) 81.07,163.34 R66001.2 R66693.2 ; C252.2 144.14,33.52 v1(144.14,33.3) ; v1(73.66,33.61) 74,33.95 CN1901.G1 ; v1(66.6,95.91) 66.85,95.66 C7039.2 67.61,95.27 Q7006.4 ; v1(150.11,51.9) C52000.2 ; v1(157.54,168.77) 157.1,168.77 156.67,168.34 R50606.2 ; v5(233.52,54.23) 233.52,53.18 C7550.2 ; v1(264.92,28.07) 264.05,27.2 CN1700.G1 ; 158.54,151.7 C7505.1 ; CN251.1 v1(155.42,30.7) 155.42,30.86 Q251.S ; D257.2 195.22,40.24 195.02,40.03 v1(194.94,40.03) ; C60008.2 198.54,44.36 v1(198.65,44.25) 198.75,44.35 R322.1 ; U53585.3 v1(111,57.58) ; C2521.2 301.7,27.99 301.37,28.32 v1(301.06,28.32) ; C304.2 211.81,21.8 211.8,21.8 C303.1 v1(211.07,21.06) ; C67042.2 v1(188.29,59.59) ; v1(87.05,77.62) 87.32,77.62 ; CN254.G1 v1(53,24.24) ; v1(106.24,56.37) U53550.3 ; v1(233.02,38.81) 233.1,38.73 233.1,38.18 C4857.2 ; C55827.2 293.44,52.61 v1(292.76,53.29) ; v1(129.79,176) 129.79,175.34 C66048.2 ; R56201.1 304.67,53.72 v1(304.06,53.72) ; 185.11,57.19 C67036.2 ; R1711.1 101.67,41.33 v1(101.57,41.23) ; v1(58.65,42.65) 58.65,42.63 59.18,42.1 C60024.2 ; v1(61.84,42.16) 62.57,42.16 C60022.2 ; C251.2 D258.2 104.74,35.96 v1(104.54,35.77) ; C6038.2 v1(16,75.95) ; v1(22.27,81.54) 21.83,81.54 21.73,81.64 C3000.2 ; R60901.2 219.1,51.39 R60905.2 219.09,50.97 219.36,50.7 v1(220.16,50.7) ; C50920.2 210.93,96.87 v1(210.74,97.05) ; C1712.2 101.5,43.35 v1(101.5,43.79) ; C53510.2 v1(146.15,96.63) ; CN604.G2 13.9,71.34 v1(13.81,71.43) ; C55821.2 293.25,57.57 v1(292.73,57.05) ; C250.2 151.32,34.29 v1(151,33.96) ; v1(98,42.29) R1712.1 ; C53572.1 125.4,51.07 125.41,51.07 125.98,50.5 v1(126.16,50.5) ; Q60002.1 35.38,49.41 v1(35.33,49.46) ; v1(142.74,138.05) 143.25,138.56 C50076.2 ; C52010.1 R52010.1 150.08,47.78 v1(150.08,46.89) ; Q4751.1 65.88,68.05 v1(65.88,68.56) ; 215.14,57.19 C67066.2 ; C53550.2 v1(103.88,56.76) ; CN4125.G1 84.55,54.41 ; Q1900.2 91.23,53.45 v1(90.34,53.45) ; C67609.2 154.7,171.39 v1(154.76,171.45) ; 205.1,57.19 C67056.2 ; C60516.2 v1(75.96,101.2) ; C1713.2 101.44,35.87 v1(101.34,35.77) ; v1(192.81,34.94) 192.78,34.97 D254.2 D255.2 ; C50087.2 144.1,143.11 v1(144.1,143.85) ; v1(84.11,80.13) 83.78,80.13 ; v1(111.7,86.67) 112.07,86.67 C4109.2 112.57,86.23 C37.2 ; C4131.2 144.12,89.29 ; Q10.1 v1(73.31,91.19) ; C4134.2 145.48,88.9 ; v1(239.09,70.62) 239.09,70.09 R4759.2 ; v1(234.62,29.53) 234.62,28.98 C3504.2 ; C67204.2 227.54,85.46 v1(227.63,85.55) ; C67216.2 v1(216.28,78.95) ; v1(125.1,67.62) 124.66,67.62 ; R51587.1 166.21,105.64 165.83,105.26 v1(165.81,105.26) ; CN603.G2 v1(32.02,62.05) ; CN253.4 v1(74.47,163) ; R52020.1 C52020.1 v1(141.45,44.62) ; v1(121.98,50.57) R53570.2 C53570.2 ; v1(296.64,35.32) U56250.2 ; v1(291.66,54.59) 291.05,55.21 C55825.2 ; v1(304.1,48.7) 304.68,49.28 C56202.2 ; v1(65.66,55.34) C1913.2 ; v1(94.59,77.9) 94.03,77.9 ; Q5001.2 157.23,40.61 v1(156.94,40.9) ; R56280.1 272.52,67.71 Q56280.2 273.35,67.99 v1(273.55,68.19) ; C67022.2 v1(168.3,59.57) ; R26.2 v1(266.25,69.57) ; C55822.2 293.68,51.18 v1(292.76,52.1) ; v1(85.75,171.76) 85.75,171.34 85.37,170.96 R66093.2 ; v1(50.7,63.71) 51.05,63.35 CN4300.G1 ; v1(94.99,170.67) 95.02,170.7 C66017.2 ; v1(117.24,48.64) 117.37,48.52 U53540.3 118.21,47.59 R53540.1 ; v1(147.14,124.29) 147.17,124.32 R51507.1 R51508.1 ; C7041.2 70.44,92.25 70.76,92.58 v1(70.76,92.76) ; v1(77.19,89.82) 79.17,89.82 CN4100.G1 ; C7571.2 80.21,108.85 ; v1(149.01,26.09) CN251.G1 ; C51116.2 v1(218.81,99.06) ; C4859.2 C4825.2 C4824.2 266.21,37.11 v1(266.29,37.04) ; v1(30.5,63.99) 30.11,63.6 C3011.2 ; CN250.27 v1(104.25,33.23) ; C66028.2 v1(109.01,175.95) ; CN254.G2 v1(61.2,24.17) ; C60266.2 v1(54.23,84.04) ; R66462.2 R66460.2 68.02,137.06 v1(68.05,137.02) ; CN252.16 v1(143.97,28.3) ; C60280.2 v1(58.65,75.78) ; v1(134.03,77.74) 133.74,77.74 ; C1933.2 v1(65.02,32.93) ; C7506.1 179.2,177.68 C50518.2 ; C301.1 R320.1 219.71,31.76 219.97,31.76 v1(220.47,32.26) ; C4136.2 C4135.2 157.59,68.34 v1(157.73,68.21) ; R52013.2 146.85,46.31 C52014.1 146.86,46.31 v1(146.86,46.94) ; CN250.G2 v1(106.29,30.77) ; CN1900.57 v1(168.42,26.19) ; R60014.1 v1(60.5,39.55) ; C4116.2 C4119.2 110.79,86.61 v1(111.31,87.13) ; C3008.2 R3006.2 36.14,62.84 35.94,63.05 v1(35.94,63.09) ; C3007.2 37.85,61.24 R3008.1 37.85,61.77 v1(37.64,61.98) ; C7033.2 v1(97.34,57.43) ; C4105.2 C4104.2 ; CN252.15 v1(150.74,28.3) ; C67052.2 v1(198.3,59.59) ; CN4125.G2 154.18,53.73 155.06,54.61 v1(155.06,54.92) ; C1936.2 v1(67.17,54.76) ; D282.3 v1(128.77,32.94) ; C312.2 v1(217.37,45.23) ; CN4301.4 v1(279.87,78.9) ; C1937.2 v1(179.3,20.67) ; C3003.2 v1(17.93,75.45) ; C66037.2 v1(116.07,170.46) ; C311.2 v1(216.48,45.23) ; D281.3 v1(123.87,33.9) ; C60007.2 v1(53.79,51.46) ; v1(61,33.02) R7007.1 ; 136.91,153.99 C7546.2 ; v1(120.24,76.98) 120,76.98 ; 238.45,37 C4856.2 ; R1700.1 v1(93.45,37.37) ; C50720.2 207.35,133.36 v1(207.34,133.35) ; CN280.G2 v1(124.05,25.85) ; C66316.2 v1(66.44,128.08) ; C67062.2 v1(208.28,59.62) ; C7020.2 281.18,62.39 v1(280.08,62.39) ; R1713.1 v1(94.68,42.24) ; C50918.2 v1(218.81,100.44) ; 303.8,35.27 C56252.2 ; C67032.2 v1(178.28,59.59) ; v1(196.97,35.36) 196.86,35.47 196.39,35.47 D250.2 D251.2 ; v1(122.2,80.3) 122.55,80.3 ; R4603.2 260.96,71.9 v1(260.96,72.6) ; D6035.3 13.63,75.7 v1(13.63,76.64) C6035.2 ; v1(58.49,51.41) R60022.1 ; CN6050.G1 v1(35.46,26.04) ; C4802.2 v1(110.95,59.51)
  BOTTOM w0.508: C7018.2 229.16,37.9 229.21,37.95 v5(229.27,37.95) ; v1(127.99,116.39) 127.99,111.03 127.41,110.45 R4518.1 ; 76.94,54.65 CN1901.G2 75.4,53.88
  vias: v1(0.74,79.9) v1(0.74,77.36) v1(0.74,74.82) v1(0.74,72.28) v1(0.74,69.74) v1(1.23,82.29) v1(2.09,68.02) v1(3.71,82.55) v1(4.63,68.02) v1(6.25,82.55) v1(7.17,68.02) v1(8.79,82.55) v1(9.61,67.53) v1(10.79,65.39) v1(10.82,63.45) v1(11.33,82.55) v1(11.79,44.94) v1(11.79,42.4) v1(11.79,39.86) v1(11.79,37.32) v1(11.79,34.78) v1(13.87,82.55) v1(14.85,24.44) v1(16.41,82.55) v1(17.45,58.5) v1(17.45,56.49) v1(17.39,24.44) v1(17.47,54.56) v1(18.95,82.55) v1(19.43,58.5) v1(19.41,56.52) v1(19.43,54.59) v1(19.93,24.44) v1(21.33,56.52) v1(21.36,58.47) v1(21.36,54.69) v1(21.49,82.55) v1(22.47,24.44) v1(23.55,68) v1(25.01,24.44) v1(26.8,69.95) v1(27.55,24.44) v1(30.09,24.44) v1(31.65,82.62) v1(31.72,50.83) v1(31.85,58.71) v1(31.85,45.83) v1(32.25,47.3) v1(32.63,24.44) v1(34.18,82.85) v1(34.59,55.48) v1(34.87,59.16) v1(35.15,24.27) v1(35.7,69.95) v1(36.57,22.44) v1(36.69,83.24) v1(39.11,22.44) v1(39.17,83.8) v1(41.65,22.44) v1(43.99,85.38) v1(44.19,22.44) v1(44.6,69.95) v1(45.31,60.06) v1(46.32,86.41) v1(46.73,22.44) v1(47.16,60.67) v1(47.85,68) v1(48.55,87.61) v1(48.99,60.18) v1(49.27,22.44) v1(50.78,88.76) v1(50.92,60.58) v1(51.81,22.44) v1(52.92,87.46) v1(53.28,23.45) v1(55.01,86.02) v1(55.44,46.76) v1(55.44,44.68) v1(55.7,77.65) v1(55.67,76.86) v1(55.82,23.45) v1(56.48,45.71) v1(57.45,85.4) v1(57.53,46.76) v1(57.53,44.68) v1(58.36,23.45) v1(59.93,85.85) v1(60.9,23.45) v1(61.74,84.83) v1(62.02,102.62) v1(62,87.29) v1(62.56,85.14) v1(62.58,31.6) v1(62.77,94.35) v1(62.96,104.98) v1(63.29,89.45) v1(63.56,91.96) v1(63.73,107.4) v1(64.31,109.87) v1(64.76,106.58) v1(64.92,170.91) v1(64.92,168.37) v1(64.92,154.38) v1(64.92,141.68) v1(64.92,132.69) v1(64.92,130.15) v1(64.92,127.61) v1(64.92,125.07) v1(64.92,122.53) v1(64.92,119.99) v1(65.7,134.82) v1(65.94,156) v1(66.19,167) v1(66.15,139.69) v1(68.37,156.46) v1(68.54,166.36) v1(68.94,163.91) v1(68.94,161.37) v1(68.94,158.83) v1(70.07,22.46) v1(70.26,41.26) v1(71.36,41.26) v1(71.8,70.64) v1(72.13,87.63) v1(72.11,86.8) v1(72.13,85.98) v1(72.13,22.44) v1(72.18,85.35) v1(72.18,84.71) v1(73.02,47.53) v1(73.07,70.64) v1(73.37,23.86) v1(73.89,180.26) v1(74.16,70.67) v1(74.93,68.35) v1(75.07,25.44) v1(76.43,180.26) v1(77.61,25.44) v1(78.18,48.72) v1(78.97,180.26) v1(79.32,69.52) v1(79.32,68.94) v1(79.32,68.35) v1(79.34,43.08) v1(79.65,47.83) v1(79.93,69.52) v1(79.93,68.94) v1(79.93,68.35) v1(80.06,147.45) v1(80.15,25.44) v1(80.67,146.87) v1(81.02,167.66) v1(81.02,166.16) v1(81.51,180.26) v1(81.53,48.7) v1(81.56,47.65) v1(81.73,78.44) v1(82.34,123.7) v1(82.48,118.18) v1(82.69,25.44) v1(82.8,54.41) v1(82.88,121.16) v1(83.18,167.66) v1(83.18,166.16) v1(83.18,164.66) v1(83.97,119.68) v1(84.05,180.26) v1(84.1,118.41) v1(84.1,78.79) v1(84.17,123.73) v1(84.22,117.63) v1(84.68,151.31) v1(85.14,114.23) v1(85.23,25.44) v1(85.34,167.66) v1(85.34,166.16) v1(85.34,164.66) v1(85.34,163.39) v1(85.47,151.31) v1(85.63,80.5) v1(85.63,79.17) v1(86.33,151.31) v1(86.6,115.48) v1(87.04,79.7) v1(87.14,151.31) v1(87.22,65.89) v1(87.77,25.44) v1(87.94,116.77) v1(88.54,66.07) v1(88.55,114.26) v1(88.6,79.41) v1(88.55,78.08) v1(88.72,155.98) v1(88.72,155.37) v1(88.72,154.79) v1(88.72,154.2) v1(89.3,155.98) v1(89.3,155.37) v1(89.3,154.79) v1(89.3,154.2) v1(89.84,47.83) v1(89.89,155.98) v1(89.89,155.37) v1(89.89,154.79) v1(89.89,154.2) v1(89.9,115.61) v1(90.27,44.38) v1(90.31,25.44) v1(90.52,155.98) v1(90.52,155.37) v1(90.52,154.79) v1(90.52,154.2) v1(90.46,78.8) v1(90.57,65.56) v1(90.88,113.84) v1(91.11,155.98) v1(91.11,155.37) v1(91.11,154.79) v1(91.11,154.2) v1(91.89,45.57) v1(92.23,115.19) v1(92.16,78.05) v1(92.46,113.71) v1(92.85,25.44) v1(93.42,134.78) v1(93.43,133.76) v1(93.43,132.54) v1(93.43,131.32) v1(93.43,130.1) v1(93.79,115.07) v1(93.9,45.49) v1(94.17,64.78) v1(94.51,80.55) v1(94.52,79.22) v1(94.66,137.78) v1(94.95,152.33) v1(94.95,151.74) v1(94.95,151.11) v1(94.95,150.52) v1(94.95,149.94) v1(95.39,25.44) v1(95.5,66.5) v1(95.48,65.11) v1(95.56,152.33) v1(95.56,151.74) v1(95.56,151.11) v1(95.56,150.52) v1(95.56,149.94) v1(95.64,116.09) v1(95.64,115.45) v1(95.64,114.82) v1(95.69,111.62) v1(96.14,152.33) v1(96.14,151.74) v1(96.14,151.11) v1(96.14,150.52) v1(96.14,149.94) v1(96.06,77.44) v1(96.34,80.15) v1(96.34,78.83) v1(96.63,112.52) v1(96.59,65.51) v1(96.72,152.33) v1(96.72,151.74) v1(96.72,151.11) v1(96.72,150.52) v1(96.72,149.94) v1(96.75,180.26) v1(97.2,39.81) v1(97.44,45.57) v1(97.93,25.44) v1(97.96,169.7) v1(97.96,169.09) v1(97.99,79.22) v1(98.01,77.25) v1(98.19,35.39) v1(98.55,39.81) v1(98.68,169.09) v1(98.69,115.52) v1(98.8,170.56) v1(99.06,66.32) v1(99.29,180.26) v1(99.26,64.93) v1(99.44,169.09) v1(99.37,79.09) v1(99.41,77.7) v1(99.56,170.56) v1(99.92,39.81) v1(99.99,112.32) v1(100.14,110.44) v1(100.2,169.09) v1(100.4,170.56) v1(100.47,25.44) v1(100.57,113.81) v1(100.73,66.55) v1(100.76,37.09) v1(100.88,115.32) v1(100.96,127.16) v1(101.02,42.6) v1(101.16,170.56) v1(101.26,134.01) v1(101.26,132.79) v1(101.26,131.58) v1(101.26,130.36) v1(101.39,128.55) v1(101.83,180.26) v1(102.39,134.01) v1(102.39,132.79) v1(102.39,131.58) v1(102.59,136.98) v1(102.56,127.87) v1(103.01,25.44) v1(103.19,170.26) v1(103.15,127.89) v1(103.73,114.8) v1(103.79,112.95) v1(103.79,110.91) v1(104.37,180.26) v1(104.44,66.4) v1(104.64,170.29) v1(104.67,127.89) v1(105.25,127.89) v1(105.55,25.44) v1(106.14,115.26) v1(106.14,113.29) v1(106.29,122.56) v1(106.65,127.89) v1(106.91,180.26) v1(107.24,127.89) v1(108.09,25.44) v1(108.33,169.7) v1(108.33,169.09) v1(108.26,76.05) v1(108.41,134.37) v1(108.41,133.15) v1(108.41,131.93) v1(108.5,79.51) v1(108.64,78.18) v1(108.7,112.76) v1(108.76,114.78) v1(109.04,169.09) v1(109.17,170.57) v1(109.42,127.86) v1(109.45,180.26) v1(109.8,169.09) v1(109.93,170.57) v1(109.99,78.56) v1(110.06,127.86) v1(110.56,169.09) v1(110.6,25.53) v1(110.77,170.57) v1(110.87,28.02) v1(111.17,115.23) v1(111.4,78.02) v1(111.53,170.57) v1(111.46,79.35) v1(111.58,127.87) v1(111.99,180.26) v1(112.07,113.7) v1(112.07,66.84) v1(112.16,127.87) v1(112.27,153.29) v1(112.27,152.71) v1(112.27,152.12) v1(112.27,151.54) v1(112.27,150.9) v1(112.27,150.32) v1(112.41,65.4) v1(112.85,148.27) v1(112.85,147.61) v1(112.95,153.52) v1(112.95,152.94) v1(112.95,152.35) v1(112.95,151.77) v1(112.95,151.13) v1(112.95,150.55) v1(112.95,149.97) v1(112.97,112.16) v1(113.14,64.7) v1(113.07,28.93) v1(113.43,67.09) v1(113.56,170.26) v1(113.56,153.52) v1(113.56,152.94) v1(113.56,152.35) v1(113.56,151.77) v1(113.56,151.13) v1(113.56,150.55) v1(113.56,149.97) v1(113.56,80.77) v1(113.69,115.04) v1(113.75,134.45) v1(113.75,133.2) v1(113.75,131.98) v1(113.87,127.85) v1(114.15,153.52) v1(114.15,152.94) v1(114.15,152.35) v1(114.15,151.77) v1(114.15,151.13) v1(114.15,150.55) v1(114.15,149.97) v1(114.34,154.38) v1(114.53,180.26) v1(114.51,127.85) v1(114.73,153.52) v1(114.73,152.94) v1(114.73,152.35) v1(114.73,151.77) v1(114.73,151.13) v1(114.73,150.55) v1(114.73,149.97) v1(115.01,170.3) v1(115.04,113.69) v1(115.22,154.03) v1(115.49,80.96) v1(115.49,78.93) v1(115.61,28.93) v1(115.7,153.5) v1(115.7,152.91) v1(115.7,152.33) v1(115.7,151.74) v1(115.7,151.11) v1(115.7,150.52) v1(115.7,149.94) v1(115.92,137.56) v1(115.98,127.86) v1(116.08,154.38) v1(116.23,65.33) v1(116.31,153.5) v1(116.31,152.91) v1(116.31,152.33) v1(116.31,151.74) v1(116.31,151.11) v1(116.31,150.52) v1(116.31,149.94) v1(116.59,112.2) v1(116.63,73.26) v1(116.66,127.85) v1(116.89,153.5) v1(116.89,152.91) v1(116.89,152.33) v1(116.89,151.74) v1(116.89,151.11) v1(116.89,150.52) v1(116.89,149.94) v1(116.99,115.39) v1(117.07,180.26) v1(117.25,127.85) v1(117.48,153.5) v1(117.48,152.91) v1(117.48,152.33) v1(117.48,151.74) v1(117.48,151.11) v1(117.48,150.52) v1(117.48,149.94) v1(117.52,148.35) v1(117.52,147.69) v1(117.83,127.86) v1(117.81,66.14) v1(117.88,63.72) v1(118.16,79.24) v1(118.15,28.93) v1(118.31,114.08) v1(118.42,77.92) v1(118.74,169.7) v1(118.71,81.73) v1(118.75,169.09) v1(119.25,67) v1(119.46,169.09) v1(119.47,65.12) v1(119.61,180.26) v1(119.58,170.56) v1(119.59,127.86) v1(119.73,112.64) v1(120.06,115.51) v1(120.22,169.09) v1(120.17,127.86) v1(120.27,67.53) v1(120.35,170.56) v1(120.69,28.87) v1(120.98,169.09) v1(121.19,170.56) v1(121.38,114.21) v1(121.94,76.75) v1(121.95,170.56) v1(121.99,26.94) v1(121.99,24.4) v1(122.15,180.26) v1(122.56,78.27) v1(123.11,22.44) v1(123.98,170.26) v1(123.98,79.48) v1(124.69,180.26) v1(125.43,170.29) v1(125.65,22.44) v1(126.18,66.72) v1(127.23,180.26) v1(128.24,119.84) v1(128.19,22.44) v1(128.73,79.72) v1(129.02,127.8) v1(129.1,169.75) v1(129.11,169.14) v1(129.13,136.25) v1(129.28,121.52) v1(129.44,139.53) v1(129.49,123.53) v1(129.77,180.26) v1(129.82,169.14) v1(129.95,170.61) v1(130.44,121.93) v1(130.58,169.14) v1(130.63,124.33) v1(130.58,119.74) v1(130.71,170.61) v1(130.71,136.3) v1(130.73,22.44) v1(130.83,127.7) v1(131.11,77.77) v1(131.21,66.04) v1(131.31,169.14) v1(131.55,170.61) v1(131.8,118.57) v1(132.23,52.86) v1(132.31,180.26) v1(132.31,170.61) v1(132.25,55.73) v1(132.41,136.4) v1(132.41,121.92) v1(132.44,77.13) v1(133.16,148.25) v1(133.16,147.59) v1(133.27,22.44) v1(133.83,152.33) v1(133.83,151.74) v1(133.83,151.11) v1(133.83,150.52) v1(133.83,149.94) v1(133.85,54.59) v1(134.02,79.17) v1(134.34,170.31) v1(134.44,152.33) v1(134.44,151.74) v1(134.44,151.11) v1(134.44,150.52) v1(134.44,149.94) v1(134.85,180.26) v1(135.03,152.33) v1(135.03,151.74) v1(135.03,151.11) v1(135.03,150.52) v1(135.03,149.94) v1(135.21,80.05) v1(135.34,77.83) v1(135.38,64.69) v1(135.43,55.73) v1(135.45,52.86) v1(135.61,152.33) v1(135.61,151.74) v1(135.61,151.11) v1(135.61,150.52) v1(135.61,149.94) v1(135.79,170.34) v1(135.81,22.44) v1(136.48,78.18) v1(137.09,158.98) v1(137.09,157.97) v1(137.08,156.75) v1(137.09,155.63) v1(137.39,180.26) v1(137.47,64.13) v1(138.35,22.44) v1(138.66,65.65) v1(139.32,39.22) v1(139.32,37.9) v1(139.29,36.27) v1(139.93,180.26) v1(140.76,39.22) v1(140.79,37.9) v1(140.84,36.27) v1(140.89,22.44) v1(141.37,138.04) v1(142.11,138.04) v1(142.26,39.22) v1(142.26,37.9) v1(142.26,36.27) v1(142.47,180.26) v1(142.63,143.23) v1(142.57,59.92) v1(143.15,156.52) v1(143.18,155.88) v1(143.43,22.44) v1(143.47,72.41) v1(143.91,51.72) v1(143.91,49.43) v1(144.01,167.82) v1(144.8,167.82) v1(144.98,164.93) v1(145.06,50.57) v1(145.93,65) v1(145.97,22.44) v1(146.05,149) v1(146.05,148.16) v1(146.05,147.32) v1(146.05,146.49) v1(146.2,51.72) v1(146.2,49.43) v1(146.7,104.84) v1(147.04,167.85) v1(146.96,93.73) v1(147.05,169.78) v1(147.05,169.19) v1(148.41,128.98) v1(148.51,22.44) v1(148.9,106.64) v1(150.1,129.64) v1(151.05,22.44) v1(151.78,170.92) v1(151.78,170.01) v1(151.78,169.22) v1(152.5,166.37) v1(152.7,170.95) v1(153.59,22.44) v1(154.6,163.38) v1(155.17,180.26) v1(155.42,169.45) v1(156.13,22.44) v1(156.31,177.6) v1(157.03,164.16) v1(157.71,180.26) v1(158.64,38.77) v1(158.62,22.17) v1(159.92,177.65) v1(160.05,38.77) v1(160.25,180.26) v1(160.63,96.96) v1(162.02,55) v1(162.02,54.42) v1(162.02,53.83) v1(162.07,177.65) v1(162.25,51.29) v1(162.25,50.53) v1(162.27,52.97) v1(162.27,52.16) v1(162.79,180.26) v1(163.1,55) v1(163.1,54.42) v1(163.1,53.83) v1(164.58,53) v1(164.58,51.9) v1(164.91,52.46) v1(165.19,53) v1(165.19,51.9) v1(165.33,180.26) v1(165.57,52.45) v1(165.78,51.9) v1(165.85,53) v1(166.18,52.46) v1(166.44,53) v1(166.44,51.9) v1(166.67,79.99) v1(166.7,79.4) v1(166.7,78.82) v1(166.79,52.46) v1(167.26,177.65) v1(167.26,79.99) v1(167.28,79.4) v1(167.28,78.82) v1(167.87,180.26) v1(167.94,83.82) v1(167.87,79.99) v1(167.87,79.4) v1(167.87,78.82) v1(167.96,85.19) v1(168.45,79.99) v1(168.45,79.4) v1(168.45,78.82) v1(168.68,177.65) v1(168.93,19.14) v1(169.03,79.99) v1(169.03,79.4) v1(169.03,78.82) v1(169.45,83.82) v1(170.41,180.26) v1(170.66,175.24) v1(171.19,85.45) v1(171.4,79.99) v1(171.42,79.4) v1(171.42,78.82) v1(171.5,31.63) v1(171.47,19.14) v1(171.75,177.65) v1(171.92,55) v1(171.92,54.42) v1(171.92,53.83) v1(171.98,79.99) v1(172.01,79.4) v1(172.01,78.82) v1(172.15,51.29) v1(172.15,50.53) v1(172.17,52.97) v1(172.17,52.16) v1(172.59,79.99) v1(172.59,79.4) v1(172.59,78.82) v1(172.59,37.8) v1(172.95,180.26) v1(173,55) v1(173,54.42) v1(173,53.83) v1(173.01,31.07) v1(173.22,171.05) v1(173.17,79.99) v1(173.17,79.4) v1(173.17,78.82) v1(173.76,79.99) v1(173.76,79.4) v1(173.76,78.82) v1(174.01,19.14) v1(174.39,83.82) v1(174.48,53) v1(174.48,51.9) v1(174.81,52.46) v1(175.09,53) v1(175.09,51.9) v1(175.49,180.26) v1(175.47,52.45) v1(175.68,51.9) v1(175.82,83.82) v1(175.75,53) v1(176.12,176.3) v1(176.08,52.46) v1(176.34,53) v1(176.34,51.9) v1(176.55,19.14) v1(176.63,177.65) v1(176.69,52.46) v1(178.03,180.26) v1(178.58,92.1) v1(178.65,83.82) v1(178.8,90.24) v1(178.79,88.43) v1(178.99,29.34) v1(179.14,177.65) v1(179.07,87.17) v1(179.09,19.14) v1(180.22,28.84) v1(180.57,180.26) v1(181.17,156.11) v1(181.58,156.57) v1(181.63,19.14) v1(181.78,28.88) v1(181.9,55.03) v1(181.9,54.44) v1(181.9,53.86) v1(181.92,38.89) v1(182.01,156.97) v1(182.13,51.32) v1(182.11,50.65) v1(182.15,53) v1(182.15,52.18) v1(182.37,83.82) v1(182.83,20.78) v1(182.98,55.03) v1(182.98,54.44) v1(182.98,53.86) v1(183.11,180.26) v1(183.05,177.65) v1(183.74,83.82) v1(183.69,28.98) v1(183.85,38.89) v1(184.53,177.65) v1(184.46,53.02) v1(184.46,51.93) v1(184.79,52.49) v1(185.07,53.02) v1(185.07,51.93) v1(185.45,52.47) v1(185.65,180.26) v1(185.73,53.02) v1(185.66,51.93) v1(185.75,38.87) v1(186.06,52.49) v1(186.32,53.02) v1(186.32,51.93) v1(186.67,52.49) v1(187.14,173.16) v1(187.22,85.6) v1(187.22,79.63) v1(187.22,79.05) v1(187.22,78.46) v1(187.22,77.83) v1(187.22,77.24) v1(187.42,163.94) v1(187.8,79.63) v1(187.8,79.05) v1(187.8,78.46) v1(187.8,77.83) v1(187.8,77.24) v1(187.96,20.95) v1(188.08,158.42) v1(188.08,156.9) v1(188.19,180.26) v1(188.38,79.63) v1(188.38,79.05) v1(188.38,78.46) v1(188.38,77.83) v1(188.38,77.24) v1(188.99,79.63) v1(188.99,79.05) v1(188.99,78.46) v1(188.99,77.83) v1(188.99,77.24) v1(189.46,83.82) v1(190.14,79.66) v1(190.14,79.07) v1(190.14,78.49) v1(190.14,77.85) v1(190.14,77.27) v1(190.24,20.95) v1(190.73,180.26) v1(190.72,79.66) v1(190.72,79.07) v1(190.72,78.49) v1(190.72,77.85) v1(190.72,77.27) v1(191.31,79.66) v1(191.31,79.07) v1(191.31,78.49) v1(191.31,77.85) v1(191.31,77.27) v1(191.39,83.82) v1(191.84,173.16) v1(191.92,79.66) v1(191.92,79.07) v1(191.92,78.49) v1(191.92,77.85) v1(191.92,77.27) v1(191.91,55.08) v1(191.91,54.49) v1(191.91,53.91) v1(192.14,51.37) v1(192.14,50.61) v1(192.17,53.05) v1(192.17,52.23) v1(192.53,85.65) v1(192.63,170.62) v1(192.78,175.44) v1(192.76,172.73) v1(192.78,20.94) v1(192.95,142.96) v1(193,55.08) v1(193,54.49) v1(193,53.91) v1(193.06,138.01) v1(193.14,85.63) v1(193.27,180.26) v1(193.57,175.47) v1(193.98,172.72) v1(194.28,19.76) v1(194.48,53.07) v1(194.48,51.98) v1(194.81,52.54) v1(195.09,53.07) v1(195.09,51.98) v1(195.46,52.53) v1(195.67,51.98) v1(195.81,180.26) v1(195.75,53.07) v1(196.08,52.54) v1(196.33,53.07) v1(196.33,51.98) v1(196.59,91.34) v1(196.75,94.34) v1(196.69,52.54) v1(196.92,169.37) v1(196.95,168.79) v1(198.35,180.26) v1(199.85,159.88) v1(200.08,92.2) v1(200.89,180.26) v1(201.14,150.42) v1(201.29,165.71) v1(201.32,92.2) v1(201.95,55.05) v1(201.95,54.47) v1(201.95,53.88) v1(202.2,53.02) v1(202.2,52.21) v1(202.17,51.34) v1(202.17,50.58) v1(202.57,92.2) v1(203.03,55.05) v1(203.03,54.47) v1(203.03,53.88) v1(203.26,150.41) v1(203.43,180.26) v1(203.79,92.2) v1(203.96,19.89) v1(204.51,53.05) v1(204.51,51.95) v1(204.54,19.89) v1(204.84,52.51) v1(205.12,53.05) v1(205.12,51.95) v1(205.5,52.5) v1(205.7,51.95) v1(205.78,53.05) v1(205.89,79.81) v1(205.91,79.23) v1(205.91,78.64) v1(205.97,180.26) v1(206.11,52.51) v1(206.36,53.05) v1(206.36,51.95) v1(206.47,79.81) v1(206.5,79.23) v1(206.5,78.64) v1(206.71,111.52) v1(206.72,52.51) v1(206.8,158.02) v1(207.08,130.6) v1(207.08,79.81) v1(207.08,79.23) v1(207.08,78.64) v1(207.67,79.81) v1(207.67,79.23) v1(207.67,78.64) v1(208.2,168.15) v1(208.3,130.98) v1(208.25,79.81) v1(208.25,79.23) v1(208.25,78.64) v1(208.51,180.26) v1(208.56,164.67) v1(209.45,172.06) v1(210,131) v1(210.56,79.81) v1(210.59,79.23) v1(210.59,78.64) v1(210.72,172.06) v1(211.14,136.66) v1(211.15,79.81) v1(211.17,79.23) v1(211.17,78.64) v1(211.6,134.04) v1(211.66,97.94) v1(211.78,131) v1(211.76,79.81) v1(211.76,79.23) v1(211.76,78.64) v1(212.01,172.06) v1(211.97,55.08) v1(211.97,54.49) v1(211.97,53.91) v1(212.21,168.13) v1(212.23,53.05) v1(212.23,52.23) v1(212.2,51.37) v1(212.2,50.61) v1(212.34,79.81) v1(212.34,79.23) v1(212.34,78.64) v1(212.42,150.12) v1(212.47,111.81) v1(212.92,79.81) v1(212.92,79.23) v1(212.92,78.64) v1(213.06,55.08) v1(213.06,54.49) v1(213.06,53.91) v1(213.15,134.14) v1(213.48,168.13) v1(213.51,131) v1(213.64,136.55) v1(213.99,165.89) v1(214.12,159.07) v1(214.34,123.11) v1(214.47,152.17) v1(214.54,53.07) v1(214.55,52.48) v1(214.55,51.9) v1(214.98,159.94) v1(215.04,137.48) v1(215.13,51.9) v1(215.16,53.06) v1(215.16,52.48) v1(215.26,130.98) v1(215.39,139.95) v1(215.5,135.05) v1(215.74,53.06) v1(215.74,51.9) v1(215.8,52.48) v1(216.38,53.06) v1(216.4,52.48) v1(216.35,51.9) v1(216.49,172.46) v1(216.49,169.92) v1(216.49,167.38) v1(216.49,164.84) v1(216.49,162.3) v1(216.49,159.76) v1(216.49,157.22) v1(216.49,154.68) v1(216.49,152.14) v1(216.49,149.6) v1(216.49,147.06) v1(216.49,144.52) v1(216.49,141.98) v1(216.49,132.99) v1(216.49,130.45) v1(216.49,127.91) v1(216.49,125.37) v1(216.49,122.83) v1(216.49,120.29) v1(216.49,117.75) v1(216.5,115.21) v1(216.61,101.91) v1(216.67,112.68) v1(217.04,110.17) v1(217.59,107.69) v1(218.34,105.26) v1(218.79,94.61) v1(219.2,87.51) v1(219.27,102.9) v1(220.37,100.61) v1(220.58,96.38) v1(221.2,85.97) v1(221.64,98.41) v1(223.65,85.4) v1(224.15,75.84) v1(224.15,75.23) v1(224.15,74.65) v1(224.15,74.07) v1(224.74,75.84) v1(224.74,75.23) v1(224.74,74.65) v1(224.74,74.07) v1(225.32,75.84) v1(225.32,75.23) v1(225.32,74.65) v1(225.32,74.07) v1(225.96,75.84) v1(225.96,75.23) v1(225.96,74.65) v1(225.96,74.07) v1(226.12,85.89) v1(226.54,75.84) v1(226.54,75.23) v1(226.54,74.65) v1(226.54,74.07) v1(226.46,71.6) v1(226.49,70.84) v1(226.47,70.02) v1(226.46,69.22) v1(227.68,32.82) v1(228.24,87.28) v1(228.7,32.85) v1(229.66,32.85) v1(230.44,86.1) v1(231.49,42.45) v1(232.1,41.08) v1(232.23,47.2) v1(233.47,42.45) v1(233.63,60.8) v1(233.65,62.78) v1(233.73,47.2) v1(234.01,50.37) v1(234.51,57.64) v1(234.62,63.33) v1(234.62,59.31) v1(234.69,49.08) v1(234.92,22.25) v1(234.95,21.42) v1(235.12,52.78) v1(235.3,61.19) v1(235.35,47.12) v1(235.43,42.45) v1(235.51,51.03) v1(235.63,56.59) v1(235.91,49.84) v1(236.47,57.63) v1(236.57,59.08) v1(236.72,42.09) v1(236.65,36) v1(237.07,42.57) v1(237.16,52.81) v1(237.23,36) v1(237.59,56.6) v1(238.81,21.9) v1(239.19,77.78) v1(239.19,76.64) v1(239.44,82.03) v1(239.42,21.9) v1(239.44,21.31) v1(240,38.08) v1(240.28,39.35) v1(240.41,77.78) v1(240.41,76.64) v1(240.43,22.86) v1(240.43,22.08) v1(240.56,23.73) v1(240.7,66.88) v1(241.25,37.75) v1(241.35,23.75) v1(241.8,82.55) v1(242.01,66.98) v1(241.96,39.2) v1(242.14,65.6) v1(242.11,23.75) v1(243.65,64.72) v1(244.34,82.55) v1(244.41,71.52) v1(245.41,66.15) v1(245.46,29.18) v1(245.91,77.15) v1(246.61,73.22) v1(246.88,82.55) v1(247.2,66.09) v1(249.42,82.55) v1(251.96,82.55) v1(252.73,57.66) v1(254.5,82.55) v1(255.88,20.45) v1(256.61,20.45) v1(257.04,82.55) v1(257.53,20.45) v1(258.26,20.45) v1(259.58,82.55) v1(259.82,19.14) v1(260.67,64.62) v1(261.24,61.4) v1(262.12,82.55) v1(262.36,19.14) v1(262.63,62.64) v1(262.76,63.76) v1(264.66,82.55) v1(264.9,19.14) v1(265.68,22.63) v1(265.67,21.89) v1(267.2,82.55) v1(267.44,19.14) v1(267.53,64.8) v1(267.69,66.17) v1(269.52,64.75) v1(269.74,82.55) v1(269.98,19.14) v1(270.68,38.76) v1(272.28,82.55) v1(274.82,82.55) v1(277.36,82.55) v1(278.51,62.41) v1(278.48,21.59) v1(279.12,62.41) v1(279.33,25.14) v1(279.9,82.55) v1(280.82,24.57) v1(281.28,70.77) v1(281.43,79.18) v1(281.4,74.63) v1(281.66,77.55) v1(282.17,71.04) v1(282.25,23.55) v1(282.44,82.55) v1(282.47,65.64) v1(283.54,65.66) v1(284.12,64.9) v1(284.68,63.66) v1(284.65,32.19) v1(284.68,31.19) v1(284.98,82.55) v1(285.09,41.13) v1(285.16,31.68) v1(285.54,63.86) v1(285.59,32.16) v1(285.67,31.17) v1(286.64,62.87) v1(287.25,61.47) v1(287.52,82.55) v1(287.68,76.41) v1(287.68,75.11) v1(287.73,73.79) v1(287.75,72.65) v1(288.85,76.38) v1(288.85,75.09) v1(288.9,73.77) v1(288.92,72.62) v1(289.51,46.74) v1(289.71,24.49) v1(289.66,23.32) v1(290.06,82.55) v1(290.19,76.38) v1(290.19,75.09) v1(290.24,73.77) v1(290.27,72.62) v1(290.7,46.76) v1(291.31,76.36) v1(291.31,75.06) v1(291.36,73.74) v1(291.39,72.6) v1(291.64,53.29) v1(291.64,52.1) v1(291.66,55.81) v1(292.6,82.55) v1(293.24,45.93) v1(293.24,22.46) v1(293.27,21.75) v1(294.31,24.69) v1(294.64,45.95) v1(295.14,82.55) v1(295.65,57.08) v1(295.65,55.4) v1(295.73,53.6) v1(295.68,51.84) v1(295.73,50.04) v1(296.43,30.14) v1(297.94,22.81) v1(297.92,19.14) v1(297.99,21.09) v1(300.46,19.11) v1(301.93,32.92) v1(302.49,17.74) v1(302.84,15.26) v1(302.84,12.72) v1(302.84,10.18) v1(302.84,7.64) v1(302.84,5.1) v1(302.84,2.56) v1(303.25,26.27) v1(303.49,27.97) v1(304.11,0.74) v1(304.53,56.93) v1(304.52,31.17) v1(304.64,14.53) v1(304.77,12.97) v1(305.3,82.55) v1(305.25,75.16) v1(305.43,71.94) v1(305.41,68.66) v1(305.43,27.97) v1(305.7,8.28) v1(305.89,25.26) v1(306.32,27.28) v1(306.65,0.74) v1(306.96,38.38) v1(307.84,82.55) v1(308.63,79.56) v1(310,81.17) v1(310.38,82.55) v1(312.2,46.86) v1(312.33,40.39) v1(312.38,80.69) v1(312.92,82.55) v1(314.74,46.86) v1(314.71,8.58) v1(315.46,82.55) v1(316.81,0.74) v1(317.41,40.39) v1(318,82.55) v1(318.07,45.11) v1(318.07,42.57) v1(318.07,7.64) v1(318.07,5.1) v1(318.07,2.56) v2(143.07,75.9) v2(153.72,171.66) v2(189.48,81.66) v2(191.26,174.07) v2(312.06,43.67) v4(153.14,137.78) v4(153.95,128.55) v4(153.92,122.84) v4(154.07,142.12) v4(154.13,131.55) v4(156.61,118.62) v4(157.43,117.99) v4(157.58,114.35) v4(157.81,149.76) v4(158.18,149.38) v4(158.17,146.68) v4(158.73,150.59) v4(158.8,147.45) v4(158.84,116.64) v4(159.65,168.22) v4(159.74,113.03) v4(159.79,116.97) v4(159.93,115.49) v4(160.05,150.03) v4(160.13,145.96) v4(160.12,114.22) v4(160.18,148.71) v4(160.27,147.41) v4(160.25,134.83) v4(160.27,134.2) v4(160.41,168.97) v4(160.44,167.48) v4(160.93,145.33) v4(161.16,168.22) v4(161.31,149.79) v4(161.67,146.12) v4(161.7,144.66) v4(161.68,129.94) v4(161.65,128.53) v4(161.68,127.8) v4(161.65,126.43) v4(161.65,125.03) v4(161.76,146.83) v4(161.95,144) v4(162.13,114.47) v4(162.23,125.73) v4(162.23,115.34) v4(162.34,145.32) v4(162.33,125.02) v4(162.25,124.34) v4(162.34,117.32) v4(162.42,129.94) v4(163,170.12) v4(163.14,169.02) v4(163.14,134.14) v4(163.14,133.43) v4(163.14,132.74) v4(163.12,132.03) v4(163.09,131.32) v4(163.12,130.64) v4(163.17,125.73) v4(163.23,109.31) v4(163.22,108.62) v4(163.47,150.25) v4(163.73,139.74) v4(163.67,134.14) v4(163.7,129.95) v4(163.75,135.53) v4(163.75,128.53) v4(163.75,127.13) v4(163.75,126.43) v4(163.77,122.24) v4(163.86,141.03) v4(163.88,116.82) v4(164.39,145.93) v4(164.37,144.52) v4(164.47,139.74) v4(164.53,126.44) v4(164.51,123.63) v4(164.52,122.23) v4(164.45,115.23) v4(164.48,109.81) v4(164.48,109.01) v4(164.48,108.37) v4(164.55,134.13) v4(164.56,132.74) v4(164.55,132.02) v4(164.58,131.33) v4(164.89,167.86) v4(165.13,143.92) v4(165.14,142.5) v4(165.11,139.72) v4(165.15,145.37) v4(165.15,126.42) v4(165.15,122.93) v4(165.15,122.23) v4(165.3,140.54) v4(165.67,168.98) v4(165.73,109.31) v4(165.73,108.51) v4(165.73,107.87) v4(165.9,143.23) v4(165.88,128.62) v4(166.09,144.55) v4(166.32,145.97) v4(166.55,142.51) v4(167.22,146.03) v4(167.24,144.69) v4(167.19,116.62) v4(167.23,115.24) v4(167.18,111.64) v4(167.28,143.22) v4(167.26,140.42) v4(167.3,120.81) v4(167.89,168.99) v4(167.91,164.47) v4(167.9,137.63) v4(167.9,113.18) v4(168.04,143.95) v4(167.97,132.73) v4(167.95,122.93) v4(167.95,122.23) v4(168,115.81) v4(168.01,114.53) v4(168.39,112.01) v4(168.39,110.74) v4(168.49,115.27) v4(168.51,92.34) v4(168.51,89.34) v4(168.57,145.97) v4(168.63,140.39) v4(168.7,143.21) v4(168.7,122.2) v4(168.76,133.44) v4(169.19,111.44) v4(169.31,145.34) v4(169.29,142.57) v4(169.34,120.8) v4(169.34,113.11) v4(169.26,93.09) v4(169.36,140.37) v4(169.35,122.93) v4(170.05,143.31) v4(170.25,145.39) v4(170.28,144.48) v4(170.31,118.21) v4(170.25,116.72) v4(170.44,111.52) v4(170.54,115.81) v4(170.74,146.08) v4(170.7,120.67) v4(170.65,114.49) v4(170.77,134.87) v4(170.76,134.15) v4(170.75,133.43) v4(171.4,134.88) v4(171.44,134.13) v4(171.45,127.83) v4(172.13,125.01) v4(172.23,127.12) v4(172.19,121.55) v4(172.22,115.2) v4(172.17,92.31) v4(172.32,145.43) v4(172.32,120.76) v4(172.32,117.14) v4(172.41,144.26) v4(172.74,125.02) v4(172.74,122.93) v4(172.73,122.24) v4(172.69,116.7) v4(172.79,144.64) v4(172.75,123.52) v4(172.82,121.52) v4(173.07,91.36) v4(173.34,165.02) v4(173.53,145.34) v4(173.54,139.02) v4(173.51,120.7) v4(173.48,115.93) v4(173.57,143.92) v4(173.61,132.06) v4(173.61,118.07) v4(173.59,90.35) v4(173.76,93.84) v4(174.11,125.03) v4(174.12,124.34) v4(174.13,123.64) v4(174.11,122.93) v4(174.12,122.23) v4(174.24,139.69) v4(174.24,139.02) v4(174.24,132.06) v4(174.25,145.95) v4(174.3,144.61) v4(174.32,118.53) v4(174.39,116.72) v4(174.43,115.29) v4(174.55,142.95) v4(174.59,146.97) v4(174.77,145.39) v4(174.94,134.85) v4(174.89,117.28) v4(174.98,140.44) v4(175.04,125.02) v4(174.95,115.92) v4(175.26,93.09) v4(175.6,148.82) v4(175.63,116.63) v4(175.66,147.44) v4(175.7,146.04) v4(175.69,115.22) v4(176.02,93.85) v4(175.99,92.37) v4(176.28,149.52) v4(176.33,117.37) v4(176.41,168.95) v4(176.37,146.74) v4(176.44,145.35) v4(176.52,144.09) v4(176.71,142.89) v4(176.98,147.33) v4(176.96,146.03) v4(177,144.6) v4(177.06,139.04) v4(177.06,138.3) v4(177.05,115.93) v4(177.05,114.53) v4(177.16,168.22) v4(177.66,146.72) v4(177.73,120.81) v4(177.7,118.02) v4(177.78,149.49) v4(177.75,145.29) v4(177.78,143.96) v4(178.39,146.03) v4(178.54,144.56) v4(178.47,129.92) v4(178.47,129.21) v4(178.47,125.05) v4(178.47,124.34) v4(178.47,122.96) v4(178.47,122.23) v4(178.58,120.54) v4(178.64,115.42) v4(178.7,171.16) v4(178.66,167.47) v4(178.81,148.29) v4(178.8,116.94) v4(178.94,144.21) v4(178.93,115.87) v4(178.98,145.37) v4(179.06,146.78) v4(179.17,136.94) v4(179.16,134.75) v4(179.23,131.4) v4(179.16,130.58) v4(179.18,128.54) v4(179.34,169.95) v4(179.33,135.46) v4(179.33,133.46) v4(179.31,127.25) v4(179.32,126.46) v4(179.3,120.97) v4(179.73,149.02) v4(179.78,147.43) v4(179.84,116.62) v4(179.98,143.13) v4(180.52,149.5) v4(180.62,117.28) v4(180.73,146.79) v4(180.78,145.41) v4(181.05,167.49) v4(181.23,147.51) v4(181.3,143.26) v4(181.32,136.93) v4(181.37,141.67) v4(181.39,117.41) v4(181.82,143.73) v4(181.94,148.17) v4(181.91,140.23) v4(181.9,136.92) v4(181.87,134.01) v4(181.9,132.72) v4(181.92,116.63) v4(181.97,146.71) v4(181.97,122.93) v4(181.98,115.93) v4(182,114.55) v4(182.28,149.34) v4(182.28,118.32) v4(182.57,143.17) v4(182.57,129.27) v4(182.65,124.96) v4(182.64,120.9) v4(182.74,145.96) v4(182.65,137.61) v4(182.7,133.53) v4(182.69,131.88) v4(182.65,126.43) v4(182.7,123.44) v4(182.72,119.25) v4(182.79,117.19) v4(182.87,113.91) v4(182.93,112.02) v4(183.02,142.23) v4(183.11,135.85) v4(183.13,121.23) v4(183.07,92.32) v4(183.16,168.22) v4(183.21,146.81) v4(183.19,131.49) v4(183.2,129.72) v4(183.25,144.04) v4(183.31,139.9) v4(183.34,138.2) v4(183.25,133.96) v4(183.34,127.19) v4(183.39,149.9) v4(183.39,136.87) v4(183.38,132.73) v4(183.35,125.8) v4(183.35,124.31) v4(183.46,148.86) v4(183.78,111.55) v4(183.91,173.47) v4(183.91,168.97) v4(184.01,143.23) v4(184.03,139) v4(184.03,137.72) v4(184.03,134.79) v4(184.03,126.46) v4(184.03,116.65) v4(184.06,145.96) v4(184.1,140.25) v4(184.11,136.07) v4(184.07,123.51) v4(184.12,119.24) v4(184.06,118.04) v4(184.06,115.27) v4(184.08,113.76) v4(184.23,129.47) v4(184.17,121.03) v4(184.63,144.13) v4(184.61,131.49) v4(184.6,123.4) v4(184.66,164.47) v4(184.73,139.78) v4(184.7,134.1) v4(184.74,125.12) v4(184.65,118.91) v4(184.7,117.14) v4(184.74,115.9) v4(184.74,114.6) v4(184.68,113.16) v4(184.81,141.85) v4(184.76,135.52) v4(184.75,127.1) v4(185.05,111.76) v4(185.32,92.32) v4(185.41,133.36) v4(185.38,115.19) v4(185.42,113.82) v4(185.49,140.35) v4(185.5,134.89) v4(185.45,118.09) v4(185.46,116.65) v4(185.74,95.43) v4(186.07,135.85) v4(186.14,134.12) v4(186.14,114.48) v4(186.09,93.44) v4(186.15,115.96) v4(186.55,87.47) v4(186.84,132) v4(186.85,118.06) v4(186.92,134.16) v4(186.85,115.2) v4(187.2,90.42) v4(187.16,86.2) v4(187.29,149.03) v4(187.31,116.73) v4(187.58,117.96) v4(187.72,92.37) v4(187.88,112.09) v4(187.96,91.19) v4(188.09,131.34) v4(188.17,114.88) v4(188.2,113.56) v4(188.32,134.94) v4(188.3,96.09) v4(188.3,95.34) v4(188.42,133.5) v4(188.92,132.92) v4(189.02,130.39) v4(189.8,93.09) v4(190.21,133.02) v4(190.56,93.85) v4(201.63,107.81) v4(201.98,138.91) v4(202.73,139.66) v4(203.48,154.96) v4(203.48,138.91) v4(204.99,157.68) v4(206.14,123.85) v4(206.13,122.37) v4(206.14,108.56) v4(206.13,106.31) v4(206.48,162.44) v4(206.47,147.14) v4(206.47,139.66) v4(206.54,119.42) v4(206.87,124.63) v4(206.88,123.12) v4(206.88,107.81) v4(206.88,101.81) v4(207.23,161.71) v4(207.23,146.41) v4(207.23,140.41) v4(207.28,104.57) v4(207.63,123.87) v4(207.61,108.56) v4(207.68,118.63) v4(207.65,116.38) v4(207.86,121.29) v4(208.02,159.68) v4(208,154.98) v4(207.95,147.17) v4(207.98,139.66) v4(208.38,124.62) v4(208.61,105.63) v4(208.98,144.22) v4(209.66,106.14) v4(209.9,159.11) v4(209.97,103.53) v4(211.37,105.74) v5(11.3,73.33) v5(11.3,72.57) v5(11.3,71.81) v5(11.3,71.05) v5(11.3,70.29) v5(12.06,73.33) v5(12.06,72.57) v5(12.06,71.81) v5(12.06,71.05) v5(12.06,70.29) v5(32.69,34.93) v5(33.44,34.93) v5(34.2,34.93) v5(34.94,34.92) v5(35.73,34.96) v5(36.49,34.98) v5(37.25,34.98) v5(37.99,34.95) v5(49.65,87.07) v5(50.41,87.1) v5(50.83,29.37) v5(50.85,30.1) v5(50.85,28.63) v5(51.18,87.1) v5(51.59,30.1) v5(51.58,29.37) v5(51.91,87.13) v5(55.67,76.17) v5(57.21,30.89) v5(57.25,31.88) v5(57.83,31.37) v5(57.9,30.62) v5(60.07,85.07) v5(60.78,85.32) v5(61.59,85.88) v5(62.3,86.29) v5(64.89,79.19) v5(64.89,78.45) v5(65.02,107.65) v5(65.99,143.87) v5(66.09,143.06) v5(66.32,107.65) v5(66.32,106.91) v5(66.6,144.43) v5(66.7,143.54) v5(67.31,144.07) v5(71.75,69.79) v5(72.16,111.71) v5(72.17,110.98) v5(72.18,110.24) v5(72.17,109.48) v5(72.18,108.74) v5(72.49,69.79) v5(72.64,69.04) v5(73.02,88.19) v5(73.02,87.46) v5(73.02,86.67) v5(73.02,85.91) v5(73.22,69.78) v5(73.28,130.66) v5(73.28,129.9) v5(73.38,69.03) v5(74.04,131.78) v5(73.96,69.78) v5(73.99,67.64) v5(74.23,68.33) v5(74.26,132.65) v5(74.27,130.48) v5(74.27,129.72) v5(74.54,69.33) v5(74.65,131.14) v5(74.79,133.16) v5(74.78,132.13) v5(75.32,133.67) v5(75.32,132.63) v5(75.29,131.6) v5(75.26,129.85) v5(75.43,130.71) v5(75.84,132.08) v5(75.85,134.18) v5(75.87,133.15) v5(76.1,131.27) v5(76.12,130.15) v5(76.39,134.71) v5(76.39,133.67) v5(76.37,132.59) v5(76.65,131.83) v5(76.7,130.69) v5(76.92,134.2) v5(76.92,133.08) v5(77.13,101.96) v5(77.14,101.22) v5(77.21,132.39) v5(77.29,131.27) v5(77.41,133.63) v5(77.47,54.33) v5(78.25,54.33) v5(78.41,141.18) v5(78.56,151.16) v5(78.58,150.42) v5(78.9,141.72) v5(78.97,140.62) v5(79.45,142.22) v5(79.46,141.17) v5(79.98,142.8) v5(80.01,141.66) v5(80.54,142.24) v5(92.84,153.07) v5(92.92,152.08) v5(92.92,151.02) v5(92.92,149.87) v5(93.96,153.07) v5(93.96,152.08) v5(93.96,151.02) v5(93.96,149.87) v5(95.16,153.05) v5(96.43,153.05) v5(97.57,152.08) v5(97.57,151.09) v5(97.57,150.02) v5(102.12,130.42) v5(102.1,129.62) v5(102.1,128.83) v5(102.61,169.35) v5(102.61,168.46) v5(102.61,167.57) v5(102.61,166.68) v5(103.37,169.35) v5(103.37,168.46) v5(103.37,167.57) v5(103.37,166.68) v5(104.14,169.35) v5(104.14,168.46) v5(104.14,167.57) v5(104.14,166.68) v5(104.9,169.35) v5(104.9,168.46) v5(104.9,167.57) v5(104.9,166.68) v5(105.66,179.38) v5(105.66,169.35) v5(105.66,168.46) v5(105.66,167.57) v5(105.66,166.68) v5(106.42,179.38) v5(107.18,179.38) v5(107.54,133.71) v5(107.54,132.92) v5(107.54,132.16) v5(107.55,134.51) v5(108.15,136.48) v5(112.98,169.35) v5(112.98,168.46) v5(112.98,167.57) v5(112.98,166.68) v5(113.74,169.35) v5(113.74,168.46) v5(113.74,167.57) v5(113.74,166.68) v5(114.5,169.35) v5(114.5,168.46) v5(114.5,167.57) v5(114.5,166.68) v5(114.64,133.54) v5(114.63,132.74) v5(115.26,169.35) v5(115.26,168.46) v5(115.26,167.57) v5(115.26,166.68) v5(115.44,179.38) v5(116.03,169.35) v5(116.03,168.46) v5(116.03,167.57) v5(116.03,166.68) v5(116.2,179.38) v5(116.96,179.38) v5(120.52,179.38) v5(121.28,179.38) v5(122.04,179.38) v5(123.39,169.35) v5(123.39,168.46) v5(123.39,167.57) v5(123.39,166.68) v5(124.16,169.35) v5(124.16,168.46) v5(124.16,167.57) v5(124.16,166.68) v5(124.92,169.35) v5(124.92,168.46) v5(124.92,167.57) v5(124.92,166.68) v5(125.68,169.35) v5(125.68,168.46) v5(125.68,167.57) v5(125.68,166.68) v5(126.44,169.35) v5(126.44,168.46) v5(126.44,167.57) v5(126.44,166.68) v5(130.83,179.28) v5(131.59,179.28) v5(132.36,179.28) v5(132.72,151.22) v5(132.73,149.14) v5(132.75,150.22) v5(133.37,137.49) v5(133.76,169.39) v5(133.76,168.5) v5(133.76,167.62) v5(133.76,166.73) v5(133.75,165.97) v5(134,149.14) v5(134.13,146.6) v5(134.13,145.33) v5(134.16,147.88) v5(134.52,169.39) v5(134.52,168.5) v5(134.52,167.62) v5(134.52,166.73) v5(134.52,165.97) v5(134.69,153.11) v5(134.94,146.6) v5(134.94,145.33) v5(135.28,169.39) v5(135.28,168.5) v5(135.28,167.62) v5(135.28,166.73) v5(135.28,165.97) v5(135.27,149.14) v5(135.27,147.87) v5(135.73,153.11) v5(135.68,146.6) v5(135.68,145.33) v5(136.04,169.39) v5(136.04,168.5) v5(136.04,167.62) v5(136.04,166.73) v5(136.04,165.94) v5(136.44,152.03) v5(136.44,150.97) v5(136.44,149.82) v5(136.44,148.78) v5(136.44,147.61) v5(136.44,146.6) v5(136.44,145.33) v5(136.78,153.11) v5(137.4,152.03) v5(137.38,146.6) v5(137.38,145.33) v5(142.11,177.6) v5(142.11,176.71) v5(142.11,175.82) v5(142.22,90.38) v5(142.26,89.59) v5(142.9,177.6) v5(142.9,176.71) v5(142.9,175.82) v5(142.9,174.93) v5(143.23,159.19) v5(143.18,154.84) v5(143.15,154.08) v5(144.2,173.28) v5(144.2,172.39) v5(144.2,171.5) v5(150.54,75.72) v5(150.54,74.98) v5(163.01,53.1) v5(163.01,52.21) v5(163.01,51.29) v5(163.9,53.1) v5(163.9,52.21) v5(163.9,51.29) v5(164.89,51.21) v5(165.14,56.35) v5(165.14,55.46) v5(165.14,54.57) v5(165.14,53.68) v5(165.8,51.19) v5(166.03,56.35) v5(166.03,55.46) v5(166.06,54.57) v5(166.08,53.68) v5(166.72,51.21) v5(166.87,78.16) v5(166.9,77.42) v5(167.64,78.16) v5(168.4,78.16) v5(168.37,77.37) v5(169.18,78.16) v5(169.19,77.4) v5(169.94,79.91) v5(169.94,79.17) v5(169.94,78.41) v5(170.11,77.45) v5(170.71,79.91) v5(170.71,79.17) v5(170.71,78.41) v5(170.84,77.45) v5(171.49,78.15) v5(171.58,77.42) v5(172.23,78.16) v5(172.32,77.42) v5(172.91,53.1) v5(172.91,52.21) v5(172.91,51.29) v5(172.97,78.13) v5(173.8,53.1) v5(173.8,52.21) v5(173.8,51.29) v5(174.39,79.66) v5(174.76,51.17) v5(175.04,56.35) v5(175.04,55.46) v5(175.04,54.57) v5(175.04,53.68) v5(175.68,51.17) v5(175.93,56.35) v5(175.93,55.46) v5(175.96,54.57) v5(175.98,53.68) v5(176.59,51.17) v5(182.89,53.12) v5(182.89,52.23) v5(182.89,51.32) v5(183.68,53.1) v5(183.68,52.21) v5(183.68,51.29) v5(184.74,51.19) v5(185.02,56.37) v5(185.02,55.48) v5(185.02,54.6) v5(185.02,53.76) v5(185.09,79.45) v5(185.09,78.69) v5(185.09,77.8) v5(185.09,77.06) v5(185.09,76.3) v5(185.09,75.56) v5(185.66,51.19) v5(185.77,79.12) v5(185.77,78.29) v5(185.75,77.45) v5(185.77,76.64) v5(185.8,75.85) v5(185.91,56.37) v5(185.91,55.48) v5(185.94,54.6) v5(185.96,53.76) v5(186.44,79.48) v5(186.44,78.74) v5(186.44,77.85) v5(186.44,77.11) v5(186.48,76.38) v5(186.51,75.62) v5(186.57,51.19) v5(187.27,76.56) v5(187.27,75.82) v5(188.16,76.56) v5(188.16,75.82) v5(188.89,76.56) v5(188.89,75.82) v5(189.05,23.03) v5(189.05,22.29) v5(189.78,76.58) v5(189.78,75.84) v5(189.81,23.03) v5(189.81,22.29) v5(190.43,164.95) v5(190.43,164.19) v5(190.52,76.58) v5(190.52,75.84) v5(190.55,23.03) v5(190.55,22.29) v5(191.28,76.58) v5(191.28,75.82) v5(191.41,23.07) v5(191.39,22.33) v5(192.02,76.58) v5(192.02,75.82) v5(192.75,79.65) v5(192.75,78.92) v5(192.75,78.16) v5(192.75,77.32) v5(192.75,76.58) v5(192.75,75.82) v5(192.92,173.94) v5(192.9,53.17) v5(192.9,52.28) v5(192.9,51.37) v5(193.24,174.6) v5(193.52,79.65) v5(193.52,78.92) v5(193.52,78.16) v5(193.52,77.29) v5(193.52,76.56) v5(193.52,75.79) v5(193.74,173.93) v5(193.79,53.17) v5(193.79,52.28) v5(193.79,51.37) v5(194.1,174.57) v5(194.3,79.65) v5(194.3,78.92) v5(194.3,78.16) v5(194.3,77.29) v5(194.3,76.56) v5(194.3,75.79) v5(194.76,51.24) v5(195.04,56.42) v5(195.04,55.54) v5(195.04,54.65) v5(195.04,53.76) v5(195.67,51.24) v5(195.93,56.42) v5(195.93,55.54) v5(195.95,54.65) v5(195.98,53.76) v5(196.59,51.24) v5(202.59,170.28) v5(202.67,174.22) v5(202.67,173.46) v5(202.94,53.15) v5(202.94,52.26) v5(202.94,51.34) v5(203.38,170.26) v5(203.82,53.15) v5(203.82,52.26) v5(203.82,51.34) v5(203.86,27.45) v5(204.12,170.26) v5(204.62,28.18) v5(204.59,27.44) v5(204.67,172.11) v5(204.79,51.22) v5(205.07,56.4) v5(205.07,55.51) v5(205.07,54.62) v5(205.07,53.73) v5(205.43,172.11) v5(205.38,27.45) v5(205.7,51.22) v5(205.74,19.87) v5(205.96,56.4) v5(205.96,55.51) v5(205.98,54.62) v5(206.01,53.73) v5(206.14,28.19) v5(206.14,27.45) v5(206.19,172.11) v5(206.51,19.89) v5(206.62,51.22) v5(208.18,77.93) v5(208.94,77.93) v5(208.93,77.17) v5(209.06,79.65) v5(209.06,78.92) v5(209.67,77.93) v5(209.7,77.17) v5(209.82,79.65) v5(209.82,78.92) v5(209.78,76.41) v5(209.9,179.45) v5(210.43,77.17) v5(210.46,77.93) v5(210.54,76.41) v5(211.22,77.93) v5(211.22,77.17) v5(211.32,76.41) v5(212.01,77.93) v5(212.06,77.17) v5(212.08,76.41) v5(212.77,77.93) v5(212.82,77.17) v5(212.82,76.41) v5(212.96,53.17) v5(212.96,52.28) v5(212.96,51.37) v5(213.85,53.17) v5(213.85,52.28) v5(213.85,51.37) v5(214.74,51.24) v5(215.1,56.42) v5(215.1,55.54) v5(215.1,54.65) v5(215.1,53.76) v5(215.59,51.25) v5(215.99,56.42) v5(215.99,55.54) v5(216.01,54.65) v5(216.04,53.76) v5(216.4,51.24) v5(221.69,47.78) v5(221.69,47.04) v5(222.42,47.79) v5(222.42,47.06) v5(222.93,72.72) v5(222.88,71.96) v5(222.91,71.22) v5(222.93,70.46) v5(222.91,69.67) v5(223.64,71.96) v5(223.62,68.92) v5(223.69,72.72) v5(223.67,71.23) v5(223.69,70.46) v5(223.67,69.68) v5(224.43,72.72) v5(224.43,71.96) v5(224.41,71.23) v5(224.43,70.46) v5(224.41,69.68) v5(224.36,68.91) v5(225.1,68.91) v5(225.19,72.72) v5(225.19,71.96) v5(225.17,71.23) v5(225.19,70.46) v5(225.17,69.68) v5(225.83,68.91) v5(225.93,71.99) v5(225.9,71.23) v5(225.93,70.46) v5(225.9,69.68) v5(225.88,54.23) v5(226.97,54.03) v5(228.63,50.98) v5(228.63,50.24) v5(229.66,47.18) v5(229.66,46.44) v5(230.4,46.44) v5(230.7,32.72) v5(231.16,47.18) v5(231.16,46.44) v5(232.94,59.13) v5(233.47,58.58) v5(241.22,22.88) v5(241.22,22.14) v5(242.01,22.88) v5(242.01,22.14) v5(244.06,29.24) v5(244.8,29.24) v5(253.92,25.84) v5(254.66,25.84) v5(258.8,26.78) v5(259.58,26.78) v5(260.37,26.78) v5(263.79,32.95) v5(263.78,32.21) v5(296.36,26.39) v5(303.63,34.34) v5(304.09,6.89) v5(304.39,34.34) v5(304.44,6.23) v5(304.85,6.89) v7(135.04,144.03) v7(135.07,142.86) v7(135.91,143.32) v7(135.93,142.15)
