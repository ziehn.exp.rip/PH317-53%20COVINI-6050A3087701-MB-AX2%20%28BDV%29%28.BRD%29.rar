# Allegro board PH317-53 COVINI-6050A3087701-MB-AX2 (BDV)(.BRD).brd (continued)
## Copper pours and planes (outline as drawn) (continued)
DGND on L3: 126.59,136.71 126.59,123.93 127.61,122.91 132.51,122.91 133.37,122.05 133.37,121.39 133.52,121.24 134.82,121.24 134.9,121.31 134.9,136.4 134.59,136.71
DGND on L3, L10: 222.48,75.59 222.48,69.65 223.49,68.63 226.36,68.63 226.82,69.09 226.82,75.92 226.67,76.08 222.96,76.08
DGND on L4: outline of 173 points within 0.51,0.51 318.3,180.49 ; 1 cut-out
DGND on L5: 305.3,68.3 306.42,68.3 309.62,71.5 309.62,77.19 309.32,77.5 306.68,77.5 304.9,75.72 304.9,68.71
DGND on L5: 222.48,75.59 222.48,69.65 223.49,68.63 226.36,68.63 226.82,69.09 226.82,75.95 226.67,76.1 222.98,76.1
DGND on L6: 306.57,66.96 308,66.96 309.62,68.58 309.62,76.64 306.22,76.64 304.9,75.31 304.9,68.63
DGND on L6: 287.17,71.05 292.6,71.05 292.86,71.3 292.86,77.58 292.6,77.83 286.33,77.83 286.08,77.58 286.08,72.14
DGND on L7: outline of 168 points within 0.51,0.51 318.3,180.49 ; 1 cut-out
DGND on L8: 222.48,75.59 222.48,69.65 223.49,68.63 226.36,68.63 226.79,69.07 226.79,75.92 226.67,76.05 222.93,76.05
DGND on L9: outline of 169 points within 0.51,0.51 318.3,180.49 ; 1 cut-out
DGND on L10: 134.49,120.37 134.18,120.68 134.18,122 131.9,124.29 131.9,136.25 132.28,136.63 132.89,136.63 132.89,136.68 134.21,136.68 134.87,137.34 137,137.34 139.44,134.9 139.44,121.47 138.35,120.37
DGND on L11: outline of 167 points within 0.51,0.51 318.3,180.49 ; 1 cut-out
DGND_CHASSIS1 on TOP, BOTTOM: 305.81,63.43 305.81,62.54 307.49,60.86 307.49,57.41 307.82,57.08 318.97,57.08 319.22,57.33 319.22,63.66 318.82,64.06 306.45,64.06
DGND_CHASSIS2 on TOP, BOTTOM: 306.37,25.23 306.37,24.46 306.75,24.08 307.24,24.08 310.18,21.14 310.18,18.9 310.46,18.62 317.29,18.62 318.46,19.79 318.46,24.82 317.65,25.63 306.78,25.63
DGND_CHASSIS4 on TOP: 303.15,134.01 302.76,134.39 302.76,138.31 303.17,138.71 303.71,138.71 304.03,138.5 304.4,138.43 313.99,138.43 314.49,137.87 315.27,137.87 315.27,134.85 314.49,134.85 313.99,134.3 304.4,134.3 304.03,134.22 303.71,134.01
DGND_CHASSIS4 on BOTTOM: 301.93,133.18 301.85,133.25 301.85,133.76 301.92,133.76 302.05,133.83 302.12,133.97 302.12,134.36 302.08,134.46 302.01,134.53 301.97,134.61 302.01,134.69 302.09,134.76 302.12,134.86 302.12,135.25 302.05,135.39 301.91,135.46 301.85,135.46 301.85,135.68 301.89,135.74 302.06,135.74 302.08,135.72 302.15,135.63 302.25,135.59 302.55,135.59 302.69,135.66 302.76,135.8 302.76,136.19 302.72,136.29 302.65,136.36 302.6,136.44 302.65,136.51 302.72,136.59 302.76,136.69 302.76,137.08 302.72,137.18 302.64,137.26 302.61,137.27 302.61,138.28 303.25,138.92 303.55,138.92 303.91,138.56 304.4,138.43 313.99,138.43 314.49,137.87 315.27,137.87 315.27,134.85 314.49,134.85 313.99,134.3 304.4,134.3 303.69,133.99 303.39,133.2 303.32,133.18
DGND_CHASSIS5 on TOP: 313.99,119.43 314.49,118.87 315.27,118.87 315.27,114.85 305.56,114.85 304.5,115.32 303.73,114.45 303.72,114.41 303.37,114.41 302.91,114.87 302.91,115.14 302.87,115.24 302.79,115.31 302.79,116.16 302.85,116.23 302.88,116.32 302.88,116.71 302.85,116.8 302.79,116.87 302.79,119.28 303.12,119.61 303.83,119.61 304.1,119.48 304.4,119.43
DGND_CHASSIS5 on BOTTOM: 313.99,119.43 314.49,118.87 315.27,118.87 315.27,114.85 305.56,114.85 304.5,115.32 303.73,114.45 303.72,114.41 303.37,114.41 302.91,114.87 302.91,115.18 302.87,115.28 302.79,115.36 302.79,115.98 302.85,116.05 302.88,116.14 302.88,116.53 302.85,116.62 302.79,116.69 302.79,118.06 302.87,118.14 302.87,119.36 303.12,119.61 303.83,119.61 304.1,119.48 304.4,119.43
GND_A on TOP, BOTTOM, L2, L3, L4, L5, L6, L7, L8, L9, L10, L11: 280.75,137.67 280.4,137.82 280.26,138.16 280.26,145.06 279.82,146.13 278.75,146.57 273.45,146.57 272.38,146.13 271.94,145.07 271.94,141.01 271.8,140.67 271.45,140.52 265.6,140.52 264.53,140.08 264.09,139.01 264.09,138.71 263.95,138.37 263.6,138.22 260.25,138.22 259.9,138.37 259.76,138.71 259.76,145.71 259.9,146.06 260.25,146.2 262.1,146.2 263.17,146.65 263.61,147.71 263.61,154.66 263.75,155.01 264.1,155.16 285.75,155.16 286.82,155.6 287.26,156.66 287.26,156.85 292.75,156.85 293.1,156.71 293.24,156.36 293.24,138.16 293.1,137.82 292.75,137.67
GND_A1 on TOP: outline of 99 points within 255.51,85.79 268.28,119.47
GND_ALG on L2, L4, L6, L7, L9, L11: outline of 102 points within 273.77,114.1 315.24,173.61
GND_ALG on L5: outline of 102 points within 273.77,114.1 315.24,173.61
GND_PB on TOP (solid shape): 290.35,127.88 290.33,127.86 281.55,127.86 281.55,129.77 281.91,130.26 282.03,130.86 282.03,134.16 282.15,134.49 282.44,134.67 282.5,134.68 282.55,134.68 290.35,134.68
GND_PB on BOTTOM (solid shape): 294.2,112.86 291.2,112.86 291.2,113.7 291.2,113.74 291.2,115.36 291.85,115.36 291.85,113.36 291.85,113.33 291.86,113.28 291.87,113.23 291.9,113.18 291.93,113.13 291.97,113.09 292.02,113.06 292.06,113.04 292.12,113.02 292.17,113.01 292.2,113.01 293.2,113.01 293.23,113.01 293.28,113.02 293.34,113.04 293.38,113.06 293.43,113.09 293.47,113.13 293.5,113.18 293.53,113.23 293.54,113.28 293.55,113.33 293.55,113.36 293.55,115.36 293.55,115.39 293.54,115.44 293.53,115.5 293.5,115.55 293.47,115.59 293.43,115.63 293.38,115.66 293.34,115.69 293.28,115.71 293.23,115.71 293.2,115.72 292.2,115.72 292.17,115.71 292.12,115.71 292.06,115.69 292.02,115.66 291.97,115.63 291.93,115.59 291.9,115.55 291.87,115.5 291.86,115.44 291.85,115.39 291.85,115.36 291.2,115.36 291.2,115.86 294.2,115.86
GND_PB on BOTTOM (solid shape): 296.05,93.58 297.66,92.57 298.66,90.96 300.88,90.96 300.88,88.16 298.66,88.16 297.84,86.76 296.56,85.77 292.74,85.77 291.46,86.76 290.64,88.16 288.42,88.16 288.42,90.96 290.64,90.96 291.64,92.57 293.25,93.58 293.25,95.79 296.05,95.79
GND_PB on BOTTOM (solid shape): outline of 92 points within 301.45,85.77 315.27,94.46
GND_PB on TOP: 277.65,89.94 280.79,89.94 280.9,89.84 280.9,89.08 280.82,89.01 277.47,89.01 277.34,89.13 277.34,89.59 277.37,89.6 277.54,89.72 277.64,89.91
GND_PB on BOTTOM: 300.89,112.22 294.99,112.22 294.71,112.5 294.71,116.01 294.79,116.08 296.67,116.08 296.74,116.01 296.74,113.59 297.15,113.19 299.18,113.19 299.51,113.52 299.51,115.45 299.67,115.6 300.94,115.6 301.09,115.45 301.09,112.42
GND_PB on BOTTOM: 300.63,145.09 298.27,145.09 298.01,145.34 298.01,147.63 298.27,147.88 300.63,147.88 300.89,147.63 300.89,145.34
GND_PB on BOTTOM: 299.4,139.97 299.47,139.83 299.61,139.76 299.72,139.76 299.72,139.68 299.46,139.42 298.24,139.42 297.99,139.68 297.99,141.91 298.22,142.14 299.49,142.14 299.67,141.96 299.67,140.74 299.72,140.69 299.72,140.56 299.6,140.56 299.46,140.5 299.4,140.36
GND_PB on BOTTOM: 286.64,98.51 286.64,98.39 286.61,98.37 286.54,98.3 286.5,98.2 286.5,97.81 286.57,97.67 286.71,97.6 286.98,97.6 287.03,97.61 287.07,97.56 287.07,96.52 286.76,96.22 285.77,96.22 285.77,96.22 285.14,96.86 285.14,98.33 285.29,98.48 285.72,98.48 286.15,98.91 286.5,98.91 286.5,98.7 286.54,98.6 286.61,98.52
GND_PB on BOTTOM: 285.59,98.76 282.06,98.76 281.94,98.89 281.94,102.21 282.06,102.34 285.59,102.34 285.72,102.21 285.72,98.89
GND_PB on L2, L4, L7, L9, L11: outline of 255 points within 271.23,85.79 315.24,154.44
GND_PB on L3: outline of 247 points within 271.23,85.79 315.24,154.44
GND_PB on L3: 303.89,144.69 303.85,144.62 303.77,144.61 303.06,144.55 302.67,143.95 302.61,143.88 302.52,143.9 302.5,143.92 300.92,143.92 300.56,143.55 300.56,138.7 300.33,138.48 300.21,138.48 300.21,138.5 300.05,138.76 299.75,138.8 299.67,138.81 299.63,138.88 299.63,146.05 301.49,147.91 302.57,147.91 302.62,147.96 302.67,147.91 302.67,147.89 303.01,147.21 303.77,147.12 303.85,147.11 303.89,147.04
GND_PB on L5: outline of 291 points within 271.23,85.79 315.24,154.44
GND_PB on L8: outline of 327 points within 271.23,85.79 315.24,154.44 ; 2 cut-outs
GND_PB on L8: 282.55,113.43 282.46,113.48 282.48,113.58 282.87,113.97 286.97,113.97 287.05,113.92 287.03,113.82 286.64,113.43
GND_PB on L10: outline of 255 points within 271.23,85.79 315.24,154.44
P0V6S on L5 (solid shape): 152.6,63.27 152.6,62.03 152.37,61.8 150.44,61.8 150.44,63.45 152.42,63.45
P0V6S on TOP: 146.94,75.44 146.94,73.94 147.34,73.54 147.34,72.22 147.09,71.96 145.44,71.96 145.12,72.28 145.12,75.51 145.26,75.64 146.73,75.64
P0V6S on TOP: 151.63,63.43 151.63,62.11 151.81,61.93 154.43,61.93 154.56,62.06 154.56,63.68 155.19,64.32 155.19,65.59 154.94,65.84 153.29,65.84 152.52,65.08 152.52,64.32
P0V6S on BOTTOM: 75.21,81.87 75.21,80.29 75.23,80.27 76.2,80.27 76.45,80.01 76.45,76.15 77.63,74.97 77.63,73.5 77.87,73.26 79.6,73.26 79.88,73.54 79.88,76.97 78.71,78.13 78.71,83.39 78.36,83.75 76.45,83.75 76.32,83.62 76.32,83.24 76.07,82.99 75.94,82.99 75.82,82.86 75.82,82.48
P1V0S_DGPU on TOP (solid shape): 158.24,139.78 158.24,139.22 158.16,139.14 157.17,139.14 156.99,139.32 156.99,139.47 156.97,139.5 156.64,139.5 156.64,139.81 156.69,139.86 158.16,139.86
P1V0S_DGPU on TOP: 146.15,161.09 144.5,161.09 144.27,161.32 144.27,164.32 145.16,165.21 149.02,165.21 149.3,165.48 149.3,167.14 149.25,167.19 148.92,167.19 148.92,170.23 148.99,170.31 151.3,170.31 151.38,170.23 151.38,168.91 151.66,168.63 151.66,163.25 151.05,162.64 147.7,162.64
P1V0S_DGPU on TOP: 156.84,134.56 156.91,134.48 156.92,134.48 157.05,134.35 157.99,134.35 158.19,134.15 159.2,134.15 159.2,139.88 157.25,139.88 156.85,139.49 156.85,136.07 156.84,136.06
P1V0S_DGPU on TOP: 158.52,126.38 158.05,126.38 158.05,126.71 157.43,127.32 157.43,128.27 157.84,128.67 158.37,128.67 158.52,128.53
P1V0S_DGPU on BOTTOM: 158.31,137.83 159.11,137.03 159.11,135.26 158.8,134.95 156.94,134.95 156.89,135 156.89,135.41 157.25,135.77 157.5,135.77 157.71,135.97 157.71,136.35 157.72,136.36 157.24,136.84 157.02,136.84 156.79,137.07 156.79,137.79 156.83,137.83
P1V0S_DGPU on BOTTOM: 144.09,163.15 144.19,163.25 145.41,163.25 145.44,163.22 145.44,162.94 145.72,162.67 146.25,162.67 146.33,162.59 146.33,161.14 145.56,160.38 144.29,160.38 144.09,160.58
P1V0S_DGPU on BOTTOM: 157.2,123.3 157.2,128.76 159.05,128.76 159.05,123.35 159,123.3
P1V0S_DGPU on BOTTOM: 163.55,119.27 163.55,118.98 163.5,118.93 163.24,118.93 162.99,119.18 162.99,119.18 162.36,119.82 162.38,119.82 162.38,120.54 162.57,120.73 163.22,120.73 163.32,120.63 163.32,120.06 163.12,119.86 163.12,119.7
P1V0S_DGPU on BOTTOM: 207.9,179.89 152.65,179.89 152.65,178.16 154.73,178.16 154.99,178.41 156.51,178.41 156.77,178.16 208.1,178.16 208.2,178.26 208.2,179.58
P1V0S_DGPU on L8: 149.42,124.03 144.4,129.06 144.4,161.83 151.13,168.56 151.13,179.51 151.36,179.73 154.78,179.73 154.99,179.53 154.99,159.19 154.28,158.47 154.28,152.89 154.2,152.81 151.86,152.81 149.5,150.45 149.5,147.68 150.31,146.87 150.31,146.08 159.43,136.96 159.43,125.2 158.26,124.03
P1V0S_DGPU on L10: 157.96,118.62 156.49,120.09 156.49,126.8 155.65,127.64 153.36,127.64 148.18,132.82 148.18,149.71 144.7,153.19 144.7,163.55 145.36,164.21 153.18,164.21 157.65,159.74 157.65,152 157.63,151.97 157.63,148.8 156.21,147.37 156.21,140.44 159.38,137.27 159.38,134.04 159.37,134.03 159.79,133.61 159.79,122.81 161.11,121.49 163.52,121.49 163.98,121.03 163.98,118.95 163.65,118.62
P1V2 on BOTTOM (solid shape): 81.96,72.65 81.96,70.31 81.66,70.01 77.97,70.01 77.85,69.88 77.85,69.27 77.75,69.17 76.3,69.17 76.12,69.35 76.12,71.96 76.55,72.39 76.68,72.39 76.91,72.62 76.91,72.8 77.2,72.8 77.2,72.83 81.78,72.83
P1V2 on TOP: 80.01,61.29 77.19,64.11 77.19,73.54 79.34,75.69 83.78,75.69 84.55,76.46 84.55,80.9 86.23,82.58 86.23,123.77 88.48,123.77 88.98,124.28 88.98,125.4 88.99,125.4 91.82,125.4 91.82,122.39 92.44,122.39 92.44,121.72 93.39,121.72 93.39,121.71 95.85,121.71 96.27,121.71 96.27,121.76 96.66,121.76 98.31,123.41 98.31,123.48 98.36,123.48 98.36,125.4 107.34,125.4 107.34,124.37 109.06,124.37 109.06,125.4 113.32,125.4 113.4,125.33 113.4,125.18 114.6,125.18 114.6,121.71 117.34,121.71 117.34,121.7 119.98,121.7 119.98,125.18 123.01,125.18 123.01,124.69 122.84,124.69 122.5,124.35 122.5,121.93 123,121.44 122.94,103.3 122.94,98.73 140.21,81.45 140.21,73.5 142.03,71.68 147.65,71.68 147.67,71.71 147.67,73 147.88,73.21 152.6,73.21 153.08,72.72 153.08,70.51 151.51,68.94 145.97,68.94 145.53,68.5 145.53,66.41 145.54,62.42 145.18,62.07 131.59,62.07 131.49,62.17 131.49,63.3 131.14,63.66 128.09,63.66 127.96,63.53 127.96,62.49 123.36,62.49 123.26,62.39 123.26,61.42 123.14,61.29 ; 6 cut-outs
P1V2 on BOTTOM: 120.37,124.79 121.18,124.79 121.66,124.31 121.92,124.31 122.09,124.49 122.09,124.9 121.82,125.17 120.37,125.17 120.32,125.12 120.32,124.84
P1V2 on BOTTOM: 120.65,84.36 122.12,84.36 122.2,84.43 123.54,84.43 123.54,85.5 123.44,85.6 122.35,85.6 122.22,85.73 122.22,86.13 122.09,86.26 120.65,86.26 120.57,86.19 120.57,84.43
P1V2 on BOTTOM: 120.21,121.29 120.21,120.83 120.65,120.4 121.36,120.4 121.38,120.42 121.46,120.42 121.69,120.2 122.53,120.2 122.73,120.4 122.73,121.06 122.42,121.36 120.29,121.36
P1V2 on BOTTOM: 119.38,73.46 123.82,73.46 124.08,73.21 124.08,72.19 124.33,71.94 125.09,71.94 125.35,72.19 125.35,73.08 125.6,73.33 127.12,73.33 128.01,72.44 128.01,71.3 127.89,71.17 120.52,71.17 120.39,71.3 120.39,72.32 120.01,72.7 119.63,72.7 119.25,73.08 119.25,73.33
P1V2 on BOTTOM: 115.62,120.37 115.97,120.37 116.1,120.5 117.42,120.5 117.52,120.6 117.52,121.26 117.42,121.36 116.07,121.36 115.47,120.76 115.47,120.53
P1V2 on BOTTOM: 151.74,71.76 151.74,73.43 151.81,73.51 154.35,73.51 154.43,73.43 154.43,71.76
P1V2 on BOTTOM: 108.2,73.46 115.69,73.46 116.07,73.08 116.07,72.19 115.06,71.17 108.45,71.17 107.95,71.68 107.95,73.21
P1V2 on L6: 86.61,125.28 86.61,110.16 123.06,110.16 123.06,125.28
P1V05A on BOTTOM (solid shape): 230.75,51.94 230.95,51.94 230.95,51.45 231.46,51.45 231.46,51.94 231.86,51.94 231.87,51.92 232.66,51.92 232.91,51.67 232.91,49.41 232.51,49 229.41,49 229.31,49.1 229.31,52.38 229.38,52.45 229.38,52.48 229.45,52.55 230.39,52.55
P1V05A on L5 (solid shape): outline of 139 points within 227,47.68 233.19,51.57
P1V05A on TOP: 236.04,66.65 238.99,66.65 239.29,66.35 239.29,64.7 236.45,64.7 235.73,65.41 235.73,66.35
P1V05A on TOP: 230.58,48.75 229.26,50.07 229.26,52.25 229.79,52.78 231.33,52.78 232.66,54.11 243.47,54.11 243.9,54.54 243.9,55.97 245.08,57.15 248.84,57.15 249.55,56.44 249.55,54.69 250.34,53.9 250.34,50.24 249.93,49.84 248.84,49.84 248.82,49.86 248.15,49.86 247.42,49.13 241.65,49.13 241.27,48.75
P1V05A on TOP: 228.47,52.66 228.47,49.43 225.52,49.43 225.22,49.74 225.22,52.51 225.37,52.66
P1V05A on BOTTOM: 245.57,56.47 248.29,56.47 249.33,55.43 249.33,54.46 250.14,53.65 250.14,50.32 249.73,49.91 248.67,49.91 247.96,50.62 247.96,53.19 247.7,53.44 246.74,53.44 246.46,53.72 246.46,55.25 245.57,56.14
P1V05A on BOTTOM: 233.09,35.89 233.22,35.77 235.3,35.77 235.43,35.89 235.43,36.94 235.3,37.06 234.44,37.06 234.06,37.44 233.22,37.44 233.09,37.32
P1V05A on BOTTOM: 245.67,53.34 245.85,53.34 246.25,52.94 246.25,50.75 247.14,49.86 247.14,49.63 246.99,49.48 246.05,49.48 245.01,50.52 245.01,52.68
P1V05A on BOTTOM: 237.89,64.32 237.82,64.39 237.82,64.77 237.64,64.95 236.09,64.95 235.96,65.08 235.96,67.52 236.04,67.59 238.6,67.59 239.54,66.65 239.54,64.98 238.89,64.32
P1V05A on L6: 229.1,35.11 229.1,74.09 252.35,74.09 252.35,48.95 242.82,48.95 242.82,35.11
P1V8_MAIN on TOP: 196.26,168.76 196.26,166.14 196.06,165.94 194.43,165.94 194.43,167.14 193.98,167.59 193.98,168.61 194.13,168.76
P1V8A on TOP (solid shape): 219.58,28.53 219.58,27.92 220.11,27.38 220.11,26.8 219.96,26.65 217.8,26.65 217.62,26.83 217.62,28.53 217.75,28.65 219.45,28.65
P1V8A on BOTTOM: 279.85,63.91 279.85,63.1 281.5,63.1 281.5,64.9 281.3,65.1 280.08,65.1 279.98,65 279.98,64.04
P1V8A on L5: 217.83,27.49 219.38,27.49 219.68,27.79 219.68,28.45 217.88,28.45 217.7,28.27 217.7,27.61
P1V8S on BOTTOM (solid shape): 281.56,61.62 281.56,60.43 281.38,60.25 280.21,60.25 279.78,60.68 279.78,60.99 279.78,61.15 279.79,61.2 279.79,61.24 279.79,61.65 279.78,61.73 279.85,61.8 281.38,61.8
P1V8S_AON1 on TOP: 207.77,174.48 207.77,172.9 207.82,172.85 210.36,172.85 210.51,173 210.51,175.64 207.44,175.64 207.26,175.47 207.26,174.48
P1V8S_AON1 on TOP: 197.58,168.76 197.58,166.37 197.66,166.3 199.11,166.3 199.36,166.55 199.36,168.66 199.26,168.76
P1V8S_AON1 on L5: 193.75,160.51 182.33,160.51 182.08,160.25 158.11,160.25 157.93,160.43 157.93,174.98 158.37,175.42 182.53,175.42 182.53,175.39 216.48,175.39 219.66,172.22 219.66,103.05 222.83,99.88 222.83,94.62 223.29,94.16 237.03,94.16 246.22,84.97 235.51,84.97 235.51,86.72 229.08,93.15 219.76,93.15 219.45,92.84 206.42,92.84 199.56,99.7 199.56,154.69 ; 3 cut-outs
P1V8S_AON1 on L8: 214.68,106.63 213.76,106.63 213.41,106.28 213.41,103.18 213.61,102.98 214.8,102.98 215.72,103.89 215.72,105.59
P1V8S_AON1 on L10: 171.58,83.75 170.31,85.02 170.31,86.29 170.69,86.67 179.81,86.67 180,86.48 181.99,86.48 182,86.46 182,86.4 182.18,86.22 184.21,86.22 184.78,86.8 186.43,86.8 187.58,87.94 187.58,95.94 188.82,97.18 188.82,100.28 189.53,100.99 192.91,100.99 198.73,95.18 211.2,95.18 214.63,98.61 214.63,102.16 213.86,102.92 213.23,102.92 212.85,103.31 212.85,106.45 213.61,107.22 218.21,107.22 219.83,105.59 219.83,101.3 221.23,99.9 221.23,96.98 218.27,94.02 213.98,94.02 203.7,83.75
P1V8S_AON2 on TOP: 159.15,117.29 159.15,117.54 158.23,118.46 158.23,118.58 158.22,118.59 158.22,122.48 158.34,122.6 159.25,122.6 159.4,122.45 159.4,121.17 159.56,121.01 159.56,121.01 159.56,120.86 159.58,120.83 160.52,120.83 160.58,120.88 160.94,120.88 160.94,120.48 160.69,120.22 159.62,120.22 159.52,120.12 159.52,119.61 159.87,119.26 159.87,118.04 159.96,117.94 159.96,117.29
P1V8S_AON2 on BOTTOM: 158.44,118.82 158.07,119.19 158.07,121.35 157.65,121.77 157.65,121.99 157.69,122.03 157.69,122.22 157.86,122.39 159.18,122.39 159.47,122.11 159.47,121.03 159.77,120.72 159.77,119.36 159.6,119.18 159.6,119.18 159.24,118.82
P1V8S_MAIN1 on TOP (solid shape): 193.65,168.53 193.65,166.98 194.03,166.98 194.26,166.75 194.26,165.84 193.77,165.36 191,165.36 190.73,165.64 190.73,168.46 190.9,168.63 193.54,168.63
P1V8S_MAIN1 on TOP: 158.19,129.6 158.24,129.55 159.38,129.55 159.38,130.34 159.36,130.36 159.35,130.36 159.35,132.4 159.31,132.44 158.96,132.44 158.92,132.47 158.92,133.9 158.75,134.07 158.53,134.07 158.52,134.08 158.18,134.08 158.18,133.83 158.05,133.71 157.66,133.71 157.25,133.3 157.25,132.24 156.89,131.88 156.89,130.73 157.04,130.58 158.05,130.58 158.19,130.45
P1V8S_MAIN1 on TOP: 190.45,158.68 190.45,156.8 190.52,156.72 191.77,156.72 192.07,157.03 192.07,158.68 192,158.75 190.52,158.75
P1V8S_MAIN1 on BOTTOM: 137.74,139.14 137.59,139.3 137.59,140.29 137.61,140.31 137.61,141.51 138.71,142.6 141.78,142.6 142.08,142.29 145.46,142.29 145.46,140.57 144.04,139.14
P1V8S_MAIN1 on BOTTOM: 159.04,134.3 159,134.34 159,134.55 158.92,134.63 157.75,134.63 157.65,134.53 157.65,134.42 157.98,134.09 158.08,133.99 158.08,133.64 157.93,133.48 157.46,133.48 157.25,133.27 157.08,133.27 156.94,133.13 156.94,132.85 157.12,132.67 157.22,132.67 158.04,131.85 158.04,131.52 157.92,131.4 157.24,131.4 156.93,131.1 156.93,130.87 158.28,129.52 158.87,129.52 159.04,129.7
P1V8S_MAIN1 on L3: 158.79,129.65 158.62,129.82 146.96,129.82 140.81,135.97 140.81,141.71 140.97,141.86 154.6,141.86 158.7,137.76 158.7,133.09 159.52,132.28 159.52,129.99 159.18,129.65
P1V8S_MAIN1 on L5: 139.06,153.27 143.43,153.27 145.06,154.89 145.06,160.99 146.22,162.16 155.34,162.16 157.4,160.1 179.98,160.1 188.91,169.03 188.92,169.03 188.98,169.09 194.26,169.09 194.48,168.86 194.48,165.84 191.21,162.56 188.44,162.56 181.4,155.53 153.54,155.53 146.71,148.7 146.71,143.41 146.69,143.4 146.69,141.95 145.18,140.44 137.79,140.44 137.03,141.2 137.03,151.24 ; 2 cut-outs
P1V8S_MAIN1 on L8: 193.95,162.21 192.88,161.14 192.88,158.47 192.07,157.66 190.75,157.66 190.24,158.17 190.24,168.61 190.4,168.76 193.77,168.76 193.95,168.58
P1V35S_FBVDDQ on TOP: outline of 179 points within 154.66,83.39 229.66,178.35 ; 27 cut-outs
P1V35S_FBVDDQ on BOTTOM: outline of 265 points within 154.96,79.4 233.5,178.16
P1V35S_FBVDDQ on BOTTOM: outline of 161 points within 162.5,118.5 181.3,142.4
P1V35S_FBVDDQ on L3: outline of 107 points within 154.66,83.58 228.16,177.88 ; 13 cut-outs
P1V35S_FBVDDQ on L6: 178.84,140.34 178.84,118.87 195.22,102.49 195.22,90.71 200.66,85.27 208.66,85.27 208.66,80.95 227.3,80.95 227.3,87.05 220.09,87.05 220.09,110.8 219.71,111.18 219.71,180.32 155.95,180.32 155.95,150.93 156.21,150.68 156.21,148.39 164.08,140.52 178.66,140.52
P1V35S_FBVDDQ on L8: 181.99,120.03 181.99,121.51 181.61,121.89 181.61,127.94 181.8,128.13 181.8,141.17 181.62,141.36 179.91,143.06 173.86,143.06 173.62,142.83 172.64,142.83 172.11,142.3 162.84,142.3 162.76,142.22 162.76,141.19 163.73,140.22 177.92,140.22 178.83,139.31 178.83,122.29 178.41,121.88 177.86,121.33 177.83,121.33 177.63,121.12 167.5,121.12 167.08,120.7 167.08,119.3 167.18,119.21 167.59,119.21 167.8,119.42 171.18,119.42 171.39,119.2 172.35,119.2 172.75,118.8 180.75,118.8
P1V35S_FBVDDQ on L8: outline of 174 points within 155.24,83.7 230.02,179.66 ; 31 cut-outs
P1V35S_FBVDDQ on L10: 168.94,161.26 169.72,162.04 169.72,166.22 168.77,167.16 168.33,167.16 168.2,167.03 168.2,165.6 166.43,165.6 165.35,164.52 165.35,162.07 165.51,161.91 166.25,161.91 166.89,162.54 168.22,162.54 168.49,162.27 168.49,161.36 168.58,161.26
P1V35S_FBVDDQ on L10: outline of 142 points within 155.95,106.71 218.69,180.98 ; 11 cut-outs
P2V5 on BOTTOM (solid shape): 83.21,65.87 83.21,63.35 83.82,62.74 83.82,60.58 83.69,60.46 81.35,60.46 80.92,60.89 80.92,64.95 81.02,65.05 81.02,65.18 81.15,65.18 81.43,65.46 81.43,65.92 81.48,65.97 83.11,65.97
P2V5 on BOTTOM: 151.74,68.58 151.48,68.84 151.48,71.07 151.46,71.1 151.18,71.1 150.57,71.71 149.2,71.71 148.89,72.01 148.89,76.53 149.35,76.99 149.35,79.18 148.56,79.96 147.6,79.96 146.48,81.08 146.48,85.22 145.51,86.19 141.35,86.19 141.17,86.36 141.17,87.79 141.41,88.03 143.49,88.03 143.68,87.84 148.56,87.84 149.06,87.34 149.06,84.19 154.71,78.54 154.71,77.83 156.33,76.2 156.33,72.72 156.28,72.67 156.28,71.48 156.82,70.95 156.82,68.86 156.54,68.58 ; 1 cut-out
P2V5 on L3: 147.52,81.18 147.52,80.29 151,76.81 151,74.35 150.62,73.97 150.62,71.23 153.13,68.71 154.12,68.71 154.33,68.91 154.33,69.42 151.81,71.94 151.81,73.13 152.37,73.69 152.37,78.11 150.52,79.96 150.52,80.37 149.37,81.51 148.13,81.51 147.93,81.31 147.65,81.31
P3V3A on TOP (solid shape): 264.74,25.18 264.74,23.93 265.05,23.62 265.05,22.38 264.97,22.3 262.86,22.3 262.79,22.38 262.79,25.28 262.94,25.43 264.49,25.43
P3V3A on BOTTOM (solid shape): 134.26,36.68 134.26,35.77 133.19,35.77 132.85,36.11 132.83,36.14 132.24,36.14 132.2,36.17 132.2,36.83 132.23,36.86 134.08,36.86
P3V3A on BOTTOM (solid shape): 235.35,35.26 235.35,34.12 235.15,33.91 235.15,31.17 234.92,30.94 232.91,30.94 232.85,31 232.86,31.01 232.86,32.29 232.84,32.32 232.84,32.57 232.66,32.75 232.66,33.63 232.66,33.63 232.66,33.66 232.86,33.66 233.19,33.99 233.19,35.36 233.3,35.46 235.15,35.46
P3V3A on L10 (solid shape): 264.26,25.33 264.26,23.32 263.57,23.32 263.47,23.42 263.47,25.3 263.55,25.38 264.21,25.38
P3V3A on TOP: 247.62,48.72 249.73,48.72 249.96,48.49 249.96,47.32 249.86,47.22 247.67,47.22 247.47,47.43 247.47,48.57
P3V3A on TOP: 253.23,52.4 253.23,52.99 252.04,52.99 252.04,53.98 252.68,54.61 254.3,54.61 254.58,54.33 254.58,52.71 254.28,52.4
P3V3A on BOTTOM: 252.98,52.38 252.78,52.59 252.78,55.15 253.04,55.41 253.33,55.41 253.9,54.84 253.9,53.65 254.23,53.32 254.23,52.64 253.97,52.38
P3V3A on BOTTOM: 247.83,47.17 249.81,47.17 250.04,47.4 250.04,48.06 249.43,48.68 247.96,48.68 247.7,48.42 247.7,47.3
P3V3A on BOTTOM: 256.46,60.77 257.78,60.77 258.04,61.02 258.04,61.76 257.78,62.01 256.67,62.01 256.24,61.58 256.24,60.99
P3V3A on L6: 231.39,32.57 231.39,34.85 242.87,34.85 242.87,48.7 252.6,48.7 252.6,65.46 260.47,65.46 260.47,48.7 260.6,48.7 260.6,32.57
P3V3A on L8: 263.52,23.35 262.4,24.46 257.48,24.46 255.06,26.88 249.42,26.88 247.09,29.21 247.09,30.94 246.66,31.37 244.29,31.37 243.55,32.11 241.94,32.12 241.09,31.27 241.09,30.46 240.51,29.87 236.09,29.87 235.45,30.51 233.52,30.51 233.32,30.71 233.32,34.45 233.35,34.47 235.12,34.47 236.95,32.64 237.49,32.64 237.99,33.15 237.99,34.37 238.66,35.03 240.56,35.03 241.32,35.79 245.21,35.79 246.05,34.95 248.71,34.95 249.27,34.4 249.27,30.53 250.9,28.91 260.02,28.91 261.24,27.69 265.58,27.69 266.09,27.18 266.09,23.78 265.66,23.35
P3V3A_LAN on TOP: 276.42,90.28 276.35,90.35 276.35,91.7 278.66,91.7 278.75,91.79 278.75,92.5 279.14,92.89 279.16,92.89 279.16,92.91 280.01,93.75 280.01,95.53 280.36,95.89 280.62,95.89 280.87,96.14 280.87,97.48 281.59,98.2 281.72,98.2 281.88,98.36 282.07,98.36 282.2,98.22 282.2,97.54 282.2,97.53 282.2,96.84 282.11,96.65 282.05,96.35 282.2,96.08 282.2,95.93 282.17,95.86 282.16,95.78 281.88,95.51 281.82,95.52 281.79,95.53 281.52,95.53 281.38,95.46 281.31,95.32 281.31,94.93 281.35,94.83 281.43,94.75 281.43,94.61 281.35,94.53 281.31,94.43 281.31,94.04 281.35,93.94 281.43,93.86 281.43,93.72 281.35,93.64 281.31,93.54 281.31,93.15 281.35,93.05 281.43,92.97 281.43,92.83 281.35,92.75 281.31,92.65 281.31,92.26 281.32,92.22 281.3,92.18 281.25,92.17 280.85,91.6 281.42,92 281.43,92.05 281.47,92.07 281.51,92.06 281.81,92.06 281.89,92.08 282.22,91.75 283.16,91.75 283.41,91.49 283.41,90.1 283.36,90.05 281.15,90.05 280.92,90.28 277.57,90.28 277.19,90.48 276.81,90.28
P3V3A_LAN on L6: outline of 95 points within 274.32,85.79 288.92,111.43
P3V3A_PB on L6: outline of 209 points within 271.23,88.79 293.11,133.15
P3V3A_WLAN on BOTTOM (solid shape): 272.87,26.67 272.67,26.47 270.15,26.47 269.87,26.75 269.87,28.23 270.09,28.45 272.87,28.45
P3V3A_WLAN on TOP: 272.72,28.98 272.72,26.7 272.54,26.52 269.44,26.52 268.65,25.73 268.65,23.96 268.17,23.47 268.17,22.66 267.81,22.3 266.42,22.3 266.32,22.41 266.32,22.97 265.99,23.3 265.73,23.3 264.99,24.03 264.99,27.33 266.8,29.14 272.56,29.14
P3V3A_WLAN on TOP: 292.73,29.24 292.86,29.11 292.86,28.25 292.07,27.46 292.07,26.44 291.41,25.78 289.23,25.78 289.05,25.96 289.05,28.55 289.73,29.24
P3V3A_WLAN on BOTTOM: 291.79,28.43 291.97,28.25 291.97,26.11 291.54,25.68 289.71,25.68 289.51,25.89 289.51,28.43
P3V3A_WLAN on L5: 270.25,27.99 270.25,22.99 270.84,22.41 292.73,22.41 293.62,23.3 293.62,26.85 292.48,27.99 288.92,27.99 288.16,27.23 288.16,26.22 287.52,25.58 282.55,25.58 282.14,25.99 278.36,25.99 276.25,28.1 270.35,28.1
P3V3DS on BOTTOM (solid shape): 34.03,61.27 34.03,59.74 30.86,59.74 30.65,59.95 30.65,61.32 30.73,61.4 33.91,61.4
P3V3DS on BOTTOM (solid shape): 231.29,31.09 231.29,29.98 231.14,29.82 230.13,29.82 230.06,29.87 229.99,29.89 229.6,29.89 229.53,29.87 229.47,29.83 229.36,29.95 229.36,31.58 229.37,31.63 229.37,31.67 229.37,32.09 229.37,32.13 230.24,32.13
P3V3DS on TOP: 207.08,29.34 214.17,29.34 214.91,28.6 214.91,26.93 214.83,26.85 214.12,26.85 213.56,26.29 209.17,26.29 209.17,25.81 208.96,25.81 208.4,25.25 207.49,25.25 207.08,25.66
P3V3DS on BOTTOM: 228.01,32.16 228.01,31.07 227.15,30.2 225.65,30.2 225.52,30.33 225.52,31.93 225.8,32.21 227.07,32.21 227.12,32.16
P3V3DS on L6: 206.88,27.11 231.14,27.11 231.14,34.9 208.86,34.9 206.55,37.22 179.5,37.22 175,41.71 92.07,41.71 92.07,62.79 30.35,62.79 30.35,60 88.26,60 88.26,37.77 138.68,37.77 141.35,35.11 203.63,35.11 206.88,31.86
P3V3DS_PB on TOP: 284.07,87.48 282.39,87.48 282.24,87.63 282.24,89.41 282.37,89.54 284.07,89.54 284.2,89.41 284.2,87.61
P3V3DS_PB on BOTTOM: 278.48,92.13 275.94,92.13 275.66,92.41 275.66,93.73 275.84,93.91 278.53,93.91 278.58,93.86 278.58,92.23
P3V3DS_PB on L5: 274.63,90.34 274.66,90.41 274.75,90.42 275.21,90.76 274.75,91.1 274.66,91.12 274.63,91.19 274.63,93.34 274.93,93.65 279.09,93.65 279.1,93.61 279.45,93.35 279.79,93.61 279.8,93.65 282.48,93.65 282.65,93.48 282.65,92.21 283.44,91.42 283.44,87.94 283.33,87.84 281.99,87.84 281.9,87.89 281.92,87.99 281.65,88.58 281.38,87.99 281.39,87.89 281.31,87.84 281.28,87.84 281.26,87.86 280.72,88.52 279.9,88.77 274.84,88.77 274.63,88.98 274.63,89.05 274.69,89.05 274.7,89.04 275.23,89.32 274.75,89.68 274.67,89.69 274.63,89.77
P3V3S on BOTTOM (solid shape): 26.67,64.39 26.67,62.13 26.49,61.95 25.24,61.95 25.07,62.13 25.07,64.39 25.27,64.6 26.46,64.6
P3V3S on BOTTOM (solid shape): 237.72,33.53 237.72,31.96 236.93,31.17 236.32,31.17 236.32,31.65 235.56,31.65 235.51,31.7 235.51,33.53 235.63,33.66 237.59,33.66
P3V3S on BOTTOM (solid shape): 295.27,38.26 295.27,37.09 295.7,36.66 295.7,35.92 295.63,35.84 294.46,35.84 294.41,35.89 294.41,38.41 294.48,38.48 295.04,38.48
P3V3S on BOTTOM (solid shape): 186.46,38 186.46,35.92 186.33,35.79 183.51,35.79 183.23,36.07 183.23,36.86 183.51,37.14 183.79,37.14 183.79,37.9 184.17,38.28 186.18,38.28
P3V3S on BOTTOM (solid shape): 64.51,55.43 64.51,52.63 64,52.12 64,52.11 64,51.74 63.8,51.54 61.87,51.54 61.59,51.82 61.59,55.32 61.82,55.55 64.39,55.55
P3V3S on BOTTOM (solid shape): 227.66,38.36 227.66,35.74 227.48,35.56 226.41,35.56 225.83,36.15 225.48,36.15 224.41,36.15 224.3,36.25 224.3,38.31 224.53,38.54 227.48,38.54
P3V3S on BOTTOM: 20.42,81.79 20.42,80.57 20.14,80.29 18.67,80.29 18.51,80.45 18.51,81.79 18.67,81.94 20.27,81.94
P3V3S on BOTTOM: 150.87,44.4 152.57,44.4 152.63,44.45 152.63,45.32 152.52,45.42 150.82,45.42 150.77,45.37 150.77,44.5
P3V3S on L6: 260.85,32.57 260.85,65.71 252.6,65.71 252.6,74.35 228.85,74.35 228.72,74.22 228.72,35.11 90.67,35.11 90.67,60 64.64,60 64.64,51.24 23.8,51.24 23.8,49.36 20.65,49.36 20.65,54.13 -2.01,54.13 -2.67,54.79 -2.67,86.16 47.11,86.16 47.11,78.92 59.31,78.92 59.31,72.95 80.64,72.95 80.64,98.1 137.28,98.1 137.28,109.53 140.84,113.08 140.84,125.15 145.79,125.15 145.79,68.76 153.16,68.76 156.59,65.33 208.66,65.33 208.66,85.02 220.09,85.02 220.09,87.56 234.18,87.56 238.63,83.11 296.29,83.11 297.18,84 321.31,84 323.47,81.84 323.47,25.71 322.83,25.07 296.16,25.07 291.84,29.39 291.84,34.73 273.94,34.73 273.94,32.57 ; 2 cut-outs
P3V3S_DPP on BOTTOM: 301.32,38.26 301.32,35.28 301.72,34.88 302.74,34.88 303.17,35.31 303.17,36.99 303.48,37.29 304.47,37.29 308.33,41.15 308.33,49.56 306.57,49.56 306.24,49.23 306.24,45.49 304.42,43.67 304.42,41.35
P3V3S_DPP on L5: 302.59,37.06 305.18,37.06 306.19,38.08 306.19,40.9 308.17,42.88 308.17,48.64 307.82,49 303.86,49 303.6,48.75 303.6,43.01 302.08,41.48 302.08,37.57
P3V3S_HDMI on TOP (solid shape): 296.57,80.17 296.57,78.79 296.52,78.74 295.73,78.74 295.7,78.77 295.7,80.14 295.86,80.29 296.44,80.29
P3V3S_LCDVDD2 on L3 (solid shape): 29.05,70.21 29.05,66.96 28.7,66.6 26.64,66.6 26.31,66.93 26.31,67.75 24.08,69.98 26.44,69.98 26.44,69.92 26.45,69.87 26.47,69.82 26.49,69.77 26.52,69.73 26.56,69.69 26.6,69.66 26.65,69.63 26.69,69.61 26.75,69.6 26.8,69.59 26.85,69.6 26.9,69.61 26.95,69.63 27,69.66 27.04,69.69 27.08,69.73 27.11,69.77 27.13,69.82 27.15,69.87 27.16,69.92 27.16,69.98 27.15,70.03 27.13,70.08 27.11,70.13 27.08,70.17 27.04,70.21 27,70.25 26.95,70.27 26.9,70.29 26.85,70.3 26.8,70.31 26.75,70.3 26.69,70.29 26.65,70.27 26.6,70.25 26.56,70.21 26.52,70.17 26.49,70.13 26.47,70.08 26.45,70.03 26.44,69.98 24.08,69.98 19.86,74.2 19.86,76.94 20.06,77.14 22.12,77.14
P3V3S_LCDVDD2 on BOTTOM: 19.91,75.04 22.42,75.04 22.5,75.11 22.5,77.22 22.32,77.4 20.82,77.4 20.7,77.52 20.7,77.88 20.66,77.92 20.28,77.92 19.91,77.55
P3V3S_LCDVDD2 on BOTTOM: 26.79,65.36 26.79,67.59 26.95,67.75 28.04,67.75 28.14,67.64 28.14,66.93 28.11,66.91 28.11,65.38 28.04,65.31 26.84,65.31
P5V0 on BOTTOM (solid shape): 20.62,74.68 20.62,71.58 20.47,71.43 16.07,71.43 15.87,71.63 15.87,74.76 15.9,74.78 20.52,74.78
P5V0 on BOTTOM (solid shape): 50.62,75.54 50.81,75.54 50.81,75.18 51.32,75.18 51.32,75.54 51.71,75.54 51.84,75.42 51.84,72.88 51.71,72.75 49.15,72.75 49.02,72.88 49.02,76.1 49.17,76.25 49.91,76.25
P5V0 on L8 (solid shape): 50.44,75.06 50.44,71.48 50.21,71.25 18.69,71.25 18.56,71.38 18.56,74.88 18.87,75.19 50.31,75.19
P5V0A_PB on BOTTOM: 285.52,92.66 285.5,92.63 285.47,92.61 285.11,92.26 285.47,91.9 285.5,91.89 285.52,91.86 285.52,90.38 284.98,89.84 282.32,89.84 281.99,90.17 281.99,94.49 281.77,94.71 281.77,94.74 281.74,94.74 281.5,94.97 281.5,98.25 281.71,98.45 284.76,98.45 284.88,98.33 284.88,96.75 284.92,96.72 284.92,96.68 284.95,96.68 285.52,96.12
P5V0A_PB on BOTTOM: 293.67,119.28 294.94,119.28 294.94,117.58 294.81,117.45 290.93,117.45 289.71,118.67 289.71,120.07 289.91,120.27 291.92,120.27 292.02,120.17 292.02,119.84 292.12,119.74 292.71,119.74 292.81,119.64 292.81,119.43 293.14,119.1 293.49,119.1
P5V0A_PB on L6: outline of 83 points within 281.68,85.79 315.24,120.58
P5V0A_USB1 on BOTTOM: 297.74,116.82 297.74,118.32 297.51,118.55 296.16,118.55 296.06,118.65 296.06,119.51 296.14,119.59 297.18,119.59 297.56,119.97 298.85,119.97 300.1,121.21 300.1,121.92 300.3,122.13 300.3,123.57 300.71,123.98 302.24,123.98 302.61,123.61 302.61,118.24 301.2,116.83 301.2,116.2 300.89,115.88 299.56,115.88 299.26,115.57 299.26,113.64 299.06,113.44 297.41,113.44 297.18,113.67 297.18,116.26
P5V0A_USB1 on BOTTOM: 300.75,139.76 300.89,139.82 300.95,139.96 300.95,140.35 300.88,140.49 300.74,140.56 300.47,140.56 300.39,140.55 300.33,140.5 300.29,140.47 299.92,140.85 299.92,142.17 299.69,142.4 298.22,142.4 297.94,142.68 297.94,144.17 298.04,144.28 301.09,144.28 302.64,142.73 302.64,140.31 301.85,139.53 300.61,139.53 300.53,139.6 300.51,139.7 300.59,139.76
P5V0A_USB1 on L6: outline of 221 points within 293.37,114.43 315.24,154.44
P5V0DS on TOP (solid shape): 279.96,65.31 279.96,63.94 279.7,63.68 277.54,63.68 276.5,64.72 276.5,65.59 276.65,65.74 279.52,65.74
P5V0DS on TOP (solid shape): 262.51,24.87 262.51,20.35 262.25,20.09 261.16,20.09 261.11,20.15 261.11,21.26 261.06,21.31 260.65,21.31 260.58,21.38 260.58,21.5 260.58,21.5 260.58,21.67 260.12,22.13 260.12,22.89 260.58,23.35 260.58,24.9 260.85,25.17 262.2,25.17
P5V0DS on BOTTOM (solid shape): 80.24,56.06 80.28,56.06 80.29,56.06 80.86,56.06 80.86,56.06 81.99,56.06 82.14,55.91 82.14,53.72 82.06,53.65 79.4,53.65 79.27,53.78 79.27,56.21 79.4,56.34 79.96,56.34
P5V0DS on L3 (solid shape): outline of 389 points within 58.04,53.09 80.74,75.04
P5V0DS on TOP: 281,33.35 281,32.36 281.1,32.26 283.94,32.26 284.07,32.39 284.07,33.3 283.87,33.51 281.15,33.51
P5V0DS on TOP: 303.43,10.24 303.43,8.61 303.68,8.36 304.8,8.36 304.95,8.51 304.95,9.12 305.13,9.3 305.99,9.3 306.12,9.43 306.12,10.29 305.94,10.47 303.65,10.47
P5V0DS on BOTTOM: 154.99,164.06 154.84,163.91 152.8,163.91 152.68,164.04 152.68,165.84 153.03,166.2 153.74,166.2 153.84,166.09 153.84,165.81 154,165.66 154.84,165.66 154.99,165.51
P5V0DS on BOTTOM: 278.46,64.95 278.46,63.02 276.4,63.02 276.32,63.1 276.32,65.18 276.42,65.28 278.13,65.28
P5V0DS on L6: 298.32,-2.36 296.67,-0.71 296.67,17.58 295.4,18.85 260.85,18.85 260.85,18.22 259.71,18.22 259.71,19.41 245.56,19.41 245.56,18.22 206.32,18.22 206.32,19.51 193.82,19.51 193.82,18.22 191.89,18.22 191.89,14.15 85.59,14.15 85.59,24.69 83.69,24.69 83.69,21.01 68.83,21.01 68.83,55.81 80.77,55.81 80.77,31.3 129.41,31.3 133.85,26.85 177.03,26.85 178.81,25.07 196.97,25.07 199.77,22.28 237.36,22.28 237.36,24.57 276.73,24.57 276.73,36.63 273.68,39.68 273.68,65.71 282.7,65.71 284.98,63.43 284.98,46.03 292.67,38.34 292.67,30.47 297.05,26.09 320.04,26.09 322.96,23.17 322.96,-2.36 ; 1 cut-out
P5V0DS on L6: 59.56,73.21 59.56,78.92 75.43,78.92 75.43,102.8 132.71,102.8 132.71,136.96 137.28,136.96 137.28,139.75 142.62,145.09 142.62,170.49 155.7,170.49 155.7,152.07 150.87,152.07 150.87,142.29 145.79,137.21 145.79,125.4 140.59,125.4 140.59,113.21 137.03,109.66 137.03,98.48 83.44,98.48 83.44,73.21
P5V0DS on L10: 188.46,16.31 188.39,16.39 160.93,16.39 155.88,21.44 120.39,21.44 115.97,25.86 68.96,25.86 68.83,25.99 68.83,32.44 68.96,32.57 133.17,32.57 137.18,28.55 171.24,28.55 174.11,25.68 186.2,25.68 186.89,26.37 195.5,26.37 196.19,25.68 200.91,25.68 201.27,25.33 209.62,25.33 210.89,24.06 224.02,24.06 224.91,23.17 233.17,23.17 235.33,25.33 262.76,25.33 263.01,25.07 263.01,17.71 261.62,16.31 257.86,16.31 257.86,19.36 245.87,19.36 245.87,16.31 205.48,16.31 205.48,19.46 193.65,19.46 193.65,16.31 ; 1 cut-out
P5V0S on BOTTOM (solid shape): 157.38,34.55 157.38,33.02 157.3,32.95 155.58,32.95 155.42,33.1 155.42,34.55 155.57,34.7 157.22,34.7
P5V0S on BOTTOM (solid shape): 66.08,58.36 66.09,58.34 66.11,58.32 66.52,58.32 66.52,56.98 66.34,56.8 65.27,56.8 65.1,56.98 65.1,58.83 65.12,58.85 65.58,58.85
P5V0S on TOP: 31.24,55.05 31.37,54.92 31.37,52.63 31.14,52.4 31.14,50.75 31.54,50.35 31.54,49 31.52,48.97 28.9,48.97 28.77,49.1 28.77,53.32 28.57,53.52 26.54,53.52 26.44,53.62 26.44,54.28 27.43,54.28 27.53,54.38 27.53,54.79 27.78,55.05
P5V0S on BOTTOM: 267.89,31.27 267.89,31.6 267.43,31.6 267.23,31.8 267.23,33.35 267.31,33.43 269.54,33.43 271.24,35.13 271.24,50.5 273.2,52.45 273.2,58.47 273.83,59.11 278.15,59.11 278.48,58.78 278.48,56.39 277.39,55.3 277.39,51.87 279.47,49.79 282.88,49.79 284.98,51.9 284.98,55.93 285.87,56.82 285.87,63.78 283.16,66.5 281.28,66.5 281.12,66.65 281.12,68.23 281.23,68.33 281.38,68.33 281.66,68.61 281.66,69.17 281.81,69.32 288.46,69.32 289.1,68.69 297.15,68.69 299.13,66.7 299.13,65.43 299.28,65.28 301.6,65.28 302.18,64.7 302.18,62.67 301.93,62.41 293.37,62.41 289.23,58.27 289.23,48.62 285.21,44.61 276.63,44.61 275.89,43.87 275.89,35.49 271.68,31.27
P5V0S on L3: 84.91,57.84 85.67,58.6 85.67,61.01 79.73,66.96 74.34,66.96 70.28,71.02 70.28,80.06 67.36,82.99 44.78,82.99 44.55,82.76 44.55,78.41 44.83,78.13 62.91,78.13 64.33,76.71 64.33,64.37 67.99,60.71 76.58,60.71 79.45,57.84
P5V0S on L6: 199.77,22.66 197.1,25.33 179.07,25.33 177.16,27.23 133.98,27.23 129.66,31.55 81.02,31.55 81.02,56.06 68.58,56.06 68.58,20.76 64.26,20.76 64.26,22.94 63.37,23.83 53.06,23.83 51.56,22.33 51.56,20.76 12.32,20.76 8.76,24.31 8.76,45.77 10.16,47.17 16.13,47.17 20.19,43.11 23.49,43.11 22.98,43.62 22.98,47.55 23.49,48.06 25.14,48.06 25.65,48.57 25.65,53.27 26.16,53.27 26.16,50.98 64.89,50.98 64.89,59.74 88.01,59.74 88.01,37.52 138.55,37.52 141.22,34.85 206.63,34.85 206.63,26.85 231.39,26.85 231.39,32.31 260.85,32.31 260.85,39.55 273.43,39.55 276.48,36.5 276.48,24.82 237.11,24.82 237.11,22.66
P5V0S on L6: 155.7,169.73 155.7,175.95 157.35,177.6 204.09,177.6 204.09,181.03 204.01,180.95 152.96,180.95 152.88,181.03 64.39,181.03 64.39,135.79 62.99,134.39 62.99,107.24 47.37,91.62 47.37,87.94 44.57,85.14 44.57,79.18 75.18,79.18 75.18,122.86 75.82,122.86 75.82,154.87 100.83,154.87 100.83,159.69 142.36,159.69 142.36,169.73
P5V0S_AUDIO_AVDD on TOP: 27.99,53.27 27.99,52.33 27.91,52.25 26.54,52.25 26.39,52.4 26.39,53.19 26.54,53.34 27.91,53.34
P5V0S_FAN1 on BOTTOM: 55.11,57.46 55.24,57.59 55.24,60.25 55.62,60.63 59.18,60.63 60.7,59.11 65.78,59.11 66.29,58.6 66.8,58.6 67.18,58.22 67.18,57.59 67.71,57.05 70,57.05 70.1,57.15 70.1,59.36 67.94,61.52 60.7,61.52 60.07,62.16 54.61,62.16 53.84,61.4 53.84,57.84 54.23,57.46
P5V0S_FAN2 on BOTTOM: 281.4,74.53 281.05,74.88 278.38,74.88 278.15,74.65 278.15,69.8 278.28,69.68 278.28,69.33 278.96,68.67 278.96,68.02 279.14,67.85 280.79,67.85 280.84,67.9 280.84,68.35 281.35,68.86 281.35,69.96 281.28,70.03 280.59,70.03 280.54,70.08 280.54,72.42 281.4,73.28
P5V0S_HDMI on BOTTOM: 304.21,65.79 305.38,65.79 305.76,66.17 306.47,66.17 307.84,67.54 307.84,68.35 307.64,68.56 307.01,68.56 306.32,67.87 302.71,67.87 302.5,67.66 302.5,66.89 302,66.4 302,65.46 302.18,65.28 303.7,65.28
P5V0S_KBLED on BOTTOM: 143.91,30.61 144.12,30.41 144.98,30.41 145.03,30.46 145.03,31.86 145.21,32.03 151.08,32.03 151.25,31.86 151.25,30.03 151.36,29.92 151.91,29.92 152.02,30.03 152.02,31.52 152.12,31.63 153.08,31.63 153.21,31.5 153.21,29.98 153.26,29.92 154.02,29.92 154.1,30 154.1,31.5 154.2,31.6 155.5,31.6 155.62,31.73 155.62,32.54 154.71,33.46 150.8,33.46 150.16,34.09 144.7,34.09 144.6,33.99 144.6,33.71 144.68,33.63 143.91,32.87
P5V0S_PVDD on TOP: 25.24,55.81 25.24,54.89 27.4,54.89 27.4,55.81
PVBAT on TOP (solid shape): 188.67,179.56 188.67,178.39 189.35,177.7 189.35,177.07 189.23,176.94 187.27,176.94 187.09,177.12 187.09,178.15 187.02,178.22 187.02,179.53 187.17,179.68 188.54,179.68
PVBAT on BOTTOM (solid shape): 225.67,44.94 226.62,44.94 227.3,44.94 227.38,44.86 227.38,42.22 227.2,42.04 222.75,42.04 222.22,42.57 222.22,44.68 222.48,44.94 225.67,44.94
PVBAT on BOTTOM (solid shape): 47.29,80.04 47.29,79.86 47.52,79.63 47.69,79.63 47.72,79.61 48.31,79.61 48.41,79.51 48.41,77.4 48.28,77.27 46.5,77.27 46.38,77.4 46.38,80.01 46.5,80.14 47.19,80.14
PVBAT on TOP: outline of 119 points within 44.07,27.08 237.84,179.73 ; 5 cut-outs
PVBAT on TOP: 94.71,176.38 94.48,176.61 94.48,179.45 94.76,179.73 139.04,179.73 139.34,179.43 139.34,177.65 138.22,177.65 137.61,177.04 136.72,177.04 136.06,176.38
PVBAT on BOTTOM: 52.24,34.78 52.6,34.42 53.21,34.42 53.44,34.65 53.44,37.82 52.55,38.71 39.34,38.71 38.91,38.28 38.91,33.84 39.14,33.61 44.4,33.61 44.68,33.89 44.68,34.37 45.08,34.78
PVBAT on BOTTOM: 69.39,154.33 69.39,172.6 70.96,174.17 70.99,174.17 72.03,175.21 72.03,179.43 72.29,179.68 84.45,179.68 84.58,179.56 84.58,174.04 84.45,173.92 79.96,173.92 73.89,167.85 73.89,159.62 75.76,157.74 75.76,152.3 75.49,152.02 71.7,152.02
PVBAT on BOTTOM: 63.04,104.32 63.04,102.26 63.14,102.16 65.45,102.16 65.66,102.37 65.66,103.43 64.89,103.43 64.77,103.56 64.77,103.91 64.36,104.32
PVBAT on BOTTOM: 68.14,88.73 68.53,88.34 68.53,87.91 67.92,87.3 67.92,85.91 67.18,85.17 63.4,85.17 63.04,85.53 63.04,87.94 63.83,88.73
PVBAT on BOTTOM: 94.87,176.58 97.15,176.58 97.41,176.84 97.41,179.12 97.15,179.38 94.74,179.38 94.36,179 94.36,177.09
PVBAT on L3, L5, L8, L10: 82.34,176.79 96.82,176.79 96.95,176.91 96.95,179.71 96.82,179.84 82.34,179.84 82.22,179.71 82.22,176.91
PVBAT_CPU on BOTTOM (solid shape): 115.69,176.84 115.69,171.38 115.44,171.13 109.87,171.13 109.8,171.2 109.8,172.19 109.88,172.27 111.2,172.27 111.33,172.4 111.33,174 111.63,174.3 111.63,176.97 112.01,177.35 115.19,177.35
PVBAT_CPU on BOTTOM (solid shape): 136.34,177.01 136.34,171.4 136.11,171.17 130.66,171.17 130.58,171.25 130.58,172.25 130.65,172.31 131.98,172.31 132.11,172.44 132.11,174.04 132.41,174.34 132.41,177.01 132.74,177.35 135.71,177.35 135.71,177.35 136.01,177.35
PVBAT_CPU on BOTTOM (solid shape): 126.11,176.84 126.11,171.7 126.08,171.57 126.11,171.43 126.11,171.37 125.86,171.12 120.29,171.12 120.22,171.19 120.22,172.2 120.29,172.27 121.62,172.27 121.74,172.39 121.74,173.99 122.05,174.3 122.05,176.96 122.43,177.34 125.6,177.34
PVBAT_CPU on BOTTOM (solid shape): 101.47,178.97 101.47,177.98 102.1,177.35 104.64,177.35 105.15,176.84 105.15,171.25 105.03,171.12 99.51,171.12 99.44,171.2 99.44,172.19 99.51,172.27 100.83,172.27 100.96,172.39 100.96,174.04 101.22,174.3 101.22,176.2 100.96,176.46 98.09,176.46 98.09,178.3 98.15,178.33 98.15,179.28 98.35,179.48 100.96,179.48
PVBAT_CPU on TOP: 101.22,170.11 135.61,170.11 136.6,171.1 136.6,175.29 136.34,175.54 101.37,175.54 100.96,175.14 100.96,170.36
PVBAT_GT on BOTTOM: 78.19,143.27 79.44,144.47 78.48,145.42 77.24,145.42 77.24,147.76 75.41,149.58 75.41,150.85 75.05,151.21 73.81,151.21 73.81,151.29 73.4,151.69 72.01,151.69 71.75,151.44 71.75,147.78 69.36,145.39 69.36,142.5 67.38,140.52 67.38,140.24 69.14,138.48 69.14,137.21 69.75,136.6 69.75,136.4 68.98,135.64 68.98,135.51 69.59,134.9 69.82,134.9
PVBAT_IMON on TOP: 159.71,47.58 159.71,45.95 159.15,45.39 154.35,45.39 154.25,45.49 154.25,45.52 153.91,45.86 153.12,45.86 152.24,46.74 152.24,49.41 152.35,49.51 155.7,49.51 157.63,47.58
PVBAT_SA on TOP (solid shape): 139.57,177.22 139.57,174.63 139.44,174.5 137.41,174.5 137.23,174.68 137.23,176.74 138.05,176.74 138.35,177.04 138.35,177.32 139.47,177.32
PVBAT_SA on BOTTOM (solid shape): 139.95,177.78 139.95,174.86 139.14,174.04 139.14,169.75 139.04,169.65 138.18,169.65 138.18,169.78 138.16,169.96 138.1,170.13 138.1,170.36 137.99,170.46 137.75,170.46 137.52,170.53 137.27,170.52 136.65,171.15 136.65,177.91 136.93,178.18 139.54,178.18
PVBAT_VRAM_DGPU on BOTTOM: 231.11,72.93 231.11,65.38 230.35,64.62 229.28,64.62 229.08,64.82 220.29,64.82 220.09,64.62 218.97,64.62 218.77,64.82 218.41,64.82 218.13,65.1 218.13,72.88 217.78,73.23 215.01,73.23 214.65,72.88 214.65,64.88 217.57,61.95 232.53,61.95 234.01,63.43 234.01,72.14 233.93,72.22 232.43,72.22 232.41,72.24 232.41,72.98 232.33,73.05 231.24,73.05
PVCCGT on TOP (solid shape): 100.43,128.78 100.17,128.53 99.26,128.53 99.13,128.65 99.13,129.77 99.16,129.8 100.43,129.8
PVCCGT on BOTTOM (solid shape): 80.24,129.85 80.24,128.6 79.45,128.6 79.45,129.95 80.13,129.95
PVCCGT on BOTTOM (solid shape): 82.88,141.3 82.88,139.96 83.05,139.78 83.05,139.53 82.11,139.53 82.01,139.63 82.01,141.35 82.06,141.41 82.78,141.41
PVCCGT on TOP: 92.97,125.53 92.71,125.78 92.2,126.29 86.26,126.29 86.18,126.37 86.18,126.55 84.79,127.93 83.75,127.93 83.44,128.25 81.3,128.25 81.25,128.3 81.25,146.46 83.94,149.15 100.45,149.15 101.72,147.88 101.72,140.47 101.93,140.26 101.93,136.78 101.62,136.78 100.5,135.66 100.5,125.98 100.06,125.53 ; 1 cut-out
PVCCGT on BOTTOM: outline of 125 points within 68.22,119.59 101.7,150.04 ; 5 cut-outs
PVCCGT on L3: 100.79,135.15 101.71,136.07 101.71,146.13 98.86,148.97 92.71,148.97 92.33,148.59 92.33,140.65 91.28,139.6 87.63,139.6 86.13,138.1 80.67,138.1 79.04,136.48 79.04,132.49 75.41,128.86 65.96,128.86 65.96,120.4 67.51,118.85 75.59,118.85 82.19,125.45 100.56,125.45 100.79,125.68
PVCCGT on L5: 83.82,125.43 82.04,127.21 82.04,134.93 87.17,140.06 91.36,140.06 91.36,143.36 90.67,144.05 86.74,144.05 86.03,144.76 86.03,148.95 86.23,149.15 100.38,149.15 100.68,148.85 100.68,125.43 ; 1 cut-out
PVCCGT on L6: 101.34,125.53 101.34,147.25 100.83,147.76 100.83,154.61 76.07,154.61 76.07,143.44 72.13,143.44 72.13,120.2 72.64,119.69 86.36,119.69 86.36,125.53
PVCCGT on L8: 101.71,136.45 101.71,146.13 100.48,147.36 100.48,148.75 100.3,148.92 87.17,148.92 86.61,148.36 86.61,143.06 87.5,142.17 88.52,142.17 88.77,141.91 88.77,141.53 88.13,140.9 87.5,140.9 87.12,140.52 87.12,138.36 87.13,138.34 87.13,137.48 88.2,136.41 90.61,136.41 90.7,136.33 90.7,136.1 90.88,135.92 101.18,135.92
PVCCGT on L10: 85.86,127.35 85.87,127.33 89.73,127.33 90.62,128.22 91.72,128.22 92.38,127.56 99.57,127.56 100.79,128.78 100.79,135.15 101.71,136.07 101.71,146.75 100.71,147.76 100.71,148.9 100.45,149.15 79.47,149.15 66.14,135.82 66.14,121.31 66.15,121.3 66.15,119.9 66.67,119.38 76.73,119.38 77.67,120.32 77.67,123.96 81.06,127.35
PVCCIO on BOTTOM (solid shape): 79.8,116.16 79.8,111.41 79.5,111.1 77.54,111.1 76.91,111.74 75.71,111.74 75,112.45 75,116.16 75.16,116.31 79.65,116.31
PVCCIO on TOP: 120.89,127.17 120.6,127.47 120.6,128.22 120.28,128.54 120.28,130.07 120.27,136.09 120.41,136.57 120.45,136.57 120.68,136.62 120.82,136.81 123.16,136.81 123.16,136.81 123.16,127.71 122.7,127.25 122.23,127.25 122.15,127.17
PVCCIO on BOTTOM: 121.03,127.15 122.98,127.15 123.06,127.23 123.06,132.87 123.06,132.87 123.06,136.48 122.35,137.19 121.21,137.19 119.94,135.92 119.94,132.92 119.95,132.91 119.95,132.4 119.63,132.08 119.63,128.55
PVCCIO on L5: 120.65,125.78 120.52,125.91 120.52,134.37 120.75,134.6 125.8,134.6 126.11,134.29 126.11,126.55 125.35,125.78 ; 1 cut-out
PVCCIO on L6: 132.46,136.96 120.52,136.96 120.52,125.53 123.31,125.53 123.31,109.91 86.36,109.91 86.36,119.43 75.43,119.43 75.43,103.05 132.46,103.05
PVCCIO on L8: 75.21,117.94 79.27,122 79.27,124.21 82.34,127.28 82.34,135.92 82.5,136.07 85.72,136.07 86.23,135.56 89.76,135.56 90.32,135 119.22,135 121.03,136.81 123.51,136.81 124,136.33 124,126.65 123.67,126.32 122.3,126.32 121.82,125.84 121.48,126.17 113.15,126.17 111.96,124.97 99.69,124.97 99.08,124.36 99.08,121.8 89.86,112.58 75.59,112.58 75.21,112.96
PVCCIO on L10: 122.12,136.81 120.92,136.81 120.44,136.33 120.44,127.64 120.55,127.54 122.07,127.54 122.2,127.66 122.2,136.74
PVCCSA on TOP: 119.2,138.26 119.2,143.79 119.81,144.41 119.81,144.86 130.63,144.86 130.88,145.11 130.88,155.45 136.24,160.81 142.44,160.81 142.57,160.68 142.57,148.77 138.66,144.86 134.54,144.86 133.32,143.64 133.32,139.09 133.22,138.99 132.43,138.99 132.36,139.07 132.36,139.25 132.1,139.5 131.44,139.5 130.02,140.92 122.58,140.92 122.25,140.59 122.25,140.11 122.12,139.98 121.72,139.98 121.55,139.81 121.45,139.61 121.44,139.61 121.29,139.45 121.25,139.24 121.26,139.22 121,138.7 120.08,138.7 119.86,138.48 119.81,138.26
PVCCSA on BOTTOM: 121.85,138.46 120.36,137.29 120.22,137.3 119.23,137.3 119.18,137.35 119.18,144.68 119.71,144.68 119.71,145.01 121.68,145.01 121.85,144.84
PVCCSA on BOTTOM: 138.07,153.7 140.36,153.7 140.56,153.9 140.56,157.13 141.33,157.9 141.33,159.88 141.65,160.2 141.65,162.49 141.4,162.74 138.07,162.74 137.82,162.49 137.82,153.95
PVCCSA on L3: 119.78,146.34 120.61,147.18 120.61,158.69 121.18,159.26 140.56,159.26 141.02,158.8 141.02,148.75 136.6,144.33 124.95,144.33 122.48,141.86 122.48,139.63 121.75,138.9 119.54,138.9 119.35,139.09 119.35,145.91
PVCCSA on L5: 120.6,144.86 130.73,144.86 130.93,145.06 130.93,153.5 136.85,159.41 140.26,159.41 140.61,159.06 140.61,154.16 140.18,153.72 138.63,153.72 136.6,151.69 136.52,151.69 136.52,142.85 133.98,140.31 123.01,140.31 122.86,140.47 122.02,140.47 121.21,139.65 121.21,139.25 120.95,138.99 119.38,138.99 119.3,139.07 119.3,143.56
PVCCSA on L6: 120.47,137.27 120.45,137.27 120.38,137.25 120.3,137.21 119.63,137.21 119.63,144.71 130.93,144.71 130.93,160.2 142.36,160.2 142.36,145.22 136.9,139.75 136.9,137.27
PVCCSA on L8: 120.29,138.7 120.29,144.86 130.63,144.86 130.88,145.11 130.88,155.45 136.24,160.81 140.51,160.81 140.84,160.48 140.84,154.23 137.69,151.08 137.69,144.99 137.56,144.86 134.54,144.86 133.32,143.64 133.32,138.66 132.94,138.28 120.71,138.28
PVCCSA on L10: 119.47,138.9 119.26,139.11 119.26,139.99 119.24,140.02 119.37,145.92 126.01,152.71 126.95,151.77 130.93,151.77 130.93,158.98 131.31,159.36 140.92,159.36 141.12,159.16 141.12,147.5 133.4,139.78 124.15,139.78 123.27,138.9
PVCCST on TOP: 131.14,137.14 131.14,139.37 129.87,140.64 122.48,140.64 122.48,139.37 121.69,139.37 120.9,138.59 120.9,137.32 121.08,137.14
PVCCSTG on TOP (solid shape): 228.5,56.06 228.5,54.03 227.84,54.03 226.82,55.05 226.82,56.32 226.92,56.42 228.14,56.42
VCCAMPHYPLL on BOTTOM: 234.85,38.69 237.08,40.92 238.07,40.92 238.25,41.1 238.25,41.38 238.38,41.51 239.5,41.51 239.71,41.3 239.71,40.62 238.88,39.79 238.88,39.78 238.74,39.64 238.74,37.52 234.74,37.52 234.74,37.82 234.31,37.82 234.26,37.87 234.26,38.41 234.54,38.69
VCCPRIM_1P2 on BOTTOM (solid shape): 252.03,54.8 252.03,53.95 251.88,53.8 250.97,53.8 250.63,54.14 250.63,54.46 251.05,54.88 251.95,54.88
