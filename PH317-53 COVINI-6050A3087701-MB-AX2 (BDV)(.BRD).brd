# Allegro board PH317-53 COVINI-6050A3087701-MB-AX2 (BDV)(.BRD).brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
M_A_DQ<5>: length 54.8
  L10 w0.076: v1(84.38,120.1) 82.44,120.1 78.99,116.65 78.99,96.55 78.51,96.07 78.51,91.31 78.12,90.92 78.12,82.83 81.2,79.75 81.2,77.94 v3(81.71,77.43)
  BOTTOM w0.076: U4555.BP6 87.06,121.17 86.74,121.17 86.73,121.17 86.55,120.98 86.31,120.98 86.31,120.98 86.06,120.98 86.06,120.98 86.05,120.98 85.84,121.2 85.05,121.2 84.56,120.71 84.38,120.27 v1(84.38,120.1)
  BOTTOM w0.109: v3(81.71,77.43) 81.71,77.42 81.8,77.34 82.15,76.48 82.32,75.64 CN4100.8
M_A_DQ<6>: length 53.1
  L10 w0.076: v1(83.33,116.77) 83.33,116.31 82.95,115.93 82.71,115.93 81.3,114.52 81.3,87.81 81.38,87.74 82.04,87.74 82.11,87.66 82.11,87.43 82.04,87.36 81.38,87.36 81.3,87.28 81.3,87.05 81.38,86.97 82.04,86.97 82.11,86.9 82.11,86.67 82.04,86.59 81.38,86.59 81.3,86.52 81.3,86.29 81.38,86.21 82.04,86.21 82.11,86.14 82.11,85.91 82.04,85.83 81.55,85.83 81.48,85.76 81.48,83.95 83.54,81.89 83.54,80 v3(84.09,79.45)
  BOTTOM w0.076: U4555.BP2 87.1,118.07 87.1,117.5 86.83,117.24 86.43,117.24 86.42,117.23 84.61,117.23 84.15,116.77 v1(83.33,116.77)
  BOTTOM w0.109: v3(84.09,79.45) 84.81,80.18 84.81,81.07 85.66,81.92 CN4100.21
M_A_DQ<7>: length 53.7
  L10 w0.076: v1(83.65,117.35) 83.22,117.35 82.63,116.75 82.32,116.75 81.02,115.45 81.02,87.21 80.95,87.13 80.73,87.13 80.65,87.05 80.65,86.82 80.73,86.75 80.95,86.75 81.02,86.67 81.02,86.44 80.95,86.37 80.73,86.37 80.65,86.29 80.65,86.06 80.73,85.99 80.95,85.99 81.02,85.91 81.02,85.68 80.95,85.6 80.73,85.6 80.65,85.53 80.65,85.3 80.73,85.22 80.95,85.22 81.02,85.15 81.02,84.92 80.95,84.84 80.73,84.84 80.65,84.77 80.65,84.54 80.73,84.46 80.95,84.46 81.02,84.39 81.02,84.01 83.26,81.77 83.26,78.84 v3(84.07,78.03)
  BOTTOM w0.076: U4555.BN3 86.72,118.71 86.55,118.54 86.55,118.1 85.94,117.49 84.62,117.49 84.38,117.25 83.74,117.25 v1(83.65,117.35)
  BOTTOM w0.109: v3(84.07,78.03) 84.98,77.12 84.98,76.31 85.41,75.88 CN4100.20
M_A_DQ<8>: length 52.3
  L10 w0.076: v1(89.82,119.31) 89.55,119.04 88.58,119.04 85.59,116.06 84.81,116.06 82.34,113.59 82.34,94.62 82.65,94.31 82.78,94.31 82.86,94.23 82.86,94.01 82.78,93.93 82.48,93.93 82.4,93.85 82.4,93.63 82.48,93.55 82.79,93.55 83.19,93.15 83.19,84.77 83.65,84.32 83.65,83.26 84.86,82.05 84.86,79.06 85.45,78.47 v3(85.64,78.47)
  BOTTOM w0.076: v1(89.82,119.31) 89.5,119.64 U4555.BL4
  BOTTOM w0.109: v3(85.64,78.47) 85.64,78.41 86.99,77.06 86.99,76.6 87.41,76.18 CN4100.28
M_A_DQ<9>: length 52.7
  L10 w0.076: v3(85.64,76.94) 85.18,76.94 84.58,77.54 84.58,81.93 83.37,83.14 83.37,84.2 82.91,84.66 82.91,92.22 82.78,92.35 82.64,92.35 82.56,92.43 82.56,92.66 82.64,92.74 82.82,92.74 82.91,92.83 82.91,93.01 82.75,93.17 82.44,93.17 82.06,93.54 82.06,113.74 84.67,116.35 85.44,116.35 88.46,119.38 89.24,119.38 v1(89.82,119.96)
  BOTTOM w0.076: v1(89.82,119.96) 89.5,120.29 U4555.BL5
  BOTTOM w0.109: CN4100.24 86.41,76.16 v3(85.64,76.94)
M_A_DQ<10>: length 51
  L10 w0.076: v1(87.53,116.32) 87.53,115.47 85.14,113.09 85.14,96.25 86.47,94.92 86.47,90.75 86.22,90.5 85.99,90.5 85.88,90.39 85.88,90.19 85.95,90.11 86.39,90.11 86.47,90.04 86.47,89.86 86.39,89.78 85.98,89.78 85.88,89.69 85.88,89.48 85.96,89.4 86.39,89.4 86.47,89.33 86.47,89.1 86.39,89.02 86.02,89.02 85.5,88.51 85.5,85.92 86.13,85.3 86.13,84.26 87.87,82.53 87.87,79.45 v3(88.58,78.74)
  BOTTOM w0.076: v1(87.53,116.32) 88.09,116.32 89.38,117.61 U4555.BL2
  BOTTOM w0.109: v3(88.58,78.74) 89.31,78.01 89.31,77.29 90.83,75.77 90.83,74.75 CN4100.42
M_A_DQ<11>: length 49.8
  L10 w0.076: v3(88.59,80.07) 88.17,80.49 88.17,82.62 86.41,84.38 86.41,85.38 86.72,85.69 86.72,86.36 86.4,86.68 86.04,86.68 85.94,86.79 85.94,86.99 86.01,87.07 86.79,87.07 86.87,87.14 86.87,87.37 86.79,87.45 86.04,87.45 85.94,87.55 85.94,87.75 86.01,87.83 86.79,87.83 86.87,87.9 86.87,88.13 86.79,88.21 86.04,88.21 85.94,88.31 85.94,88.51 86.01,88.59 86.79,88.59 86.87,88.67 86.87,94.95 85.42,96.4 85.42,113.03 88.38,115.99 v1(88.38,117.18)
  BOTTOM w0.076: v1(88.38,117.18) 88.5,117.18 U4555.BM1
  BOTTOM w0.109: CN4100.41 90.72,83.06 90.72,81.59 90.48,81.35 89.86,81.35 v3(88.59,80.07)
M_A_DQ<12>: length 52.7
  L10 w0.076: v3(85.63,81.16) 85.63,82.07 84.2,83.49 84.2,84.55 83.75,85.01 83.75,94.53 83.39,94.9 83.39,97.26 83.26,97.39 83.03,97.39 82.95,97.47 82.95,97.7 83.03,97.77 83.28,97.77 83.35,97.85 83.35,98.08 83.28,98.15 83.03,98.15 82.95,98.23 82.95,98.46 83.03,98.53 83.28,98.53 83.35,98.61 83.35,98.84 83.28,98.91 83.03,98.91 82.95,98.99 82.95,99.22 83.03,99.3 83.28,99.3 83.35,99.37 83.35,99.6 83.28,99.68 83.03,99.68 82.95,99.75 82.95,99.98 83.03,100.06 83.28,100.06 83.35,100.13 83.35,100.36 83.28,100.44 83.03,100.44 82.95,100.51 82.95,100.74 83.03,100.82 83.28,100.82 83.35,100.9 83.35,101.12 83.28,101.2 83.03,101.2 82.95,101.28 82.95,101.51 83.03,101.58 83.28,101.58 83.35,101.66 83.35,101.89 83.28,101.96 83.03,101.96 82.95,102.04 82.95,102.27 83.03,102.34 83.28,102.34 83.35,102.42 83.35,102.65 83.28,102.72 83.03,102.72 82.95,102.8 82.95,103.03 83.03,103.11 83.28,103.11 83.35,103.18 83.35,103.41 83.28,103.49 83.03,103.49 82.95,103.56 82.95,103.79 83.03,103.87 83.28,103.87 83.35,103.94 83.35,104.17 83.28,104.25 83.03,104.25 82.95,104.32 82.95,104.55 83.03,104.63 83.28,104.63 83.35,104.71 83.35,104.93 82.95,105.33 82.95,113.3 85.19,115.54 85.86,115.54 88.05,117.74 89.08,117.74 90.61,119.26 v1(90.61,119.31)
  BOTTOM w0.076: U4555.BK4 v1(90.61,119.31)
  BOTTOM w0.109: CN4100.25 86.66,81.95 85.87,81.16 v3(85.63,81.16)
M_A_DQ<13>: length 53.3
  L10 w0.076: v3(85.65,79.84) 85.49,79.84 85.14,80.19 85.14,82.16 83.92,83.37 83.92,84.44 83.47,84.89 83.47,93.33 83.21,93.6 83.21,93.94 83.47,94.21 83.47,94.42 83.22,94.67 82.7,94.67 82.62,94.74 82.62,94.97 82.7,95.05 83.02,95.05 83.1,95.12 83.1,95.35 83.02,95.43 82.7,95.43 82.62,95.5 82.62,95.73 82.7,95.81 83.02,95.81 83.1,95.89 83.1,96.11 83.02,96.19 82.7,96.19 82.62,96.27 82.62,96.49 82.7,96.57 83.02,96.57 83.1,96.65 83.1,96.88 83.02,96.95 82.7,96.95 82.62,97.03 82.62,113.38 85.01,115.77 85.66,115.77 88.66,118.77 89.86,118.77 90.22,119.14 90.22,119.58 v1(90.61,119.96)
  BOTTOM w0.076: U4555.BK5 v1(90.61,119.96)
  BOTTOM w0.109: CN4100.29 87.66,81.85 v3(85.65,79.84)
M_A_DQ<14>: length 50.6
  L10 w0.076: v3(88.59,77.42) 87.59,78.43 87.59,82.29 85.73,84.14 85.73,85.29 85.22,85.8 85.22,90.23 85.89,90.9 86.09,90.9 86.17,90.98 86.17,91.21 86.09,91.29 85.62,91.29 85.52,91.38 85.52,91.59 85.6,91.67 86.09,91.67 86.17,91.74 86.17,91.97 86.09,92.05 85.62,92.05 85.52,92.14 85.52,92.35 85.6,92.43 85.9,92.43 86.17,92.7 86.17,94.82 84.86,96.13 84.86,113.09 87.06,115.29 v1(87.06,115.85)
  BOTTOM w0.076: v1(87.06,115.85) 87.57,115.85 88.22,116.12 U4555.BK1
  BOTTOM w0.109: v3(88.59,77.42) 89.91,76.1 CN4100.38
M_A_DQ<15>: length 51.6
  L10 w0.076: v3(87.06,80.36) 87.2,80.51 87.2,82.18 85.4,83.98 85.4,85.17 84.94,85.62 84.94,92.75 85.02,92.83 85.79,92.83 85.87,92.91 85.87,93.14 85.79,93.21 85.07,93.21 84.99,93.29 84.99,93.52 85.07,93.59 85.79,93.59 85.87,93.67 85.87,93.9 85.79,93.97 85.07,93.97 84.99,94.06 84.99,94.28 85.07,94.35 85.7,94.35 85.82,94.47 85.82,94.77 85.69,94.9 85.09,94.9 84.58,95.41 84.58,113.48 v1(84.8,113.7)
  BOTTOM w0.076: 87.21,114.54 88.56,115.38 90.5,117.32 90.5,118.05 U4555.BK2
  BOTTOM w0.109: v1(84.8,113.7) 84.81,113.72 85.56,113.93 87.21,114.54 ; CN4100.37 89.58,83.03 89.58,81.88 88.78,81.07 87.77,81.07 v3(87.06,80.36)
M_A_DQ<16>: length 51.7
  L10 w0.076: v1(90.35,116.06) 89.89,116.06 88.5,115.48 86.21,113.19 86.21,96.96 87.63,95.55 87.63,85.31 89.35,83.59 89.35,79.23 v3(90.47,78.11)
  BOTTOM w0.076: v1(90.35,116.06) 91.16,116.06 91.79,116.69 91.79,117.18 91.47,117.5 91.47,117.98 91.65,118.16 91.65,119.55 91.74,119.64 U4555.BG4
  BOTTOM w0.109: CN4100.50 92.91,75.83 90.64,78.11 v3(90.47,78.11)
M_A_DQ<17>: length 52.1
  L10 w0.076: v1(90.8,116.5) 90.43,116.5 88.32,115.63 85.9,113.21 85.9,96.72 87.35,95.27 87.35,85.19 89.07,83.47 89.07,78.66 89.35,77.98 v3(90.54,76.79)
  BOTTOM w0.076: v1(90.8,116.5) 91.34,116.5 91.63,116.8 91.63,117.11 91.31,117.44 91.31,118.15 91.34,118.19 91.34,119.69 U4555.BG5
  BOTTOM w0.109: v3(90.54,76.79) 90.55,76.79 90.85,76.79 91.82,75.82 91.82,74.76 CN4100.46
M_A_DQ<18>: length 51.8
  L10 w0.076: v1(93.12,119.31) 91.94,118.13 91.94,116.43 88.83,113.32 88.83,112.42 88.49,112.08 88.49,101.8 88.86,101.42 89.55,101.42 89.66,101.31 89.66,101.06 89.59,100.99 89.1,100.99 89.02,100.9 89.02,100.68 89.09,100.61 89.5,100.61 89.66,100.45 89.66,86.15 92.93,82.89 92.93,79.92 94.28,78.56 94.53,78.56 v3(94.53,78.56)
  BOTTOM w0.076: U4555.BF4 92.8,119.64 v1(93.12,119.31)
  BOTTOM w0.109: v3(94.53,78.56) 95.54,77.56 95.54,76.39 95.83,76.1 95.83,74.74 CN4100.62
M_A_DQ<19>: length 52.3
  L10 w0.076: v1(93.12,119.96) 92.8,119.96 91.67,118.83 91.67,116.62 88.5,113.45 88.5,112.54 88.19,112.23 88.19,101.1 88.97,100.33 89.25,100.33 89.38,100.19 89.38,99.85 89.29,99.75 88.94,99.75 88.85,99.66 88.85,99.44 89.38,98.91 89.38,86.03 92.64,82.78 92.64,78.92 v3(94.36,77.2)
  BOTTOM w0.076: U4555.BF5 92.8,120.29 v1(93.12,119.96)
  BOTTOM w0.109: v3(94.36,77.2) 94.33,77.2 94,76.88 94,76.53 94.1,76.43 94.54,76.43 94.91,76.05 CN4100.58
M_A_DQ<20>: length 50.4
  L10 w0.076: v3(90.46,79.46) 90.19,79.46 89.63,80.02 89.63,83.7 87.91,85.42 87.91,96.1 87.8,96.2 87.43,96.2 87.36,96.28 87.36,96.49 87.45,96.58 87.8,96.58 87.88,96.66 87.88,96.89 87.8,96.97 87.12,96.97 86.52,97.56 86.52,113.15 88.53,115.16 v1(89.45,115.16)
  BOTTOM w0.076: v1(89.45,115.16) 89.51,115.1 89.95,115.1 90.57,115.72 91.08,115.72 92.05,116.7 92.05,117.15 91.65,117.56 91.65,117.85 91.94,118.14 U4555.BG2
  BOTTOM w0.109: v3(90.47,79.46) 90.61,79.46 92.66,81.52 CN4100.49
M_A_DQ<21>: length 49.4
  L10 w0.076: v1(89,114.71) 88.4,114.71 86.81,113.12 86.81,98.77 86.96,98.63 87.77,98.63 87.89,98.51 87.89,98.24 87.79,98.14 86.94,98.14 86.87,98.07 86.87,97.74 86.94,97.66 88.1,97.66 88.19,97.57 88.19,85.54 90,83.73 90,83.22 90.07,83.14 90.58,83.14 90.71,83.01 90.71,82.77 90.61,82.66 90.05,82.66 89.96,82.58 89.96,82.34 90.04,82.27 90.73,82.27 90.8,82.19 90.8,81 90.59,80.78 v3(90.46,80.78)
  BOTTOM w0.076: v1(89,114.71) 89.06,114.77 89.95,114.77 90.62,115.43 91.04,115.43 92.26,116.65 92.26,117.19 91.94,117.5 U4555.BG1
  BOTTOM w0.109: v3(90.46,80.78) 90.68,80.78 91.66,81.77 CN4100.45
M_A_DQ<22>: length 50.1
  L10 w0.076: v3(94.52,81.4) 93.54,82.38 93.54,83.06 90.22,86.38 90.22,103.38 89.91,103.69 89.23,103.69 89.13,103.79 89.13,103.96 89.21,104.04 89.5,104.04 89.58,104.11 89.58,104.35 89.47,104.46 89.16,104.46 89.08,104.53 89.08,104.76 89.16,104.84 89.42,104.84 89.5,104.91 89.5,105.14 89.42,105.22 89.16,105.22 89.08,105.29 89.08,105.52 89.16,105.6 89.42,105.6 89.5,105.68 89.5,105.9 89.42,105.98 89.16,105.98 89.08,106.06 89.08,106.29 89.16,106.36 89.42,106.36 89.5,106.44 89.5,106.67 89.42,106.74 89.16,106.74 89.08,106.82 89.08,107.05 89.16,107.12 89.42,107.12 89.5,107.2 89.5,107.43 89.42,107.5 89.16,107.5 89.08,107.58 89.08,107.81 89.16,107.89 89.42,107.89 89.5,107.96 89.5,108.19 89.42,108.27 89.16,108.27 89.08,108.34 89.08,108.57 89.16,108.65 89.42,108.65 89.5,108.72 89.5,108.95 89.42,109.03 89.16,109.03 89.08,109.1 89.08,109.33 89.16,109.41 89.42,109.41 89.5,109.49 89.5,109.71 89.42,109.79 89.16,109.79 89.08,109.87 89.08,110.1 89.16,110.17 89.42,110.17 89.5,110.25 89.5,110.48 89.42,110.55 89.16,110.55 89.08,110.63 89.08,110.86 89.16,110.93 89.42,110.93 89.5,111.01 89.5,113.02 92.64,116.16 92.64,116.87 v1(93.12,117.36)
  BOTTOM w0.076: U4555.BF1 92.8,117.69 v1(93.12,117.36)
  BOTTOM w0.109: CN4100.59 95.16,81.93 95.47,81.63 95.47,81.3 95.2,81.03 94.89,81.03 v3(94.52,81.4)
M_A_DQ<23>: length 50.4
  L10 w0.076: v1(93.12,118.01) 92.31,117.19 92.31,116.34 89.12,113.16 89.12,112.12 88.79,111.78 88.79,103.74 89.12,103.4 89.79,103.4 89.94,103.25 89.94,102.96 89.82,102.84 89.11,102.84 89.04,102.76 89.04,102.53 89.11,102.46 89.87,102.46 89.94,102.38 89.94,102.16 89.87,102.08 89.17,102.08 89.09,102 89.09,101.78 89.16,101.7 89.87,101.7 89.94,101.62 89.94,86.26 93.21,83 93.21,81.2 v3(94.52,79.88)
  BOTTOM w0.076: U4555.BF2 92.8,118.34 v1(93.12,118.01)
  BOTTOM w0.109: CN4100.63 96.16,81.88 95.79,81.51 95.79,80.95 94.72,79.88 v3(94.52,79.88)
M_A_DQ<24>: length 50.2
  L10 w0.076: v3(96.34,78.17) 96.03,77.86 95.65,77.86 95.52,77.99 95.52,82.16 90.98,86.7 90.98,105.44 90.87,105.56 90.44,105.56 90.29,105.71 90.29,112.27 91.62,113.6 91.62,113.98 91.78,114.13 v1(91.78,114.74)
  BOTTOM w0.076: v1(91.78,114.74) 92.33,114.74 92.97,115.38 93.27,115.38 94.24,116.35 94.24,117.47 94.17,117.54 94.17,117.81 94.46,118.1 U4555.BD2
  BOTTOM w0.109: CN4100.70 97.84,74.74 97.84,75.78 96.73,76.89 96.73,77.48 96.34,77.87 v3(96.34,78.17)
M_A_DQ<25>: length 49.3
  L10 w0.076: v3(96.06,76.68) 95.4,76.68 95.23,76.86 95.23,82.06 90.7,86.58 90.7,104.09 90.46,104.33 90.46,104.69 90.7,104.93 90.7,105.16 90.62,105.24 90.11,105.24 90.01,105.34 90.01,112.41 91.33,113.72 v1(91.33,114.29)
  BOTTOM w0.076: U4555.BD1 94.46,116.45 94.4,116.4 94.4,116.28 93.34,115.21 93.1,115.21 92.18,114.29 v1(91.33,114.29)
  BOTTOM w0.109: v3(96.06,76.68) 96.08,76.68 96.91,75.85 CN4100.66
M_A_DQ<26>: length 52.2
  L10 w0.076: v1(95.64,119.31) 94.91,119.31 94.57,118.97 94.57,113.65 93.03,112.11 93.03,87.56 94.87,85.72 95.61,85.72 97.07,84.27 97.07,84.16 96.85,83.94 96.85,83.83 97.01,83.67 97.12,83.67 97.34,83.89 97.45,83.89 97.61,83.73 97.61,83.62 97.39,83.4 97.39,83.29 97.86,82.81 97.86,80.41 98.9,79.37 98.9,78.3 99.01,78.18 99.19,78.18 v3(99.37,78.36)
  BOTTOM w0.076: v1(95.64,119.31) 95.31,119.64 U4555.BC4
  BOTTOM w0.109: v3(99.37,78.36) 99.68,78.36 101.41,76.63 CN4100.84
M_A_DQ<27>: length 52.6
  L10 w0.076: v3(99.4,77.04) 98.62,77.82 98.62,79.26 97.57,80.31 97.57,82.69 96.42,83.83 96.42,83.94 96.66,84.18 96.66,84.28 96.5,84.45 96.39,84.45 96.15,84.21 96.04,84.21 95.88,84.37 95.88,84.48 96.12,84.71 96.12,84.82 95.5,85.44 94.76,85.44 92.75,87.45 92.75,112.32 94.19,113.76 94.19,119.73 94.42,119.96 v1(95.64,119.96)
  BOTTOM w0.076: v1(95.64,119.96) 95.31,120.29 U4555.BC5
  BOTTOM w0.109: v3(99.4,77.04) 99.4,77.04 99.72,77.04 100.41,76.35 CN4100.80
M_A_DQ<28>: length 52.5
  L10 w0.076: v3(96.33,80.83) 96.33,82.14 91.54,86.93 91.54,107.57 91.47,107.64 90.93,107.64 90.85,107.72 90.85,107.95 90.93,108.03 91.47,108.03 91.54,108.1 91.54,108.33 91.47,108.41 90.93,108.41 90.85,108.48 90.85,108.71 90.93,108.79 91.47,108.79 91.54,108.86 91.54,109.09 91.47,109.17 90.93,109.17 90.85,109.24 90.85,109.47 90.93,109.55 91.47,109.55 91.54,109.63 91.54,109.85 91.47,109.93 90.93,109.93 90.85,110.01 90.85,110.23 90.93,110.31 91.47,110.31 91.54,110.39 91.54,110.62 91.47,110.69 90.93,110.69 90.85,110.77 90.85,111 90.93,111.07 91.47,111.07 91.54,111.15 91.54,111.38 91.47,111.45 90.93,111.45 90.85,111.53 90.85,111.76 90.93,111.84 91.47,111.84 91.54,111.91 91.54,112.68 92.08,113.21 92.08,113.93 93.12,114.98 v1(93.12,116.09)
  BOTTOM w0.076: U4555.BD5 93.94,119.77 93.94,118.71 93.85,118.62 93.85,117.57 93.82,117.54 93.82,116.99 93.5,116.67 93.5,116.47 v1(93.12,116.09)
  BOTTOM w0.109: v3(96.33,80.83) 97.16,81.66 CN4100.67
M_A_DQ<29>: length 51.6
  L10 w0.076: v1(92.67,115.64) 92.67,115.01 92.18,114.52 92.18,114.3 91.89,114.01 91.89,113.48 90.57,112.16 90.57,107.57 90.77,107.36 91.19,107.36 91.26,107.29 91.26,107.07 91.19,106.99 90.66,106.99 90.58,106.92 90.58,106.69 90.66,106.61 91.19,106.61 91.26,106.54 91.26,106.31 91.19,106.23 90.66,106.23 90.58,106.15 90.58,105.93 90.66,105.85 91.19,105.85 91.26,105.77 91.26,86.81 95.8,82.28 95.8,79.82 96.12,79.49 v3(96.34,79.49)
  BOTTOM w0.076: v1(92.67,115.64) 93.24,115.64 94.01,116.42 94.01,118.45 94.16,118.61 94.16,119.34 U4555.BD4
  BOTTOM w0.109: v3(96.34,79.49) 98.07,81.22 98.07,83.02 CN4100.71
M_A_DQ<30>: length 50.5
  L10 w0.076: v1(95.64,117.36) 95.39,117.36 95.18,117.15 95.18,113.47 93.59,111.88 93.59,90.95 93.67,90.87 94.36,90.87 94.44,90.8 94.44,90.57 94.36,90.49 93.63,90.49 93.59,90.46 93.59,90.15 93.63,90.11 94.36,90.11 94.44,90.04 94.44,89.81 94.36,89.73 93.63,89.73 93.59,89.69 93.59,89.39 93.63,89.35 94.36,89.35 94.44,89.27 94.44,89.05 94.36,88.97 93.63,88.97 93.59,88.93 93.59,88.63 93.63,88.59 94.36,88.59 94.44,88.51 94.44,88.28 94.36,88.21 93.67,88.21 93.59,88.13 93.59,87.89 93.69,87.78 94.43,87.78 94.59,87.62 94.59,86.91 95.1,86.41 95.92,86.41 98.49,83.84 98.49,83.22 98.68,83.04 99.49,83.04 99.86,82.66 99.86,81.76 v3(99.38,81.27)
  BOTTOM w0.076: v1(95.64,117.36) 95.31,117.69 U4555.BC1
  BOTTOM w0.109: CN4100.79 100.16,81.57 99.87,81.27 v3(99.38,81.27)
M_A_DQ<31>: length 50.8
  L10 w0.076: v3(99.36,79.89) 99.36,80.05 99.08,80.33 98.48,80.33 98.39,80.42 98.39,80.71 98.47,80.79 98.89,80.79 98.97,80.86 98.97,81.09 98.89,81.17 98.47,81.17 98.39,81.24 98.39,81.47 98.47,81.55 98.96,81.55 99.04,81.62 99.04,81.85 98.96,81.93 98.47,81.93 98.39,82.01 98.39,82.3 98.47,82.38 98.95,82.38 99.03,82.45 99.03,82.68 98.95,82.76 98.29,82.76 98.21,82.83 98.21,83.72 95.93,86 94.99,86 93.31,87.68 93.31,111.99 94.87,113.55 94.87,117.78 95.09,118.01 v1(95.64,118.01)
  BOTTOM w0.076: U4555.BC2 95.31,118.34 v1(95.64,118.01)
  BOTTOM w0.109: v3(99.36,79.89) 99.6,79.89 101.16,81.45 CN4100.83
M_A_DQ<32>: length 51.2
  L10 w0.076: v1(111.62,114.15) 111.62,112.56 115.27,108.91 115.27,102.69 114.88,102.31 114.88,102.08 114.96,102 115.19,102 115.27,101.93 115.27,101.7 115.19,101.62 114.96,101.62 114.88,101.54 114.88,101.32 114.96,101.24 115.19,101.24 115.27,101.16 115.27,100.94 115.19,100.86 114.96,100.86 114.88,100.78 114.88,96.85 125.66,86.06 125.66,81.54 126,81.21 126,78.78 v3(125.37,78.15)
  BOTTOM w0.076: v1(111.62,114.15) 112.12,114.65 112.12,115.31 112.13,115.33 112.13,117.61 U4555.AB1
  BOTTOM w0.109: CN4100.170 124.91,77.7 v3(125.37,78.15)
M_A_DQ<33>: length 51.6
  L10 w0.076: v1(111.17,114.6) 111.23,114.54 111.23,113.87 111.31,113.79 111.31,112.47 114.99,108.79 114.99,104.39 114.91,104.31 114.55,104.31 114.47,104.23 114.47,104 114.55,103.93 114.91,103.93 114.99,103.85 114.99,103.62 114.91,103.55 114.55,103.55 114.47,103.47 114.47,103.24 114.55,103.17 114.91,103.17 114.99,103.09 114.99,102.86 114.47,102.35 114.47,96.86 125.38,85.95 125.38,81.43 125.7,81.11 125.7,79.84 v3(125.3,79.44)
  BOTTOM w0.076: v1(111.17,114.6) 111.97,115.4 111.97,117.37 111.77,117.57 111.77,118.05 U4555.AB2
  BOTTOM w0.109: CN4100.173 125.7,83.08 125.7,79.84 v3(125.3,79.44)
M_A_DQ<34>: length 52.5
  L10 w0.076: v1(113.24,119.31) 113.04,119.11 112.78,118.73 112.29,117.54 112.12,116.68 112.12,114.64 112.75,114.01 112.75,113.77 114.13,112.4 114.13,112.22 116.79,109.56 116.79,97.02 128.09,85.72 128.09,83.34 128.44,82.98 128.99,82.98 129.06,82.91 129.06,82.68 128.99,82.6 128.41,82.6 128.34,82.53 128.34,82.3 128.41,82.22 128.99,82.22 129.06,82.14 129.06,81.92 128.99,81.84 128.41,81.84 128.34,81.76 128.34,80.63 128.59,80.38 v3(128.76,80.38)
  BOTTOM w0.076: v1(113.24,119.31) 112.91,119.64 U4555.AA4
  BOTTOM w0.109: CN4100.183 128.16,80.6 128.38,80.38 v3(128.76,80.38)
M_A_DQ<35>: length 53.1
  L10 w0.076: v1(113.24,119.96) 113.03,119.75 112.76,119.35 112.07,117.69 111.87,116.65 111.87,114.57 112.53,113.9 112.53,113.76 113.79,112.49 113.79,112.15 116.51,109.44 116.51,96.91 127.81,85.61 127.81,83.22 128.06,82.97 128.06,79.39 v3(127.6,77.09)
  BOTTOM w0.076: U4555.AA5 v1(113.24,119.96)
  BOTTOM w0.109: v3(127.6,77.09) 128.01,76.68 128.01,74.76 CN4100.182
M_A_DQ<36>: length 53
  L10 w0.076: v1(111.17,116.5) 111.05,116.5 110.56,116.02 110.56,114.23 110.72,114.07 110.72,112.18 113.85,109.06 113.85,96.69 124.83,85.72 124.83,76.96 125,76.79 v3(125.38,76.79)
  BOTTOM w0.076: v1(111.17,116.5) 111.55,116.89 111.55,117.3 111.46,117.39 111.46,118.43 111.58,118.55 111.58,119.81 U4555.AB5
  BOTTOM w0.109: CN4100.174 125.91,76.26 v3(125.38,76.79)
M_A_DQ<37>: length 52.7
  L10 w0.076: v3(125.26,80.81) 125.25,80.81 125.11,80.95 125.11,85.83 114.13,96.81 114.13,104.48 114.26,104.61 114.6,104.61 114.68,104.68 114.68,104.91 114.6,104.99 114.26,104.99 114.18,105.07 114.18,105.29 114.26,105.37 114.6,105.37 114.68,105.45 114.68,105.67 114.6,105.75 114.26,105.75 114.18,105.83 114.18,106.06 114.26,106.13 114.6,106.13 114.68,106.21 114.68,106.44 114.6,106.51 114.26,106.51 114.18,106.59 114.18,106.82 114.26,106.89 114.6,106.89 114.68,106.97 114.68,107.2 114.6,107.27 114.26,107.27 114.18,107.35 114.18,107.58 114.26,107.66 114.6,107.66 114.68,107.73 114.68,107.96 114.6,108.04 114.26,108.04 114.18,108.11 114.18,108.34 114.26,108.42 114.6,108.42 114.68,108.49 114.68,108.67 110.99,112.35 110.99,114.13 110.77,114.35 110.77,115.47 v1(111.17,115.87)
  BOTTOM w0.076: v1(111.17,115.87) 111.56,116.26 111.56,116.59 111.72,116.75 111.72,117.37 111.61,117.47 111.61,118.35 111.77,118.5 111.77,119.34 U4555.AB4
  BOTTOM w0.109: CN4100.169 124.77,83.01 124.77,81.24 125.2,80.81 v3(125.26,80.81)
M_A_DQ<38>: length 51.3
  L10 w0.076: v3(128.77,79.06) 128.77,79.06 129.03,79.31 129.22,79.79 129.35,80.44 129.35,83.05 128.37,84.04 128.37,85.84 117.1,97.1 117.1,109.7 112.97,113.82 112.97,114.11 112.39,114.69 112.39,116.09 112.79,117.57 v1(113.24,118.03)
  BOTTOM w0.076: U4555.AA2 112.91,118.34 v1(113.24,118.03)
  BOTTOM w0.109: CN4100.187 129.27,83.01 129.27,79.56 128.77,79.06 v3(128.77,79.06)
M_A_DQ<39>: length 50.5
  L10 w0.076: v3(128.76,77.72) 129.02,78.11 129.1,78.25 129.31,78.95 129.46,79.56 129.63,80.41 129.63,83.08 129.58,83.42 129.16,84.81 128.65,85.95 117.43,97.18 117.43,109.87 116.57,110.73 116.37,110.73 113.52,113.58 113.32,113.88 113.12,114.26 112.86,114.74 112.63,115.3 112.63,115.68 112.72,116.34 112.86,116.86 113.06,117.21 v1(113.24,117.39)
  BOTTOM w0.076: U4555.AA1 v1(113.24,117.39)
  BOTTOM w0.109: v3(128.76,77.72) 129.01,77.48 129.01,74.76 CN4100.186
M_A_DQ<40>: length 56.7
  L10 w0.076: v1(113.24,116.12) 112.86,115.74 112.86,115.3 113.07,114.8 113.7,114.16 113.7,113.7 116.43,110.97 116.78,110.97 117.91,109.84 117.91,108.81 117.99,108.73 118.3,108.73 118.37,108.66 118.37,108.43 118.3,108.35 117.99,108.35 117.91,108.28 117.91,108.05 117.99,107.97 118.3,107.97 118.37,107.9 118.37,107.67 118.3,107.59 117.99,107.59 117.91,107.52 117.91,97.38 129.68,85.61 129.68,85 130.11,84.56 130.11,77.4 130.41,77.11 v3(131.13,77.11)
  BOTTOM w0.076: v1(113.24,116.12) 113.92,116.8 113.92,117.52 113.97,117.57 113.97,119.51 114.17,119.71 114.17,119.88 U4555.V5
  BOTTOM w0.109: v3(131.13,77.11) 130.84,77.11 129.91,76.18 CN4100.190
M_A_DQ<41>: length 54.6
  L10 w0.076: v1(114.14,114.59) 114.14,113.78 116.4,111.52 117.06,111.52 118.99,109.59 118.99,105.9 118.92,105.83 118.59,105.83 118.47,105.7 118.47,105.5 118.54,105.43 118.88,105.43 118.96,105.35 118.96,105.12 118.88,105.05 118.54,105.05 118.47,104.97 118.47,104.74 118.54,104.67 118.88,104.67 118.96,104.59 118.96,104.36 118.88,104.29 118.54,104.29 118.47,104.21 118.47,103.98 118.54,103.9 118.88,103.9 118.96,103.83 118.96,103.6 118.88,103.52 118.54,103.52 118.47,103.45 118.47,103.22 118.54,103.14 118.88,103.14 118.96,103.07 118.96,102.84 118.88,102.76 118.54,102.76 118.47,102.68 118.47,102.46 118.54,102.38 118.88,102.38 118.96,102.3 118.96,102.08 118.88,102 118.54,102 118.47,101.92 118.47,97.61 130.28,85.79 130.28,85.23 130.67,84.84 130.67,80.03 130.81,79.89 v3(131.13,79.89)
  BOTTOM w0.076: v1(114.14,114.59) 114.34,114.79 114.34,117.45 114.29,117.51 114.29,118.05 U4555.V2
  BOTTOM w0.109: CN4100.191 130.16,80.86 v3(131.13,79.89)
M_A_DQ<42>: length 53.8
  L10 w0.076: v1(115.73,117.38) 115.32,116.97 115.32,115.6 119.61,111.31 120.1,111.31 121.96,109.46 121.96,108.38 122.03,108.3 122.36,108.3 122.43,108.23 122.43,108 122.36,107.92 122.03,107.92 121.96,107.84 121.96,107.62 122.03,107.54 122.36,107.54 122.43,107.46 122.43,107.23 122.36,107.16 122.03,107.16 121.96,107.08 121.96,97.63 134.69,84.89 134.69,77.76 v3(134,77.07)
  BOTTOM w0.076: U4555.U1 115.37,117.69 v1(115.73,117.38)
  BOTTOM w0.109: v3(134,77.07) 133.41,76.48 133.41,74.92 CN4100.204
M_A_DQ<43>: length 54.4
  L10 w0.076: v3(134.03,79.95) 134.36,80.28 134.36,81.54 134.07,81.83 133.92,81.83 133.85,81.91 133.85,82.14 133.92,82.21 134.34,82.21 134.41,82.29 134.41,82.52 134.34,82.59 133.92,82.59 133.85,82.67 133.85,82.9 133.92,82.98 134.34,82.98 134.41,83.05 134.41,83.28 134.34,83.36 133.92,83.36 133.85,83.43 133.85,83.66 133.92,83.74 134.34,83.74 134.41,83.81 134.41,84.04 134.34,84.12 133.92,84.12 133.85,84.2 133.85,84.42 133.92,84.5 134.34,84.5 134.41,84.58 134.41,84.78 121.64,97.55 121.64,109.36 119.99,111.01 119.66,111.01 115.08,115.59 115.08,117.36 115.72,118.01 v1(115.72,118.03)
  BOTTOM w0.076: U4555.U2 115.38,118.34 v1(115.72,118.03)
  BOTTOM w0.109: CN4100.203 133.07,83.02 133.07,80.9 v3(134.03,79.95)
M_A_DQ<44>: length 53.9
  L10 w0.076: v1(114.59,114.14) 114.59,113.58 116.46,111.71 117.34,111.71 119.29,109.76 119.29,101.75 119.17,101.63 118.88,101.63 118.75,101.5 118.75,101.28 118.82,101.2 119.72,101.2 119.79,101.12 119.79,100.89 119.72,100.82 118.82,100.82 118.75,100.74 118.75,100.51 118.82,100.44 119.72,100.44 119.79,100.36 119.79,100.13 119.72,100.06 118.82,100.06 118.75,99.98 118.75,99.75 118.82,99.68 119.72,99.68 119.79,99.6 119.79,99.37 119.72,99.29 118.82,99.29 118.75,99.22 118.75,98.99 118.82,98.91 119.72,98.91 119.79,98.84 119.79,98.61 119.72,98.53 118.82,98.53 118.75,98.46 118.75,97.73 130.56,85.91 130.56,85.34 131.13,84.78 131.13,81.36 v3(131.16,81.33)
  BOTTOM w0.076: U4555.V1 114.57,114.15 v1(114.59,114.14)
  BOTTOM w0.109: CN4100.195 131.07,83.02 131.07,81.41 131.16,81.33 v3(131.16,81.33)
M_A_DQ<45>: length 55.6
  L10 w0.076: v3(131.14,78.44) 131.03,78.33 130.55,78.33 130.39,78.49 130.39,84.72 130,85.11 130,85.68 118.19,97.49 118.19,106.07 118.26,106.14 118.61,106.14 118.68,106.22 118.68,106.45 118.61,106.52 118.26,106.52 118.19,106.6 118.19,106.95 118.27,107.03 118.63,107.03 118.71,107.1 118.71,109.44 116.85,111.3 116.35,111.3 116.29,111.37 116.29,111.39 113.9,113.78 113.9,114.28 113.35,114.82 113.24,115.1 v1(113.24,115.49)
  BOTTOM w0.076: U4555.V4 114.13,119.19 114.13,116.37 v1(113.24,115.49)
  BOTTOM w0.109: CN4100.194 131.03,74.77 131.03,75.72 131.6,76.29 131.6,77.98 v3(131.14,78.44)
M_A_DQ<46>: length 56.4
  L10 w0.076: v3(133.98,78.4) 132.39,79.99 132.39,80.31 132.46,80.39 132.86,80.39 132.93,80.46 132.93,80.69 132.86,80.77 132.46,80.77 132.39,80.84 132.39,81.07 132.46,81.15 132.86,81.15 132.93,81.23 132.93,81.45 132.86,81.53 132.46,81.53 132.39,81.61 132.39,86.01 121.06,97.33 121.06,109.1 114.55,115.62 114.55,118.79 v1(115.72,119.96)
  BOTTOM w0.076: v1(115.72,119.96) 115.4,120.29 U4555.U5
  BOTTOM w0.109: CN4100.208 134.45,74.7 134.45,77.93 v3(133.98,78.4)
M_A_DQ<47>: length 55.5
  L10 w0.076: v1(115.73,119.28) 115.44,119.28 114.83,118.67 114.83,115.6 119.7,110.73 119.94,110.73 121.36,109.32 121.36,97.44 132.74,86.05 132.74,85.19 132.87,85.06 133.43,85.06 133.54,84.95 133.54,84.67 133.46,84.59 132.77,84.59 132.69,84.51 132.69,84.29 132.77,84.21 133.46,84.21 133.54,84.13 133.54,83.9 133.46,83.83 132.77,83.83 132.69,83.75 132.69,83.52 132.77,83.45 133.46,83.45 133.54,83.37 133.54,83.14 133.46,83.07 132.77,83.07 132.69,82.99 132.69,82.76 132.77,82.69 133.46,82.69 133.54,82.61 133.54,82.38 133.46,82.3 132.77,82.3 132.69,82.23 132.69,82 132.77,81.92 133.44,81.92 133.51,81.85 133.51,81.47 133.62,81.35 v3(133.96,81.35)
  BOTTOM w0.076: v1(115.73,119.28) 115.38,119.64 U4555.U4
  BOTTOM w0.109: v3(133.96,81.35) 134.16,81.56 CN4100.207
M_A_DQ<48>: length 54.4
  L10 w0.076: v1(117.41,114.98) 117.41,114.39 119.58,112.23 120.36,112.23 123.9,108.7 123.9,106.88 123.54,106.52 123.54,106.29 123.61,106.22 123.82,106.22 123.9,106.14 123.9,105.91 123.82,105.84 123.61,105.84 123.54,105.76 123.54,105.53 123.61,105.46 123.82,105.46 123.9,105.38 123.9,105.15 123.82,105.07 123.61,105.07 123.54,105 123.54,104.77 123.61,104.69 123.82,104.69 123.9,104.62 123.9,104.39 123.82,104.31 123.61,104.31 123.54,104.24 123.54,97.52 135.93,85.12 135.93,77.61 135.4,77.07 v3(135.36,77.07)
  BOTTOM w0.076: U4555.R2 116.8,118.05 116.8,117.57 116.87,117.5 116.87,116.8 117.11,116.56 117.11,115.93 117.41,115.63 v1(117.41,114.98)
  BOTTOM w0.109: v3(135.36,77.07) 135.41,77.02 CN4100.212
M_A_DQ<49>: length 55.1
  L10 w0.076: v1(118.24,119.96) 117.92,119.48 117.64,118.8 117.46,117.91 117.46,117.08 117.83,116.19 121.21,112.81 122.25,112.31 122.74,112.05 123.56,111.61 126.15,109.02 126.15,97.11 138.02,85.24 138.02,78.37 138.21,77.56 v3(138.41,76.84)
  BOTTOM w0.076: U4555.P5 117.89,120.29 118.23,120.02 v1(118.24,119.96)
  BOTTOM w0.109: CN4100.224 138.49,74.74 138.49,76.76 v3(138.41,76.84)
M_A_DQ<50>: length 56.1
  L10 w0.076: v1(116.59,115.83) 116.59,114.95 119.59,111.95 120.25,111.95 123.6,108.6 123.6,107.83 123.52,107.75 123.31,107.75 123.24,107.67 123.24,107.44 123.31,107.37 123.52,107.37 123.6,107.29 123.6,107.06 123.24,106.7 123.24,100.38 123.16,100.31 122.85,100.31 122.77,100.23 122.77,100 122.85,99.93 123.16,99.93 123.24,99.85 123.24,99.62 123.16,99.55 122.85,99.55 122.77,99.47 122.77,99.24 122.85,99.16 123.16,99.16 123.24,99.09 123.24,98.86 123.16,98.78 122.85,98.78 122.77,98.71 122.77,97.89 135.63,85.03 135.63,79.62 135.4,79.39 v3(135.25,79.39)
  BOTTOM w0.076: v1(116.59,115.83) 116.62,115.83 116.7,115.91 116.7,117.38 116.64,117.43 116.64,118.22 116.79,118.38 116.79,119.34 U4555.R4
  BOTTOM w0.109: v3(135.25,79.39) 136.1,80.24 136.1,83.05 CN4100.215
M_A_DQ<51>: length 55.2
  L10 w0.076: v3(138.63,78.19) 138.3,78.52 138.3,85.36 126.44,97.22 126.44,109.27 122.63,113.09 121.27,113.09 117.96,116.4 117.67,117.09 117.67,117.75 117.87,118.73 117.99,119.03 v1(118.27,119.31)
  BOTTOM w0.076: v1(118.27,119.31) 117.94,119.64 U4555.P4
  BOTTOM w0.109: v3(138.63,78.19) 138.74,78.19 139.41,77.52 CN4100.228
M_A_DQ<52>: length 56.5
  L10 w0.076: v1(116.13,116.26) 116.13,115.11 119.63,111.61 120.2,111.61 122.93,108.89 122.93,107.11 122.62,106.8 122.62,106.42 122.7,106.35 122.85,106.35 122.93,106.27 122.93,106.04 122.85,105.97 122.55,105.97 122.47,105.89 122.47,105.66 122.55,105.59 122.85,105.59 122.93,105.51 122.93,105.28 122.85,105.21 122.55,105.21 122.47,105.13 122.47,104.9 122.55,104.82 122.85,104.82 122.93,104.75 122.93,104.52 122.85,104.44 122.55,104.44 122.47,104.37 122.47,104.14 122.55,104.06 122.85,104.06 122.93,103.99 122.93,103.76 122.85,103.68 122.55,103.68 122.47,103.61 122.47,103.38 122.55,103.3 122.85,103.3 122.93,103.22 122.93,103 122.85,102.92 122.55,102.92 122.47,102.84 122.47,102.61 122.55,102.54 122.85,102.54 122.93,102.46 122.93,102.23 122.85,102.16 122.55,102.16 122.47,102.08 122.47,101.85 122.55,101.78 122.85,101.78 122.93,101.7 122.93,101.47 122.85,101.4 122.55,101.4 122.47,101.32 122.47,101.09 122.55,101.01 122.85,101.01 122.93,100.94 122.93,100.71 122.85,100.63 122.55,100.63 122.47,100.56 122.47,97.79 135.22,85.05 v3(135.22,80.76)
  BOTTOM w0.076: v1(116.13,116.26) 116.13,116.85 116.48,117.2 116.48,118.33 116.55,118.39 116.55,119.75 U4555.R5
  BOTTOM w0.109: CN4100.211 135.16,80.82 135.22,80.76 v3(135.22,80.76)
M_A_DQ<53>: length 53.4
  L10 w0.076: v1(118.27,118.01) 117.95,117.62 117.89,117.44 117.89,117.29 118.11,116.59 121.26,113.44 122.72,113.44 126.83,109.33 126.83,107.62 126.91,107.54 127.21,107.54 127.28,107.47 127.28,107.24 127.21,107.16 126.91,107.16 126.83,107.09 126.83,106.86 126.91,106.78 127.21,106.78 127.28,106.71 127.28,106.48 127.21,106.4 126.91,106.4 126.83,106.33 126.83,106.1 126.91,106.02 127.21,106.02 127.28,105.94 127.28,105.72 127.21,105.64 126.91,105.64 126.83,105.56 126.83,105.33 126.91,105.26 127.21,105.26 127.28,105.18 127.28,104.95 127.21,104.88 126.91,104.88 126.83,104.8 126.83,104.57 126.91,104.5 127.21,104.5 127.28,104.42 127.28,104.19 127.21,104.12 126.91,104.12 126.83,104.04 126.83,97.35 138.92,85.27 138.92,81.89 138.73,81.71 138.73,80.98 v3(138.78,80.94)
  BOTTOM w0.076: U4555.P2 117.94,118.34 v1(118.27,118.01)
  BOTTOM w0.109: CN4100.225 138.66,81.92 138.49,81.75 138.49,81.22 v3(138.78,80.94)
M_A_DQ<54>: length 54.3
  L10 w0.076: v3(136.52,76.4) 137.53,76.4 137.74,76.62 137.74,85.13 125.87,96.99 125.87,108.9 123.42,111.36 122.31,111.36 118.92,114.75 118.09,114.75 v1(117.89,114.54)
  BOTTOM w0.076: v1(117.89,114.54) 117.89,115.54 117.37,116.05 117.37,116.71 117.09,116.99 U4555.R1
  BOTTOM w0.109: v3(136.52,76.4) 136.41,76.3 136.41,74.92 CN4100.216
M_A_DQ<55>: length 53.7
  L10 w0.076: v1(118.27,117.37) 118.27,116.87 118.38,116.6 121.25,113.73 122.83,113.73 127.64,108.91 127.64,103.82 127.57,103.74 127.19,103.74 127.11,103.67 127.11,103.44 127.19,103.36 127.48,103.36 127.55,103.29 127.55,103.06 127.48,102.98 127.19,102.98 127.11,102.91 127.11,97.47 139.2,85.38 139.2,79.92 v3(138.78,79.51)
  BOTTOM w0.076: U4555.P1 117.94,117.69 v1(118.27,117.37)
  BOTTOM w0.109: v3(138.78,79.51) 139.15,79.51 139.66,80.02 139.66,83.12 CN4100.229
M_A_DQ<56>: length 58.4
  L10 w0.076: v3(140.73,79.61) 140.27,80.07 140.27,86.18 128.74,97.71 128.74,105.04 128.81,105.12 129.18,105.12 129.25,105.2 129.25,105.43 129.18,105.5 128.81,105.5 128.74,105.58 128.74,105.81 128.81,105.88 129.18,105.88 129.25,105.96 129.25,106.19 129.18,106.26 128.81,106.26 128.74,106.34 128.74,106.57 128.81,106.64 129.18,106.64 129.25,106.72 129.25,106.95 129.18,107.03 128.81,107.03 128.74,107.1 128.74,107.33 128.81,107.41 129.18,107.41 129.25,107.48 129.25,107.71 129.18,107.79 128.81,107.79 128.74,107.86 128.74,108.09 129.2,108.55 129.2,108.97 123.09,115.08 121.99,115.08 121.05,116.01 119.66,116.01 v1(119.61,115.96)
  BOTTOM w0.076: v1(119.61,115.96) 119.61,116.56 119.35,116.82 119.35,117.1 119.16,117.29 119.16,119.19 U4555.M4
  BOTTOM w0.109: v3(140.73,79.61) 141.66,80.55 141.66,82.88 141.66,82.88 CN4100.237
M_A_DQ<57>: length 54.9
  L10 w0.076: v3(140.66,76.57) 139.68,77.55 139.68,85.58 127.59,97.67 127.59,100.78 127.75,100.93 128.02,100.93 128.1,101.01 128.1,101.22 128.02,101.3 127.68,101.3 127.61,101.38 127.61,101.61 127.7,101.7 128.03,101.7 128.11,101.78 128.11,102 128.04,102.08 127.7,102.08 127.62,102.16 127.62,102.44 128.15,102.97 128.15,109.15 122.9,114.4 121.85,114.4 121.59,114.66 v1(120.93,114.66)
  BOTTOM w0.076: v1(120.93,114.66) 120.96,114.69 120.96,115.74 119.69,117.01 119.69,117.25 119.6,117.34 U4555.M1
  BOTTOM w0.109: v3(140.66,76.57) 140.41,76.32 CN4100.232
M_A_DQ<58>: length 60.1
  L10 w0.076: v3(144.6,79.44) 144.48,79.31 144.08,79.31 143.92,79.47 143.92,80.25 142.3,81.86 142.3,87.02 131.81,97.51 131.81,102.61 131.38,103.04 131.38,103.27 131.46,103.35 131.73,103.35 131.81,103.42 131.81,103.65 131.73,103.73 131.46,103.73 131.38,103.8 131.38,104.03 131.46,104.11 131.73,104.11 131.81,104.18 131.81,104.41 131.73,104.49 131.46,104.49 131.38,104.57 131.38,104.79 131.46,104.87 131.73,104.87 131.81,104.95 131.81,105.18 131.73,105.25 131.46,105.25 131.38,105.33 131.38,105.56 131.46,105.63 131.73,105.63 131.81,105.71 131.81,105.94 131.73,106.01 131.46,106.01 131.38,106.09 131.38,106.32 131.46,106.39 131.73,106.39 131.81,106.47 131.81,106.7 131.73,106.78 131.46,106.78 131.38,106.85 131.38,107.08 131.46,107.16 131.73,107.16 131.81,107.23 131.81,107.46 131.73,107.54 131.46,107.54 131.38,107.61 131.38,107.84 131.46,107.92 131.73,107.92 131.81,107.99 131.81,108.22 131.73,108.3 131.46,108.3 131.38,108.38 131.38,110.03 123.49,117.92 122.17,117.92 v1(120.79,119.31)
  BOTTOM w0.076: U4555.L4 120.46,119.64 v1(120.79,119.31)
  BOTTOM w0.109: v3(144.6,79.44) 144.6,79.68 144.75,79.83 144.75,83.03 CN4100.249
M_A_DQ<59>: length 56.7
  L10 w0.076: v1(120.79,118.01) 121.49,118.01 121.86,117.64 123.35,117.64 131.1,109.89 131.1,102.5 131.18,102.43 131.4,102.43 131.48,102.35 131.48,102.12 131.4,102.05 131.18,102.05 131.1,101.97 131.1,101.74 131.18,101.67 131.4,101.67 131.48,101.59 131.48,101.36 131.4,101.28 131.18,101.28 131.1,101.21 131.1,100.75 131.49,100.36 131.49,97.43 142.02,86.9 142.02,81.75 143.64,80.13 143.64,78.24 143.84,78.04 v3(144.36,78.04)
  BOTTOM w0.076: U4555.L2 120.46,118.34 v1(120.79,118.01)
  BOTTOM w0.109: v3(144.36,78.04) 144.91,77.48 CN4100.250
M_A_DQ<60>: length 60.8
  L10 w0.076: v1(119.15,116.4) 119.21,116.46 121.01,116.46 122.1,115.37 123.25,115.37 129.56,109.06 129.56,104.75 129.48,104.67 129.09,104.67 129.02,104.59 129.02,104.37 129.09,104.29 129.48,104.29 129.56,104.21 129.56,103.98 129.48,103.91 129.09,103.91 129.02,103.83 129.02,103.6 129.09,103.53 129.48,103.53 129.56,103.45 129.56,103.22 129.48,103.15 129.09,103.15 129.02,103.07 129.02,102.84 129.09,102.77 129.48,102.77 129.56,102.69 129.56,102.46 129.48,102.38 129.09,102.38 129.02,102.31 129.02,102.08 129.09,102 129.48,102 129.56,101.93 129.56,101.7 129.48,101.62 129.09,101.62 129.02,101.55 129.02,101.32 129.09,101.24 129.48,101.24 129.56,101.17 129.56,100.94 129.48,100.86 129.09,100.86 129.02,100.78 129.02,100.56 129.09,100.48 129.48,100.48 129.56,100.4 129.56,100.17 129.48,100.1 129.09,100.1 129.02,100.02 129.02,99.79 129.09,99.72 129.48,99.72 129.56,99.64 129.56,99.41 129.48,99.34 129.09,99.34 129.02,99.26 129.02,99.03 129.09,98.96 129.48,98.96 129.56,98.88 129.56,98.65 129.48,98.57 129.09,98.57 129.02,98.5 129.02,98.27 129.09,98.19 129.48,98.19 129.56,98.12 129.56,97.28 140.55,86.29 140.55,81.11 v3(140.67,81)
  BOTTOM w0.076: U4555.M5 119.2,119.88 119.2,119.66 119,119.46 119,117.57 118.98,117.55 118.98,117.18 119.15,117.01 v1(119.15,116.4)
  BOTTOM w0.109: CN4100.233 140.66,81.77 140.92,81.51 140.92,81.25 v3(140.67,81)
M_A_DQ<61>: length 56.3
  L10 w0.076: v3(140.61,78.01) 139.97,78.65 139.97,86.06 127.88,98.15 127.88,98.64 127.96,98.71 128.22,98.71 128.31,98.8 128.31,99.02 128.24,99.09 127.95,99.09 127.87,99.17 127.87,99.4 127.95,99.48 128.22,99.48 128.31,99.57 128.31,99.78 128.24,99.86 127.95,99.86 127.87,99.93 127.87,100.32 128.43,100.88 128.43,109.27 122.97,114.73 121.94,114.73 121.56,115.11 120.56,115.11 120.51,115.07 v1(120.51,115.07)
  BOTTOM w0.076: v1(120.51,115.07) 120.51,115.07 120.51,115.94 119.53,116.92 119.53,117.18 119.32,117.39 119.32,118.05 U4555.M2
  BOTTOM w0.109: v3(140.61,78.01) 140.92,78.01 141.43,77.5 141.43,77.3 141.51,77.23 141.51,74.75 CN4100.236
M_A_DQ<62>: length 60.6
  L10 w0.076: v1(120.79,119.96) 122.52,118.22 123.6,118.22 132.09,109.73 132.09,104.08 132.41,103.76 132.41,103.53 132.33,103.46 132.17,103.46 132.09,103.38 132.09,103.15 132.17,103.08 132.59,103.08 132.66,103 132.66,102.77 132.59,102.69 132.17,102.69 132.09,102.62 132.09,102.39 132.17,102.31 132.59,102.31 132.66,102.24 132.66,102.01 132.59,101.93 132.17,101.93 132.09,101.86 132.09,101.63 132.17,101.55 132.59,101.55 132.66,101.48 132.66,101.25 132.59,101.17 132.17,101.17 132.09,101.09 132.09,100.87 132.17,100.79 132.59,100.79 132.66,100.71 132.66,100.48 132.59,100.41 132.17,100.41 132.09,100.33 132.09,100.1 132.17,100.03 132.59,100.03 132.66,99.95 132.66,99.72 132.59,99.65 132.17,99.65 132.09,99.57 132.09,99.34 132.17,99.27 132.59,99.27 132.66,99.19 132.66,98.96 132.59,98.88 132.17,98.88 132.09,98.81 132.09,98.58 132.17,98.5 132.59,98.5 132.66,98.43 132.66,98.2 132.59,98.12 132.17,98.12 132.09,98.05 132.09,97.82 132.17,97.74 132.59,97.74 132.66,97.67 132.66,97.05 142.58,87.13 142.58,81.98 143.85,80.71 v3(144.33,80.71)
  BOTTOM w0.076: v1(120.79,119.96) 120.46,120.29 U4555.L5
  BOTTOM w0.109: v3(144.33,80.71) 143.66,81.38 CN4100.245
M_A_DQ<63>: length 56.8
  L10 w0.076: v1(120.84,117.37) 120.88,117.4 123.17,117.4 130.82,109.75 130.82,100.39 130.9,100.32 131.14,100.32 131.22,100.24 131.22,100.01 131.14,99.94 130.9,99.94 130.82,99.86 130.82,99.63 130.9,99.55 131.14,99.55 131.22,99.48 131.22,99.25 131.14,99.17 130.9,99.17 130.82,99.1 130.82,98.87 130.9,98.79 131.14,98.79 131.22,98.72 131.22,98.49 131.14,98.41 130.9,98.41 130.82,98.34 130.82,97.71 141.75,86.79 141.75,81.63 143.36,80.02 143.36,77.26 143.92,76.71 v3(144.4,76.71)
  BOTTOM w0.076: U4555.L1 120.53,117.69 v1(120.84,117.37)
  BOTTOM w0.109: v3(144.4,76.71) 143.91,76.22 CN4100.246
M_A_DQS0_DN: length 53.5
  L10 w0.076: v1(84.97,119.32) 84.9,119.24 84.37,119.24 84.29,119.17 84.07,119.17 83.26,118.36 83.16,118.26 83.12,118.26 83.11,118.24
  L10 w0.081: 83.11,118.24 82.63,117.77 81.64,117.77 80.03,116.16 80.03,91.69 79.62,91.27 79.62,83.89 82.27,81.24 82.27,80 82.12,79.85 81.82,79.85 81.73,79.93 v3(81.73,80.38)
  BOTTOM w0.076: v1(84.97,119.32) 84.85,119.45 84.85,119.66 85.22,120.03 85.98,120.03 85.99,120.03 86.46,120.03 86.6,120.17 87.07,120.17 87.17,120.07 87.17,119.94 87.24,119.87 87.24,119.72 87.17,119.65 86.96,119.65 86.83,119.77 U4555.BR5
  BOTTOM w0.099: v3(81.73,80.38) 81.73,79.94 81.83,79.84 82.42,79.84 83.28,80.7 83.28,81.85 83.16,81.96 CN4100.11
M_A_DQS0_DP: length 53.6
  L10 w0.076: 83.33,118.19 83.33,118.19 84.14,119 84.39,119 v1(84.53,118.86)
  L10 w0.081: 83.33,118.19 83.33,118.15 82.73,117.55 81.73,117.55 80.26,116.07 80.26,91.59 79.84,91.18 79.84,83.98 82.5,81.33 82.5,79.91 82.21,79.62 81.8,79.62 81.73,79.55 v3(81.73,79.11)
  BOTTOM w0.076: v1(84.53,118.86) 84.59,118.93 84.59,119.48 84.68,119.57 84.68,119.72 85.16,120.2 86.05,120.2 86.06,120.19 86.39,120.19 86.53,120.34 87.19,120.34 U4555.BP5
  BOTTOM w0.099: v3(81.73,79.11) 81.73,79.54 81.83,79.64 82.5,79.64 83.48,80.62 83.48,81.78 83.66,81.96 CN4100.13
M_A_DQS1_DN: length 51.6
  L10 w0.076: 84.02,113.94 84.04,113.95 84.08,113.95 85.19,115.07 85.74,115.07 85.81,115 86.14,115 86.18,115.04 v1(86.19,115.04)
  L10 w0.081: 84.02,113.94 83.87,113.79 83.87,95.1 84.23,94.74 84.23,85.21 84.69,84.75 84.69,83.69 86.23,82.15 86.23,78.86 86.44,78.65 86.8,78.65 v3(87.06,78.39)
  BOTTOM w0.076: v1(86.19,115.04) 86.19,115.02 86.42,114.79 86.57,114.79 87.06,114.99 88.53,115.97 90.09,117.53 90.09,117.82 89.76,118.15 89.76,118.76 89.53,118.99 U4555.BL3
  BOTTOM w0.099: v3(87.06,78.39) 87.32,78.66 87.49,78.66 87.78,78.36 87.78,77.17 88.57,76.38 88.57,76.09 88.41,75.94 CN4100.32
M_A_DQS1_DP: length 51.6
  L10 w0.076: 84.18,113.78 84.19,113.8 84.19,113.84 85.26,114.9 85.67,114.9 85.75,114.82 v1(85.75,114.57)
  L10 w0.081: v1(87.05,79.12) 86.8,78.87 86.54,78.87 86.45,78.95 86.45,82.24 84.91,83.78 84.91,84.85 84.46,85.3 84.46,94.83 84.1,95.19 84.1,113.7 84.18,113.78
  BOTTOM w0.076: v1(85.75,114.57) 85.8,114.62 86.61,114.62 87.14,114.85 88.63,115.84 90.25,117.46 90.25,117.89 89.92,118.21 89.92,118.69 U4555.BK3
  BOTTOM w0.099: v1(87.05,79.12) 87.31,78.86 87.57,78.86 87.98,78.45 87.98,77.25 88.77,76.46 88.77,76.08 88.91,75.94 CN4100.34
M_A_DQS2_DN: length 51.1
  L10 w0.076: 87.7,112.22 87.71,112.23 87.71,112.27 87.82,112.38 87.82,112.98 88.23,113.4 88.23,113.69 v1(88.11,113.82)
  L10 w0.081: v3(92.14,79.42) 91.88,79.16 91.67,79.16 91.51,79.33 91.51,83.22 88.9,85.83 88.9,98.64 87.57,99.97 87.57,112.09 87.7,112.22
  BOTTOM w0.076: v1(88.11,113.82) 88.11,113.82 88.2,113.9 88.38,113.9 88.51,113.78 88.51,113.6 88.59,113.52 88.69,113.52 89.02,113.61 89.9,114.14 91.29,115.28 92.43,116.42 92.51,116.62 92.51,117.12 92.46,117.24 92.23,117.47 92.23,118.77 92.33,118.87 92.33,119.01 92.24,119.1 92.05,119.1 U4555.BG3
  BOTTOM w0.099: CN4100.53 93.66,81.93 93.79,81.8 93.79,80.5 92.48,79.18 92.38,79.18 v3(92.14,79.42)
M_A_DQS2_DP: length 51.2
  L10 w0.076: v1(87.65,113.36) 87.65,112.45 87.59,112.38 87.54,112.38 87.54,112.37
  L10 w0.081: 87.54,112.37 87.35,112.18 87.35,99.88 88.67,98.55 88.67,85.74 91.29,83.12 91.29,79.23 91.58,78.94 91.9,78.94 v1(92.14,78.7)
  BOTTOM w0.076: U4555.BF3 92.39,118.7 92.39,117.54 92.6,117.33 92.67,117.15 92.67,116.58 92.57,116.33 91.4,115.16 89.99,114 89.08,113.46 88.72,113.36 v1(87.65,113.36)
  BOTTOM w0.099: v1(92.14,78.7) 92.41,78.98 92.56,78.98 93.99,80.41 93.99,81.81 94.16,81.98 CN4100.55
M_A_DQS3_DN: length 51.3
  L10 w0.076: 92.78,112.92 92.79,112.93 92.79,112.97 93.18,113.36 93.18,113.9 93.37,114.09 93.37,114.64 v1(93.38,114.65)
  L10 w0.081: 92.78,112.92 92.27,112.4 92.27,87.25 97.04,82.47 97.04,78.41 97.22,78.24 97.74,78.24 v3(98.01,78.51)
  BOTTOM w0.076: v1(93.38,114.65) 93.38,114.54 93.56,114.36 93.9,114.36 95.06,115.53 95.06,117.08 94.74,117.4 94.74,118.87 94.63,118.99 U4555.BD3
  BOTTOM w0.099: v3(98.01,78.51) 97.72,78.22 97.59,78.22 97.37,78.01 97.37,76.99 98.16,76.2 98.87,76.2 99.01,76.07 99.01,75.88 98.91,75.78 CN4100.74
M_A_DQS3_DP: length 51.3
  L10 w0.076: v1(92.92,114.19) 93.02,114.1 93.02,113.43 92.67,113.09 92.63,113.09 92.62,113.07
  L10 w0.081: 92.62,113.07 92.04,112.5 92.04,87.15 96.82,82.38 96.82,78.32 97.13,78.01 97.85,78.01 v1(98.01,77.85)
  BOTTOM w0.076: v1(92.92,114.19) 93.97,114.19 95.23,115.46 95.23,117.14 94.91,117.47 94.91,118.7 U4555.BC3
  BOTTOM w0.099: v1(98.01,77.85) 97.84,78.02 97.67,78.02 97.57,77.92 97.57,77.07 98.24,76.4 98.96,76.4 99.21,76.15 99.21,75.9 99.41,75.69 CN4100.76
M_A_DQS4_DN: length 51.3
  L10 w0.076: v1(112.52,112.62) 112.52,112.67 112.69,112.85 112.89,112.85 113.38,112.35 113.38,111.65 114.57,110.46 114.57,110.42 114.59,110.41
  L10 w0.081: v1(127.56,80.18) 127.34,80.4 126.97,80.4 126.49,80.88 126.49,82.34 126.7,82.55 127.01,82.55 127.1,82.63 127.1,82.96 127.01,83.04 126.7,83.04 126.49,83.25 126.49,83.76 126.7,83.98 127.01,83.98 127.1,84.06 127.1,84.38 127.01,84.46 126.7,84.46 126.49,84.68 126.49,85.93 115.77,96.65 115.77,109.23 114.59,110.41
  BOTTOM w0.076: U4555.AA3 112.73,118.99 112.51,118.77 112.51,117.51 112.68,117.34 112.68,113.11 112.52,112.95 v1(112.52,112.62)
  BOTTOM w0.099: CN4100.177 126.66,81.96 126.81,81.81 126.81,80.66 127.06,80.41 127.33,80.41 v1(127.56,80.18)
M_A_DQS4_DP: length 51.2
  L10 w0.076: v1(112.05,113.07) 112.11,113.01 112.96,113.01 113.55,112.42 113.55,111.72 114.69,110.58 114.73,110.58 114.75,110.57
  L10 w0.081: 114.74,110.57 115.99,109.32 115.99,96.74 126.71,86.02 126.71,84.77 126.79,84.69 127.11,84.69 127.32,84.48 127.32,83.96 127.11,83.75 126.79,83.75 126.71,83.67 126.71,83.35 126.79,83.26 127.11,83.26 127.32,83.05 127.32,82.54 127.11,82.33 126.79,82.33 126.71,82.25 126.71,80.97 127.06,80.62 127.34,80.62 v3(127.56,80.84)
  BOTTOM w0.076: U4555.AB3 112.17,118.99 112.34,118.81 112.34,117.44 112.51,117.27 112.51,113.18 112.41,113.07 112.06,113.07 v1(112.05,113.07)
  BOTTOM w0.099: v3(127.56,80.84) 127.33,80.61 127.14,80.61 127.01,80.74 127.01,81.81 127.16,81.96 CN4100.179
M_A_DQS5_DN: length 54.2
  L10 w0.076: v1(115.94,112.79) 115.94,113.13 116.03,113.23 116.24,113.23 119.86,109.61 119.86,109.12 119.83,109.09 119.83,109.07
  L10 w0.081: v1(132.41,77.72) 132.41,77.78 132.14,78.05 131.92,78.05 131.68,78.29 131.68,85.72 120.32,97.07 120.32,107.2 119.83,107.7 119.83,109.07
  BOTTOM w0.076: v1(115.94,112.79) 115.94,113.15 116.03,113.25 116.03,115.61 115.03,116.6 115.03,117.56 115.02,117.57 115.02,118.7 U4555.U3
  BOTTOM w0.099: CN4100.198 131.91,75.81 132.21,76.11 132.21,76.3 133,77.09 133,77.78 132.8,77.98 132.67,77.98 v1(132.41,77.72)
M_A_DQS5_DP: length 54.2
  L10 w0.076: 120.06,109.07 120.06,109.09 120.03,109.12 120.03,109.68 116.31,113.39 115.96,113.39 115.81,113.24 v1(115.47,113.24)
  L10 w0.081: 120.06,109.07 120.06,107.79 120.55,107.3 120.55,97.17 131.9,85.81 131.9,78.38 132.01,78.27 132.31,78.27 v3(132.41,78.38)
  BOTTOM w0.076: U4555.V3 114.77,118.99 114.86,118.9 114.86,117.5 114.87,117.49 114.87,116.53 115.86,115.54 115.86,113.32 115.79,113.24 v1(115.47,113.24)
  BOTTOM w0.099: CN4100.200 132.41,76.22 133.2,77 133.2,77.87 132.88,78.18 132.61,78.18 v3(132.41,78.38)
M_A_DQS6_DN: length 55.3
  L10 w0.076: 122.92,110.58 122.9,110.58 122.87,110.61 122.47,110.61 119.48,113.6 119.29,113.6 119.21,113.53 119.21,113.21 v1(119.29,113.13)
  L10 w0.081: 122.92,110.58 123.19,110.58 125.11,108.66 125.11,96.76 137.03,84.83 137.03,79.4 136.92,79.29 136.67,79.29 136.46,79.5 v1(136.46,79.55)
  BOTTOM w0.076: U4555.P3 117.82,119.05 117.71,119.17 117.48,119.17 117.42,119.1 117.42,118.89 117.54,118.77 117.54,117.24 119.21,115.57 119.21,113.21 v1(119.29,113.13)
  BOTTOM w0.099: v1(136.46,79.55) 136.46,79.55 136.68,79.32 137.08,79.32 137.31,79.55 137.31,81.81 137.16,81.96 CN4100.219
M_A_DQS6_DP: length 55.3
  L10 w0.076: 122.92,110.8 122.9,110.8 122.87,110.77 122.54,110.77 119.55,113.77 119.01,113.77 v1(118.83,113.59)
  L10 w0.081: 122.92,110.8 123.28,110.8 125.33,108.75 125.33,96.85 137.25,84.93 137.25,79.3 137.01,79.06 136.63,79.06 v3(136.46,78.89)
  BOTTOM w0.076: U4555.R3 117.37,118.7 117.37,117.18 119.05,115.5 119.05,113.8 v1(118.83,113.59)
  BOTTOM w0.099: v3(136.46,78.89) 136.45,78.89 136.68,79.12 137.17,79.12 137.51,79.47 137.51,81.81 137.66,81.96 CN4100.221
M_A_DQS7_DN: length 57.9
  L10 w0.081: v3(141.94,77.65) 141.94,78.02 142.02,78.1 142.47,78.1 142.81,78.45 142.81,79.85 141.26,81.41 141.26,86.59 130.32,97.52 130.32,109.31 122.93,116.7 122.22,116.7 122.02,116.51 v1(121.73,116.51)
  BOTTOM w0.076: U4555.L3 120.05,118.7 120.05,117.39 121.29,116.15 121.54,116.15 121.73,116.34 v1(121.73,116.51)
  BOTTOM w0.099: v3(141.94,77.65) 141.94,78.08 142.04,78.18 142.38,78.18 142.56,78 142.56,75.96 142.41,75.81 CN4100.240
M_A_DQS7_DP: length 58
  L10 w0.081: v1(122.18,116.06) 122.18,116.35 122.31,116.48 122.84,116.48 130.1,109.22 130.1,97.43 141.04,86.49 141.04,81.31 142.59,79.76 142.59,78.54 142.37,78.33 142.02,78.33 141.94,78.41 v3(141.94,78.92)
  BOTTOM w0.076: U4555.M3 119.89,118.7 119.89,117.32 121.22,115.98 121.61,115.98 121.68,116.06 v1(122.18,116.06)
  BOTTOM w0.099: v3(141.94,78.92) 141.94,78.48 142.04,78.38 142.47,78.38 142.76,78.09 142.76,75.96 142.91,75.81 CN4100.242
M_A_PARITY: length 49.9
  L10 w0.109: v3(118.15,79.91) 116.97,81.09 116.97,83.5 104.85,95.62 104.85,104.97 106,106.12 106,112.55 v1(106.14,112.69)
  BOTTOM w0.076: v1(106.14,112.69) 107.04,113.6 107.04,114.66 107.58,115.19 107.58,117.41 107.48,117.51 107.48,118.7 U4555.AG3
  BOTTOM w0.17: CN4100.143 116.16,81.9 v3(118.15,79.91)
M_A_RAS#: length 52.7
  L10 w0.076: 107.68,109.36 107.68,114.94 107.23,115.39 107.23,119.04 107.48,119.29 v1(108.21,119.29)
  L10 w0.109: 107.68,109.36 108.25,108.79 108.25,96.1 120.52,83.83 120.52,80.86 120.24,80.57 120.24,77.67 v3(120.24,77.64)
  BOTTOM w0.076: U4555.AH4 107.32,119.34 108.15,119.34 v1(108.21,119.29)
  BOTTOM w0.17: CN4100.152 120.41,75.9 120.68,76.16 120.68,77.2 v3(120.24,77.64)
M_A_WE#: length 49.3
  L10 w0.076: 107.93,109.65 107.93,115.08 107.77,115.24 107.77,117.63 108.7,118.57 108.7,119.44 v1(108.21,119.94)
  L10 w0.109: v3(120.75,80.33) 120.94,80.51 120.94,84 108.67,96.26 108.67,108.91 107.93,109.65
  BOTTOM w0.076: U4555.AG4 107.91,119.64 v1(108.21,119.94)
  BOTTOM w0.17: CN4100.151 120.16,81.8 120.75,81.22 v3(120.75,80.33)
M_B_A_0: length 68.5
  L3 w0.076: v1(106.32,123.22) 106.68,122.86 106.68,121.45 106.75,121.39 106.75,117.89 107.04,117.59 107.04,109.93 107.22,109.76
  L3 w0.109: v3(121.41,63.86) 121.41,70 120.11,71.3 120.11,74.57 117.71,76.97 117.71,83.69 116.23,85.18 116.23,85.96 116.23,86.3 110.69,91.83 110.57,92.12 110.57,105.02 108.64,106.95 108.64,108.34 107.22,109.76
  BOTTOM w0.076: v1(106.32,123.22) 106,122.9 U4555.AJ9
  BOTTOM w0.17: v3(121.41,63.86) CN4125.144
